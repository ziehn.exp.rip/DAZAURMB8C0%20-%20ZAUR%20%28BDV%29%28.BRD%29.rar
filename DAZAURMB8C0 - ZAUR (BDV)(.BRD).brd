# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_AZ_CODEC_SYNC: length 119.2
  TOP w0.102: v2(109.08,45.88) 109.08,46.21 108.65,46.65 108.65,47.74 109.03,48.12 109.66,48.12 110.09,48.55 110.09,51.88 111.7,53.48 114.33,53.48 115.39,52.41 121.12,52.41 v1(121.37,52.67)
  IN1 w0.089: v1(121.37,52.67) 121.5,52.67 124.51,49.65 124.51,44.91 131.53,37.88 131.53,37.32 132.8,36.05 132.8,35.67 134.24,34.24 136.55,34.24 137.27,33.51 137.27,32.27 137.81,31.74 138.95,31.74 140.73,29.96 140.73,27.04 141.37,26.39 143.3,26.39 143.92,27.01 145.49,27.01 145.92,27.44 153.4,27.44 154.22,28.27 156.95,28.27 157.01,28.21 157.52,28.21 157.75,28.43 160.15,28.43 160.71,27.88 164.81,27.88 165.86,28.92 173.2,28.92 173.6,29.32 184.77,29.32 186.46,27.63 189.55,27.63 191.03,29.11 193,29.11 193.34,29.45 195.51,29.45 196,28.97 197.65,28.97 198.05,28.56 v1(198.74,28.56)
  BOTTOM w0.102: v2(109.08,45.88) 109.03,45.83 R590.1 ; v1(198.74,28.56) 198.94,28.56 199.45,28.06 U35.10
PCH_BLON_C: length 7
  TOP w0.102: R71.2 55.1,107.72 56,106.82 R73.2 56.43,106.54 56.58,106.39 56.58,106.13 56.22,105.78 R74.2 56.22,105.24 56.7,104.76 R79.1 55.65,104.64 v1(55.36,104.94) 54.93,104.51 Q3.5
PCH_BLON_EC: length 214.3
  TOP w0.102: U15.88 182.39,24.96 v1(182.43,25.01) ; R71.1 54.65,108.3 v1(55.05,108.7)
  IN3 w0.089: v1(60.06,117.46) 60.55,117.95 61.04,117.95 61.11,118.02 63.19,118.02 64.13,117.08 64.32,117.08 65.09,116.32 65.59,116.32 68.77,113.14 69.91,113.14 71.44,111.62 71.44,110.46 72.28,109.61 74.33,109.61 75.25,108.7 75.25,107.68 75.54,107.39 75.54,105.43 75.89,105.08 76.07,105.08 76.34,104.81 76.34,103.78 76.83,103.29 76.83,98.66 77.31,98.18 82.23,98.18 83.3,97.12 92.39,97.12 93.81,98.54 98.99,98.54 101.03,96.51 101.03,95.49 103.21,93.31 105.88,93.31 107.2,91.98 107.2,90.5 109.71,87.99 109.71,82.56 111.03,81.24 111.8,81.24 115.96,77.08 117.28,77.08 117.64,76.72 117.64,74.03 118.54,73.13 124.89,73.13 125.82,72.2 125.82,67.34 125.54,67.06 125.54,64.2 124.1,62.76 124.1,46.76 125.16,45.71 125.16,42.02 126.43,40.75 128.65,40.75 130.53,38.87 136.69,38.87 139.13,36.44 141.52,36.44 142.44,35.52 142.44,33.23 141.73,32.52 141.73,30.11 144.65,27.19 152.89,27.19 153.47,27.76 157.71,27.76 159.73,29.78 170.29,29.78 171.13,28.94 171.13,28.31 172.7,26.74 175.17,26.74 175.55,27.12 181.16,27.12 182.43,25.85 v1(182.43,25.01)
  BOTTOM w0.102: v1(55.05,108.7) 55.05,109.21 59.09,113.24 59.09,116.5 v1(60.06,117.46)
PCH_DISP_ON: length 44.2
  TOP w0.102: R128.2 95.98,82.98 96.22,82.74 Q9.3 94.32,82.28 93.91,81.88 89.52,81.88 88.63,82.76 87.05,82.76 86.8,83.01 86.8,83.3 81.47,88.63 75.16,88.63 68.13,95.66 68.13,95.92 v1(68.01,96.05)
  BOTTOM w0.102: R529.1 67.72,89.49 68.01,89.78 68.01,91.93 68.16,92.09 68.16,95.9 v1(68.01,96.05)
PCH_DPST_PWM: length 65.4
  TOP w0.102: v1(65.47,102.58) 66.48,101.56 66.48,99.31 69.48,96.31 69.48,95.68 71.33,93.84 72.76,93.84 73.59,93 73.59,92.44 76.44,89.6 81.91,89.6 86.23,85.28 91.33,85.28 92.17,86.12 93.31,86.12 93.92,85.51 96.35,85.51 97.24,84.62 101.05,84.62 102.15,83.52 R133.2 103.21,83.52 103.44,83.3 v1(103.63,83.3) 103.82,83.3 104,83.48 104.77,83.48 105.85,82.39 Q10.3 ; v1(57.08,108.22) 57.36,107.94 R69.1
  IN2 w0.089: v1(65.47,102.58) 65.47,103.71 63.92,105.26 63.92,106.47 62.72,107.67 62.72,108.01 61.91,108.83 57.69,108.83 v1(57.08,108.22)
PCH_LVDS_BLON: length 70.8
  TOP w0.102: R74.1 56.68,105.42 57.14,104.96 57.14,103.82 57.68,103.28 57.68,102.59 58.48,101.79 58.48,101.46 58.61,101.33 v1(58.61,99.17) 59.04,98.74 60.56,98.74 60.64,98.67 65.78,98.67 67.5,96.94 67.5,95.74 67.91,95.34 68.11,95.34 75.07,88.38 81.34,88.38 86.55,83.17 86.55,82.94 86.96,82.54 88.53,82.54 89.17,81.9 89.17,80.55 89.29,80.43 89.77,80.43 90.77,81.42 96.61,81.42 97.45,80.58 99.29,80.58 99.45,80.42 100.92,80.42 101.33,80 101.33,79.41 101.13,79.21 101.13,78.32 101.26,78.19 102.26,78.19 104.53,75.93 106.11,75.93 106.71,75.33 R170.1 107,74.92 106.56,74.48 Q13.3
PCH_SUSPWRDNACK: length 1.6
  TOP w0.102: U15.15 164.62,22.56 TP35.1
PCIE_CLKREQ_LAN#: length 95.6
  TOP w0.102: v1(103.11,40.88) 103.36,41.13 104.07,41.13 104.91,40.3 R224.1 ; R99.1 58.98,97.6 59.37,97.21 Q5.3 v1(64.7,95.74) 67.12,93.33 68.92,93.33 71.56,90.69 v1(71.56,87.49)
  IN1 w0.089: v2(95.75,47.54) 95.39,47.91 95.39,49.31 94.11,50.6 94.11,52.37 93.41,53.07 92.9,53.07 92.52,53.45 92.52,56.37 93.28,57.14 93.28,57.9 94.17,58.79 94.17,65.26 93.53,65.9 90.87,65.9 90.49,66.28 90.49,66.41 90.1,66.79 86.42,66.79 85.66,67.55 84.64,67.55 84.39,67.8 84.39,68.31 84.26,68.44 83.88,68.44 83.27,69.05 82.76,69.05 82.59,69.23 82.59,72.86 82.87,73.14 82.87,77.58 81.72,78.73 81.72,84.31 79.94,86.09 72.96,86.09 v1(71.56,87.49)
  IN2 w0.089: v1(103.11,40.88) 103.06,40.88 102.17,41.77 98.61,41.77 96.48,43.9 96.48,45.81 96.07,46.21 96.07,47.22 v2(95.75,47.54)
  BOTTOM w0.102: U30.AN11 v2(95.75,47.54)
PCIE_CLKREQ_SSD#: length 100.4
  TOP w0.102: v1(50.86,26.94) 50.63,26.94 49.51,25.82 49.49,25.79 49.49,25.76 49.49,22.69 48.47,21.67 48.07,21.67 47.92,21.83 47.03,21.83 46.49,22.36 42.03,22.36 41.1,21.43 41.1,16.99 40.47,16.36 35.99,16.36 33.21,13.58 31.68,13.58 29.65,11.54 29.65,7.35 29.89,7.11 Q28.1 27.68,6.52 27.11,5.96 R433.1 ; R241.1 92.57,33.87 v2(91.91,34.53)
  IN1 w0.089: v1(50.86,26.94) 51.09,27.16 52.54,27.16 52.77,26.94 54.55,26.94 55.92,28.31 58.1,28.31 58.51,28.71 76.49,28.71 77.28,27.93 79.82,27.93 81.6,29.7 84.42,29.7 86.14,31.43 88.53,31.43 91.37,34.28 91.65,34.28 v2(91.91,34.53) 91.12,35.32 91.12,37.76 91.27,37.91 91.27,39.25 91.48,39.46 91.48,44.53 v2(92.13,45.19)
  BOTTOM w0.102: U30.AT14 92.51,45.56 v2(92.13,45.19)
PCIE_CLKREQ_WLAN#: length 109.7
  TOP w0.102: R227.1 105.04,39.53 104.02,40.55 103.44,40.55 103.34,40.45 102.73,40.45 v1(102.49,40.69)
  IN1 w0.089: v1(123.76,37.07) 123.51,36.82 123.51,34.28 126.05,31.74 126.05,30.59 126.43,30.21 129.11,30.21 132.18,27.14 133.92,27.14 135.1,25.96 135.83,25.96 139.08,22.71 145.5,22.71 146.09,23.3 157.21,23.3 157.34,23.18 165.72,23.18 166.51,22.39 167.52,22.39 167.6,22.31 172.38,22.31 172.53,22.47 173.72,22.47 v1(174.23,21.96)
  IN2 w0.089: v1(123.76,37.07) 121.98,37.07 121.22,37.83 116.27,37.83 113.85,40.25 110.17,40.25 108.37,42.05 107.02,42.05 105.85,40.88 105.85,40.27 104.43,38.85 103.31,38.85 102.68,39.48 102.68,40.58 102.56,40.69 v1(102.49,40.69) 101.85,40.69 101.28,41.26 98.45,41.26 96.07,43.64 96.07,45.66 95.67,46.06 95.67,46.87 95.38,47.16 95.38,47.87 95.29,47.96 94.39,47.96 v2(93.98,48.36)
  BOTTOM w0.102: v2(93.98,48.36) 93.88,48.36 U30.AN13 ; Q44.3 178.81,22.14 178.47,21.8 R698.2 177.35,22.31 175.3,22.31 174.94,21.96 v1(174.23,21.96)
PCIE_LOM_WAKE#: length 145.2
  TOP w0.102: v1(44.13,101.59) 44.26,101.46 44.26,100.32 45.27,99.3 49.08,99.3 52.21,102.42 52.21,105.07 52,105.27 49.16,105.27 48.98,105.45 47.38,105.45 47.23,105.6 U2.21
  IN3 w0.089: v2(98.92,54.52) 98.92,54.77 99.25,55.1 101.53,55.1 101.66,55.23 101.66,58.91 102.03,59.28 102.54,59.28 102.92,59.66 v2(102.92,59.79) ; v1(110.93,61.84) 110.55,61.84 109.99,62.39 109.99,63.92 109.28,64.63 109.13,64.63 108.46,65.3 108.46,68.82 104.33,72.95 104.33,74.79 103.31,75.81 103.31,78.98 102.04,80.25 102.04,83.24 97.37,87.91 96.32,87.91 95.62,88.61 93.03,88.61 91.59,90.04 90.57,90.04 89.24,91.38 86.35,91.38 84.44,93.28 76.9,93.28 70.42,99.76 70.42,101.97 68.64,103.75 68.64,105.27 68.13,105.78 66.38,105.78 61.56,110.6 58.48,110.6 57.72,111.37 48.45,111.37 46.9,109.82 46.42,109.82 43.22,106.61 43.22,104.15 43.75,103.62 43.75,102.09 44.13,101.71 v1(44.13,101.59)
  BOTTOM w0.102: v2(98.92,54.52) 98.51,54.93 U30.AE7 ; v1(110.93,61.84) 110.93,61.2 110.17,60.44 109.92,60.44 109.38,60.97 R572.1 108.9,60.67 109.1,60.46 109.1,59.57 108.82,59.3 104.44,59.3 103.95,59.79 v2(102.92,59.79)
PCIE_REQ_LAN#_R: length 26.2
  TOP w0.102: U2.12 44.44,102.53 43.62,101.71 43.62,101.46 43.88,101.21 43.88,100.7 44,100.57 44,100.19 45.15,99.05 50.86,99.05 v1(52.77,97.14) ; Q5.1 61.28,96.79 61.28,97.91 R100.1 60.9,98.03 60.77,98.16 59.89,98.16 R99.2 59.28,98.51 58.71,98.51 58.23,98.03 58.23,97.52 v1(57.97,97.27)
  IN3 w0.089: v1(57.97,97.27) 56.7,98.54 53.66,98.54 52.77,97.65 v1(52.77,97.14)
PCIE_RST1#: length 18.8
  TOP w0.102: v1(96.33,31.3) 96.48,31.45 R272.1
  IN2 w0.089: v1(96.33,31.3) 95.64,31.99 94.17,31.99 93.28,32.88 93.28,36.82 93.33,36.87 93.33,37.76 94.04,38.47 94.04,39.36 93.58,39.81 93.58,45.55 v2(93.98,45.95)
  BOTTOM w0.102: v2(93.98,45.95) 93.62,45.59 U30.AT13
PCIE_RST#: length 410
  TOP w0.102: v1(47.84,104.63) 47.68,104.8 U2.19 ; U3.1 91.61,94.32 C138.2 91.26,93.14 v1(91.25,93.13) ; R747.1 198.24,16.78 v1(198.72,17.26) 198.94,17.49 D16.1 ; v1(27.7,31.48) 27.7,28.36 27.93,28.13 27.93,25.94 27.04,25.06 27.04,22.97 26.22,22.15 26.22,20.05 25.08,18.9 24.83,18.9 24.52,18.59 24.52,18.14 25.97,16.69 25.97,13.58 24.7,12.31 24.7,11.16 23.96,10.43 22.76,10.43 22,9.66 20.59,9.66 19.65,8.72 17.87,8.72 17.74,8.59 R424.2
  IN1 w0.089: v1(27.7,31.48) 27.49,31.69 27.49,32.98 25.69,34.78 25.69,64.91 24.32,66.28 24.32,74.03 23.05,75.3 23.05,80.76 22.29,81.52 22.29,82.66 21.65,83.3 21.65,85.97 20.6,87.02 20.6,94.3 24.58,98.28 28.76,98.28 29.02,98.03 44.03,98.03 44.64,98.64 44.64,99.94 44.38,100.19 44.38,100.57 44.99,101.18 44.99,102.17 45.22,102.4 46.47,102.4 47.84,103.77 v1(47.84,104.63) ; v1(114.36,20.18) 111.69,20.18 107.68,24.19 107.68,28.26 107.12,28.82 107.12,29.45 105.98,30.59 105.98,31.23 105.7,31.51 104.94,31.51 104.2,32.24 104.2,33.26 103.43,34.03 v1(103.43,34.05)
  IN2 w0.089: v1(27.7,31.48) 27.62,31.41 27.62,30.47 27.79,30.3 27.79,27.91 26.83,26.96 26.83,25.72 26.96,25.59 35.26,25.59 37.55,23.3 40.82,23.3 43.69,26.17 48.74,26.17 50.44,24.47 62.9,24.47 62.96,24.54 68.97,24.54 69.52,25.08 72.81,25.08 73.68,25.94 86.22,25.94 86.98,26.71 94.47,26.71 96.43,24.75 v1(96.96,24.75) ; v1(198.72,17.26) 198.21,16.75 197.32,16.75 193.79,20.28 191.95,20.28 190.52,21.71 190.52,23.27 189.14,24.65 185.63,24.65 185.23,24.24 184.59,24.24 184.42,24.42 181.75,24.42 180.82,25.35 178.15,25.35 177.49,24.69 173.13,24.69 172.18,23.74 169.59,23.74 169.13,24.19 166,24.19 165.32,23.51 162.8,23.51 162.26,22.97 157.32,22.97 156.16,24.13 146.02,24.13 144.73,22.85 142.36,22.85 140.92,21.41 133.37,21.41 132.27,20.31 128.71,20.31 128.59,20.43 124.01,20.43 123.76,20.18 120.56,20.18 119.54,19.16 115.89,19.16 115.12,19.93 114.62,19.93 v1(114.36,20.18) ; v1(47.84,104.63) 47.84,104.76 48.7,105.62 48.7,106.41 50.48,108.19 50.48,110.11 52.03,111.66 53.2,111.66 53.94,112.41 59.98,112.41 62.93,109.46 62.93,107.74 64.11,106.55 64.11,105.34 65.9,103.55 65.9,102 67.12,100.78 67.12,99.6 74.75,91.97 80.87,91.97 82.31,90.54 86.04,90.54 88.2,92.7 90.82,92.7 v1(91.25,93.13)
  IN3 w0.089: v1(103.43,34.05) 104.2,33.28 104.2,32.5 103.19,31.48 103.19,29.07 102.22,28.1 102.22,27.37 99.6,24.75 v1(96.96,24.75)
  BOTTOM w0.102: v1(103.43,34.05) 103.66,34.28 C630.1 103.66,34.89 103.14,35.41 R628.2
PCIE_RST#_R: length 15.4
  TOP w0.102: v2(103.82,36.71) 103.44,36.71 v1(103.08,36.36) 102.3,37.15 102.3,38.98 100.14,41.13 99.63,41.13 98.59,42.18 98.59,43.52 98.74,43.67 98.74,44.56 99.62,45.44 99.62,46.35 v2(99.5,46.47)
  BOTTOM w0.102: R628.1 103.59,36.07 103.82,36.3 v2(103.82,36.71) ; v2(99.5,46.47) 99.5,46.58 99.21,46.87 U30.AP6
PCIE_RXN9_LAN: length 85.2
  TOP w0.102: C90.2 48.55,103.65 48.59,103.61 48.87,103.61 49.66,102.82 50.06,102.82 v1(50.48,103.24)
  IN3 w0.089: v2(98.06,68.43) 98.17,68.54 98.41,68.54 98.49,68.62 98.49,68.75 98.38,68.87 97.8,68.87 97.38,69.29 97.38,71.43 98.53,72.58 99.55,72.58 99.93,72.97 99.93,77.12 97.65,79.4 97.65,83.53 96.18,85 95.13,85 94.45,85.69 91.35,85.69 90.26,86.78 89.65,86.78 87.98,88.44 84.17,88.44 83.16,89.44 75.77,89.44 73.99,91.22 72.62,91.22 71.99,91.85 71.99,93.23 65.52,99.71 65.52,100.49 64.16,101.84 63.94,101.84 63.45,102.34 63.45,102.61 60.74,105.32 49.42,105.32 48.65,104.55 48.65,103.83 49.68,102.81 50.05,102.81 v1(50.48,103.24)
  BOTTOM w0.102: v2(98.06,68.43) 98.06,68.14 97.91,67.99 U30.K8
PCIE_RXN10_WLAN: length 127.4
  IN1 w0.089: v1(179.77,23.28) 179.72,23.23 179.72,22.41 179.41,22.11 177.51,22.11 175.75,20.36 172.6,20.36 172.38,20.59 165.87,20.59 164.9,21.55 163.36,21.55 162.71,20.9 159.83,20.9 159.54,21.2 156.4,21.2 155.42,20.22 146.19,20.22 145.64,19.67 138.62,19.67 134.81,23.48 134.01,23.48 132.85,24.65 131.1,24.65 129.42,26.33 128.76,26.33 127.99,27.09 125.61,27.09 124.13,28.56 121.35,28.56 119.49,30.42 119.49,38.38 117.84,40.03 117.84,43.11 117.23,43.72 117.23,52.38 113.47,56.14 113.47,60.18 109.15,64.5 108.49,64.5 106.86,66.13 106.86,68.04 104.55,70.34 101.79,70.34 100.34,68.9 99.44,68.9 98.88,69.46 v2(98.88,69.46)
  BOTTOM w0.102: v2(98.88,69.46) 98.51,69.08 U30.H7 ; v1(179.77,23.28) 179.77,23.61 179.86,23.7 180.16,23.7 181.46,22.4 181.46,22.1 181.74,21.82 181.74,20.85 181.96,20.63 CN11.43
PCIE_RXN13_SSD: length 119.7
  IN3 w0.089: v1(39.01,14.42) 38.92,14.51 38.92,14.97 39.05,15.1 40.57,15.1 43.75,18.27 44.55,18.27 47.75,21.47 63.75,21.47 64.08,21.8 69.37,21.8 69.57,21.6 75.14,21.6 75.5,21.96 75.5,22.56 76.74,23.8 77.87,23.8 80.86,26.78 84.14,26.78 84.64,27.29 90.9,27.29 91.92,28.31 92.9,28.31 93.33,28.74 96.03,28.74 97.6,30.31 97.6,31.86 98.13,32.4 98.13,34.05 98.69,34.61 98.69,36.81 99.1,37.21 99.1,38.28 99.79,38.98 100.34,38.98 100.9,39.53 100.9,46.09 101.3,46.48 101.3,47.98 105.47,52.15 105.47,59.33 103.4,61.4 101.84,61.4 101.28,61.96 101.28,65.12 99.21,67.19 97.32,67.19 96.61,67.91 96.61,69.07 96.84,69.3 96.84,70 96.62,70.22 96.08,70.22 v2(95.96,70.33)
  BOTTOM w0.102: v1(39.01,14.42) 38.77,14.19 38.77,12.05 R726.1 ; v2(95.96,70.33) 95.86,70.33 U30.F11
PCIE_RXN13_SSD_C: length 1.9
  BOTTOM w0.102: CN19.5 38.85,10.47 38.73,10.59 38.73,11 R726.2
PCIE_RXN14_SSD: length 119.5
  IN3 w0.089: v1(36.65,12.97) 36.65,13.3 36.82,13.47 40.76,13.47 48.08,20.79 64.08,20.79 64.41,21.12 69.07,21.12 69.27,20.92 75.97,20.92 81.15,26.1 90.72,26.1 91.74,27.11 93.87,27.11 94.81,28.05 96.44,28.05 98.33,29.95 98.33,31.42 98.82,31.91 98.82,33.43 99.38,33.99 99.38,36.44 99.86,36.92 99.86,38.06 100.01,38.21 100.65,38.21 101.66,39.23 101.66,45.71 102.38,46.43 102.38,47.28 106.32,51.22 106.32,59.63 103.82,62.12 103.82,63.74 101.15,66.41 101.15,67.17 100.28,68.05 99.11,68.05 99.07,68.01 97.9,68.01 97.18,68.73 v2(96.99,68.73)
  BOTTOM w0.102: R730.1 35.81,11.91 35.81,12.06 35.94,12.19 36.27,12.19 36.52,12.44 36.52,12.83 v1(36.65,12.97) ; U30.H10 96.52,69.19 96.98,68.73 v2(96.99,68.73)
PCIE_RXN14_SSD_C: length 1.8
  BOTTOM w0.102: CN19.17 35.85,10.43 35.71,10.57 35.71,11.02 R730.2
PCIE_RXN15_SSD: length 133.1
  IN3 w0.089: v1(33,12.69) 32.72,12.97 32.72,13.18 32.86,13.32 33.77,13.32 34.1,12.99 34.1,12.09 34.78,11.42 39.51,11.42 40.19,12.1 42.82,12.1 46.8,16.08 46.8,16.88 49.08,19.16 57.66,19.16 57.89,18.93 64.98,18.93 65.19,19.14 68.95,19.14 69.25,18.83 75.8,18.83 81.24,24.27 94.1,24.27 96.29,26.45 98.95,26.45 100.06,27.56 100.06,31.12 101.03,32.08 101.03,33.86 102.09,34.93 102.09,36.92 103.9,38.72 104.33,38.72 104.71,39.1 104.71,41.13 104.33,41.52 104.33,43.55 104.77,43.99 105.03,43.99 105.22,44.18 105.22,47.32 107.88,49.99 107.88,60.06 105.47,62.47 105.47,66.03 102.88,68.62 102.88,70.08 101.14,71.82 98.78,71.82 98.06,71.09 v2(97.97,71.09)
  BOTTOM w0.102: R722.1 32.7,12.15 32.7,12.38 v1(33,12.69) ; v2(97.97,71.09) 97.57,70.69 U30.F8
PCIE_RXN15_SSD_C: length 1.9
  BOTTOM w0.102: R722.2 32.72,11.03 32.66,10.89 32.66,10.7 32.85,10.24 CN19.29
PCIE_RXN16_SSD: length 131.1
  IN3 w0.089: v1(29.38,13.58) 29.6,13.8 29.6,14.05 29.8,14.26 34.13,14.26 34.99,13.41 34.99,12.64 35.19,12.43 39.18,12.43 39.74,12.99 40.97,12.99 43.79,15.81 44.94,15.81 45.58,16.45 45.58,16.93 48.93,20.28 62.7,20.28 63.1,19.87 63.97,19.87 64.15,20.05 69.89,20.05 70.22,19.72 75.45,19.72 81.32,25.59 91.37,25.59 92.42,26.63 94.42,26.63 95.21,27.42 98.17,27.42 99.17,28.42 99.17,31.57 99.93,32.33 99.93,35.63 101.08,36.77 101.08,37.28 102.6,38.81 102.6,39.69 103.52,40.61 103.52,41.05 103.36,41.2 103.36,44.1 103.24,44.22 103.24,44.77 104.13,45.66 104.13,47.82 106.92,50.62 106.92,59.75 104.51,62.17 104.51,64.93 102.72,66.71 102.34,66.71 101.53,67.52 101.53,68.66 100.33,69.86 99.42,69.86 99.21,70.07 99.21,70.17 99.23,70.31 v2(99.06,70.54)
  BOTTOM w0.102: U30.F7 98.66,70.54 v2(99.06,70.54) ; R723.1 29.56,12.06 29.56,13.4 v1(29.38,13.58)
PCIE_RXN16_SSD_C: length 1.9
  BOTTOM w0.102: CN19.43 29.35,10.4 29.55,10.6 29.55,11.04 R723.2
PCIE_RXN_LAN_L: length 2
  TOP w0.102: U2.18 47.29,104.4 47.41,104.28 47.48,104.28 47.74,104.02 47.74,103.82 47.83,103.72 48.05,103.72 48.1,103.77 C90.1
PCIE_RXP9_LAN: length 85.2
  TOP w0.102: v1(50.48,102.6) 49.57,102.6 48.78,103.39 48.7,103.39 C94.2
  IN3 w0.089: v1(50.48,102.6) 49.59,102.6 48.45,103.75 48.45,104.63 49.34,105.52 60.83,105.52 63.65,102.7 63.65,102.42 64.03,102.04 64.25,102.04 65.72,100.57 65.72,99.79 72.2,93.31 72.2,91.93 72.71,91.43 74.08,91.43 75.86,89.65 83.25,89.65 84.25,88.64 88.07,88.64 89.73,86.98 90.34,86.98 91.43,85.89 94.53,85.89 95.22,85.2 96.26,85.2 97.85,83.61 97.85,79.49 100.14,77.2 100.14,72.88 99.63,72.38 98.61,72.38 97.59,71.35 97.59,69.37 97.89,69.07 98.46,69.07 98.7,68.84 98.7,68.62 v2(98.86,68.45)
  BOTTOM w0.102: U30.K7 98.51,68.1 v2(98.86,68.45)
PCIE_RXP10_WLAN: length 127.4
  IN1 w0.089: v1(179.13,23.28) 179.51,22.9 179.51,22.5 179.33,22.31 177.42,22.31 175.67,20.56 172.69,20.56 172.46,20.79 165.95,20.79 164.98,21.75 163.27,21.75 162.63,21.11 159.92,21.11 159.62,21.4 156.31,21.4 155.34,20.42 146.1,20.42 145.56,19.87 138.7,19.87 134.89,23.68 134.1,23.68 132.93,24.85 131.18,24.85 129.51,26.53 128.84,26.53 128.08,27.29 125.69,27.29 124.22,28.76 121.43,28.76 119.7,30.5 119.7,38.47 118.04,40.12 118.04,43.19 117.44,43.8 117.44,52.46 113.68,56.22 113.68,60.26 109.23,64.71 108.57,64.71 107.06,66.22 107.06,68.12 104.63,70.55 101.7,70.55 100.26,69.1 99.53,69.1 99.4,69.23 99.4,69.38 v2(99.5,69.48)
  BOTTOM w0.102: v2(99.5,69.48) 99.21,69.18 U30.H6 ; CN11.41 182.52,21.13 182.24,20.85 182.05,20.85 181.95,20.94 181.95,21.91 181.67,22.19 181.67,22.49 180.25,23.91 179.77,23.91 v1(179.13,23.28)
PCIE_RXP13_SSD: length 119.7
  IN3 w0.089: v1(38.33,14.42) 38.72,14.81 38.72,15.06 38.97,15.3 40.49,15.3 43.67,18.48 44.46,18.48 47.66,21.68 63.66,21.68 63.99,22.01 69.45,22.01 69.66,21.8 75.06,21.8 75.3,22.04 75.3,22.64 76.66,24 77.79,24 80.78,26.99 84.05,26.99 84.56,27.49 90.82,27.49 91.84,28.51 92.82,28.51 93.25,28.94 95.95,28.94 97.39,30.39 97.39,31.95 97.93,32.48 97.93,34.13 98.49,34.69 98.49,36.89 98.89,37.3 98.89,38.37 99.71,39.18 100.26,39.18 100.7,39.62 100.7,46.17 101.09,46.57 101.09,48.06 105.27,52.23 105.27,59.24 103.31,61.2 101.76,61.2 101.08,61.88 101.08,65.04 99.12,66.99 97.23,66.99 96.4,67.82 96.4,69.16 96.63,69.39 96.63,69.91 96.53,70.01 96.27,70.01 v2(95.96,69.7)
  BOTTOM w0.102: v1(38.33,14.42) 38.56,14.2 38.56,12.03 R725.1 ; v2(95.96,69.7) 95.9,69.64 95.64,69.64 95.51,69.78 U30.G11
PCIE_RXP13_SSD_C: length 1.9
  BOTTOM w0.102: CN19.7 38.35,10.46 38.52,10.63 38.52,11.09 R725.2
PCIE_RXP14_SSD: length 119.4
  IN3 w0.089: v1(36,12.97) 36.24,13.21 36.27,13.21 36.74,13.68 40.68,13.68 47.99,20.99 63.99,20.99 64.32,21.32 69.15,21.32 69.35,21.12 75.88,21.12 81.06,26.3 90.64,26.3 91.65,27.32 93.79,27.32 94.73,28.26 96.35,28.26 98.13,30.03 98.13,31.51 98.61,31.99 98.61,33.51 99.17,34.07 99.17,36.52 99.66,37 99.66,38.14 99.93,38.42 100.56,38.42 101.46,39.31 101.46,45.79 102.18,46.51 102.18,47.37 106.11,51.3 106.11,59.54 103.62,62.04 103.62,63.66 100.95,66.32 100.95,67.08 100.19,67.84 99.19,67.84 99.16,67.8 97.82,67.8 97.46,68.16 v2(97.17,68.16)
  BOTTOM w0.102: R729.1 35.52,11.74 35.6,11.82 35.6,12.15 35.85,12.41 36.18,12.41 36.3,12.53 36.3,12.69 36.03,12.97 v1(36,12.97) ; U30.J10 96.83,68.31 97.01,68.31 v2(97.17,68.16)
PCIE_RXP14_SSD_C: length 1.8
  BOTTOM w0.102: CN19.19 35.35,10.38 35.49,10.52 35.49,11.02 R729.2
PCIE_RXP15_SSD: length 133.1
  IN3 w0.089: v2(98,70.41) 98.4,70.82 98.4,71.15 98.86,71.61 101.06,71.61 102.68,69.99 102.68,68.53 105.27,65.94 105.27,62.39 107.68,59.97 107.68,50.07 105.01,47.41 105.01,44.27 104.94,44.19 104.69,44.19 104.13,43.63 104.13,41.43 104.51,41.05 104.51,39.19 104.24,38.92 103.81,38.92 101.89,37 101.89,35.01 100.82,33.95 100.82,32.17 99.86,31.2 99.86,27.65 98.87,26.66 96.2,26.66 94.02,24.47 81.16,24.47 75.72,19.04 69.34,19.04 69.03,19.34 65.1,19.34 64.9,19.14 57.97,19.14 57.75,19.37 49,19.37 46.59,16.96 46.59,16.17 42.73,12.31 40.11,12.31 39.42,11.62 34.86,11.62 34.3,12.18 34.3,13.08 33.85,13.52 32.78,13.52 32.51,13.26 32.51,12.97 v1(32.23,12.69)
  BOTTOM w0.102: R721.1 32.49,12.14 32.49,12.43 v1(32.23,12.69) ; v2(98,70.41) 97.58,69.99 U30.G8
PCIE_RXP15_SSD_C: length 1.9
  BOTTOM w0.102: CN19.31 32.35,10.43 32.45,10.53 32.45,11.19 R721.2
PCIE_RXP16_SSD: length 131.1
  IN3 w0.089: v1(30.01,13.58) 29.8,13.8 29.8,13.97 29.89,14.06 34.05,14.06 34.78,13.32 34.78,12.55 35.11,12.23 39.26,12.23 39.82,12.79 41.06,12.79 43.88,15.61 45.02,15.61 45.78,16.37 45.78,16.84 49.02,20.08 62.61,20.08 63.02,19.67 64.05,19.67 64.23,19.85 69.81,19.85 70.14,19.52 75.53,19.52 81.4,25.39 91.46,25.39 92.5,26.43 94.51,26.43 95.29,27.21 98.26,27.21 99.38,28.33 99.38,31.48 100.14,32.24 100.14,35.55 101.28,36.69 101.28,37.2 102.8,38.72 102.8,39.61 103.72,40.52 103.72,41.13 103.57,41.29 103.57,44.18 103.44,44.31 103.44,44.69 104.33,45.58 104.33,47.74 107.12,50.53 107.12,59.84 104.71,62.25 104.71,65.01 102.8,66.92 102.42,66.92 101.74,67.6 101.74,68.74 100.42,70.07 99.5,70.07 99.41,70.16 99.43,70.28 v2(99.66,70.45)
  BOTTOM w0.102: U30.G6 99.21,70 v2(99.66,70.45) ; v1(30.01,13.58) 29.78,13.35 29.78,12.02 R724.1
PCIE_RXP16_SSD_C: length 1.9
  BOTTOM w0.102: CN19.41 29.85,10.58 29.77,10.66 29.77,11.13 29.84,11.2 29.92,11.2 R724.2
PCIE_RXP_LAN_L: length 2
  TOP w0.102: C94.1 48.1,103.46 48.05,103.51 47.74,103.51 47.52,103.73 47.52,103.93 47.39,104.06 47.29,104.06 47.23,104 U2.17
PCIE_TXN0_SSD_C: length 12.7
  BOTTOM w0.102: C598.2 106.39,71.47 106.24,71.32 106.1,71.32 105.95,71.46 105.95,71.96 105.88,72.03 105.36,72.03 104.43,71.11 104.43,70.9 104.5,70.83 106.01,70.83 106.23,70.6 106.23,70.17 105.98,69.92 104.79,69.92 104.67,69.8 104.67,68.38 104.39,68.1 103.76,68.1 103.53,67.87 103.53,67.31 103.3,67.08 101.9,67.08 U30.L1
PCIE_TXN1_SSD_C: length 12.8
  BOTTOM w0.102: C600.2 107.91,70.07 107.82,69.97 107.55,69.97 107.43,70.09 107.43,70.7 107.36,70.76 107.16,70.76 106.95,70.55 106.95,69.38 106.58,69.01 105.59,69.01 105.47,68.89 105.47,66.71 105.23,66.47 104.8,66.47 104.57,66.7 104.57,67.27 104.47,67.37 104.27,67.37 104.16,67.27 104.16,66.7 103.94,66.47 102.81,66.47 102.71,66.56 102.17,66.56 102.06,66.45 101.44,66.45 U30.L2
PCIE_TXN2_SSD_C: length 12.8
  BOTTOM w0.102: U30.M2 101.28,65.37 101.28,65.26 101.4,65.15 101.52,65.15 101.82,65.45 102.79,65.45 103.09,65.75 104.18,65.75 104.37,65.56 104.37,64.36 104.61,64.12 105.09,64.12 105.33,64.36 105.33,65.51 106.18,66.36 106.18,68.13 106.35,68.3 106.86,68.3 107.63,69.07 107.76,69.07 107.91,68.92 C602.2
PCIE_TXN3_SATA1_TXN_SSD_C: length 12.8
  BOTTOM w0.102: C603.2 107.91,67.9 107.77,68.05 107.62,68.05 107.5,67.93 107.5,67.37 107.39,67.26 106.89,67.26 106.67,67.03 106.67,66.13 105.83,65.29 105.83,63.21 105.6,62.98 104.13,62.98 103.87,63.23 103.87,65.04 103.64,65.26 103.12,65.26 102.93,65.08 102.19,65.08 102.01,64.9 101.89,64.9 U30.N1
PCIE_TXN6_LAN_C: length 12.6
  BOTTOM w0.102: C608.1 107.79,63.36 107.56,63.36 107.45,63.26 107.45,62.17 107.29,62 107.29,61.2 106.72,60.63 106.72,60.41 106.49,60.18 106.11,60.18 105.88,60.41 105.88,60.63 105.78,60.73 105.57,60.73 105.47,60.63 105.47,60.41 105.24,60.18 104.86,60.18 104.63,60.41 104.63,60.63 104.53,60.73 104.01,60.73 102.45,62.29 102.45,62.93 102.06,63.31 101.7,63.31 101.53,63.14 101.28,63.14 100.94,63.49 U30.P4
PCIE_TXN7_WLAN_C: length 12.7
  BOTTOM w0.089: 102.42,64.29 102.4,64.29 102.39,64.3 101.66,64.3 101.55,64.19 101.28,64.19 100.97,64.49 U30.N4
  BOTTOM w0.102: 102.42,64.29 102.64,64.29 103.06,63.87 103.06,62.7 104.23,61.53 104.73,61.53 105.25,62.05 105.46,62.05 105.56,61.95 105.56,61.85 105.79,61.62 106.36,61.62 106.59,61.85 106.59,62.39 106.75,62.56 106.75,64.56 107.2,65.01 C606.1
PCIE_TXN9_LAN: length 105.3
  TOP w0.102: U2.14 45.24,102.69 45.05,102.51 45.05,102.38 44.92,102.25 44.92,101.31 45.29,100.94 45.29,100.71 v1(45.54,100.46)
  IN3 w0.089: v1(45.54,100.46) 45.32,100.67 45.32,101.23 44.84,101.71 44.84,102.55 45.96,103.67 45.96,107.35 48.7,110.1 49.97,110.1 50.66,110.78 55.48,110.78 56.26,109.99 61.42,109.99 69.71,101.7 69.71,98.98 75.99,92.7 84.23,92.7 86.08,90.84 89.04,90.84 90.36,89.52 91.37,89.52 92.82,88.07 95.41,88.07 96.1,87.39 97.16,87.39 101.33,83.21 101.33,79.28 102.6,78.01 102.6,75.47 103.74,74.32 103.74,72.58 107.94,68.39 107.94,64.04 108.61,63.36 108.85,63.36 v1(109.07,63.14)
  BOTTOM w0.102: C608.2 108.36,63.46 108.48,63.57 108.63,63.57 v1(109.07,63.14)
PCIE_TXN10_WLAN: length 118.8
  IN1 w0.089: v1(109.19,65.19) 109.33,65.33 110.22,65.33 110.48,65.07 110.48,64.15 113.75,60.87 118.42,60.87 120.51,58.78 120.51,55.97 117.92,53.38 117.92,44.22 118.6,43.54 118.6,40.41 120.25,38.76 120.25,30.8 121.73,29.32 124.34,29.32 125.89,27.77 128.36,27.77 129.04,27.09 129.64,27.09 131.4,25.34 133.18,25.34 134.34,24.17 135.09,24.17 138.34,20.92 146.24,20.92 146.57,21.25 155.43,21.25 156.12,21.93 159.95,21.93 160.3,21.58 162.27,21.58 162.93,22.24 165.23,22.24 166.2,21.27 172.71,21.27 172.88,21.09 174.33,21.09 176.44,23.2 177.71,23.2 178.24,23.74 179.39,23.74 179.72,24.07 179.72,24.75 v1(179.89,24.93)
  BOTTOM w0.102: C606.2 108.66,65.3 109.08,65.3 v1(109.19,65.19) ; CN11.37 182.42,22.13 182.27,22.28 182.27,22.58 180.91,23.94 180.91,24.83 180.35,25.39 179.77,25.39 179.68,25.3 179.68,25.14 v1(179.89,24.93)
PCIE_TXN13_SSD: length 144
  TOP w0.102: v1(36.13,5.7) 36.1,5.7 35.72,6.08 35.72,6.44 35.88,6.59 36.12,6.59 R739.1
  IN3 w0.089: v1(112.84,67.17) 112.84,67.22 113.22,67.6 113.42,67.6 113.52,67.5 113.52,66.87 113.02,66.36 113.02,65.69 114.29,64.42 114.29,59.76 113.6,59.07 113.6,56.01 117.71,51.9 117.71,44.44 115,41.72 115,38.75 114.41,38.17 114.41,36.65 113.52,35.76 113.52,34.57 113.65,34.45 113.65,34.02 111.87,32.24 111.87,31.76 107.68,27.57 107.68,24.84 106.91,24.07 105.26,24.07 103.62,22.42 103.62,21.66 101.63,19.67 94.68,19.67 93.81,20.53 84.1,20.53 80.01,16.45 78.78,16.45 76.92,14.59 74.66,14.59 74.05,13.98 56.81,13.98 55.92,14.87 54.03,14.87 52.6,13.44 50.1,13.44 45.02,8.37 41.71,8.37 39.37,6.03 37.86,6.03 36.89,5.07 36,5.07 35.85,5.22 35.85,5.55 36,5.7 v1(36.13,5.7)
  BOTTOM w0.102: v1(112.84,67.17) 112.67,67.35 112.25,67.35 111.99,67.61 111.99,69.42 110.68,70.73 109.63,71.78 108.99,71.78 108.74,72.03 107.13,72.03 C598.1
PCIE_TXN13_SSD_C: length 3.7
  TOP w0.102: v1(36.13,7.99) 36.08,7.99 35.88,7.78 35.88,7.38 36.03,7.23 R739.2
  BOTTOM w0.102: CN19.11 37.35,8.91 36.86,8.42 36.23,8.42 36.13,8.32 v1(36.13,7.99)
PCIE_TXN14_SSD: length 141.7
  TOP w0.102: R741.1 34.29,9.06 33.98,9.06 33.91,8.98 33.91,8.27 33.86,8.22 33.86,7.06 34.02,6.89 v1(34.11,6.89)
  IN3 w0.089: v1(34.11,6.89) 34.05,6.89 33.71,6.56 33.71,6.21 33.89,6.03 34.52,6.03 35.23,6.74 39.13,6.74 41.44,9.05 44.71,9.05 51.21,15.56 56.37,15.56 56.7,15.23 68.01,15.23 68.51,14.72 73.82,14.72 74.37,15.28 76.64,15.28 78.5,17.13 79.73,17.13 83.82,21.22 96.07,21.22 96.42,21.58 102.14,21.58 102.73,22.17 102.73,22.77 104.38,24.42 104.38,26.58 105.85,28.05 105.92,28.05 106.4,28.54 107.06,28.54 109.63,31.1 110.04,31.1 111,32.06 111,32.98 112.13,34.11 112.13,36.14 112.89,36.9 112.89,39.79 113.98,40.88 113.98,43.62 115.12,44.77 116.31,44.77 116.65,45.1 116.65,52 112.89,55.76 112.89,59.51 113.4,60.01 113.4,64.29 112,65.69 112,66.75 112.13,66.87 112.13,67.59 111.91,67.81 111.77,67.81 v1(111.34,67.38)
  BOTTOM w0.102: C600.1 108.62,70.6 109.57,70.6 110.69,69.48 110.69,67.84 110.91,67.63 111.09,67.63 v1(111.34,67.38)
PCIE_TXN14_SSD_C: length 2.7
  TOP w0.102: R741.2 34.1,10.03 34.1,10.55 v1(34.38,10.83)
  BOTTOM w0.102: CN19.23 34.35,10.8 v1(34.38,10.83)
PCIE_TXN15_SSD: length 137.7
  TOP w0.102: v1(31.43,8.37) 31.09,8.71 31.09,8.91 31.18,8.99 R743.1
  IN3 w0.089: v1(109.14,68.54) 109.14,68.74 109.51,69.11 109.63,69.11 110.09,68.64 110.09,67.72 110.86,66.96 110.86,66.2 111.16,65.89 111.16,63.2 112.2,62.16 112.2,55.48 115.3,52.38 115.3,46.93 113.09,44.72 113.09,41.01 112.13,40.04 112.13,37.1 111.78,36.75 111.47,36.75 110.98,36.27 110.98,33.95 110.09,33.06 110.09,32.33 109.76,31.99 109.5,31.99 106.78,29.27 105.39,29.27 103.62,27.5 103.62,25.6 101.53,23.51 99.62,23.51 98.91,22.8 96.37,22.8 95.48,21.91 83.55,21.91 79.49,17.84 78.24,17.84 76.47,16.06 74.18,16.06 73.67,15.56 68.82,15.56 67.8,16.57 66.4,16.57 65.74,15.91 57.03,15.91 56.7,16.24 50.88,16.24 44.38,9.74 41.15,9.74 38.87,7.45 35.35,7.45 34.64,8.16 32.59,8.16 31.91,7.48 31.3,7.48 31,7.78 31,7.94 v1(31.43,8.37)
  BOTTOM w0.102: C602.1 108.65,68.85 108.99,68.85 109.14,68.7 v1(109.14,68.54)
PCIE_TXN15_SSD_C: length 2.7
  TOP w0.102: v1(31.43,10.91) 31.2,10.68 31.2,10.13 R743.2
  BOTTOM w0.102: v1(31.43,10.91) 31.35,10.83 CN19.35
PCIE_TXN16_SSD: length 135.9
  TOP w0.102: v1(28.45,8.11) 28.22,8.35 28.22,8.84 28.37,8.99 R745.1
  IN3 w0.089: v1(109.19,67.55) 109.39,67.35 109.74,67.35 110.37,66.71 110.37,65.52 110.68,65.21 110.68,62.98 111.72,61.94 111.72,55.28 114.74,52.26 114.74,47.25 112.41,44.91 112.41,41.18 110.5,39.27 110.5,34.35 109.79,33.64 109.54,33.64 109.26,33.36 109.26,32.47 108.12,31.34 107.65,31.34 106.58,30.27 105.53,30.27 102.94,27.68 102.94,26.16 100.76,23.98 99.37,23.98 98.74,23.35 96.07,23.35 95.11,22.39 83.35,22.39 79.28,18.32 78.05,18.32 76.68,16.95 71.39,16.95 70.95,16.52 68.62,16.52 68.08,17.05 66.15,17.05 65.49,16.39 57.28,16.39 56.39,17.28 50.69,17.28 43.63,10.22 40.96,10.22 39.71,8.98 28.52,8.98 28.38,8.84 28.38,8.18 v1(28.45,8.11)
  BOTTOM w0.102: v1(109.19,67.55) 108.94,67.3 108.75,67.3 C603.1
PCIE_TXN16_SSD_C: length 2.5
  TOP w0.102: v1(28.48,10.81) 28.28,10.6 28.28,10.13 R745.2
  BOTTOM w0.102: v1(28.48,10.81) 28.35,10.67 CN19.47
PCIE_TXP0_SSD_C: length 12.7
  BOTTOM w0.102: C597.2 106.14,72.25 105.27,72.25 104.21,71.19 104.21,70.81 104.41,70.62 105.92,70.62 106.02,70.51 106.02,70.26 105.89,70.13 104.7,70.13 104.46,69.89 104.46,68.47 104.3,68.31 103.67,68.31 103.31,67.96 103.31,67.4 103.21,67.3 101.75,67.3 U30.L3
PCIE_TXP1_SSD_C: length 12.8
  BOTTOM w0.102: C599.2 107.66,70.98 107.07,70.98 106.73,70.64 106.73,69.47 106.49,69.23 105.5,69.23 105.26,68.98 105.26,66.8 105.14,66.69 104.89,66.69 104.79,66.79 104.79,67.36 104.56,67.59 104.18,67.59 103.95,67.36 103.95,66.79 103.85,66.69 102.9,66.69 102.8,66.78 102.08,66.78 101.97,66.67 101.67,66.67 101.54,66.8 101.35,66.8 U30.L4
PCIE_TXP2_SSD_C: length 12.8
  BOTTOM w0.102: C601.2 107.75,69.29 107.54,69.29 106.77,68.52 106.26,68.52 105.97,68.22 105.97,66.45 105.12,65.6 105.12,64.45 105,64.34 104.7,64.34 104.58,64.45 104.58,65.64 104.27,65.96 103,65.96 102.7,65.67 101.68,65.67 101.55,65.8 101.34,65.8 U30.M4
PCIE_TXP3_SATA1_TXP_SSD_C: length 12.8
  BOTTOM w0.089: 102.17,64.76 102.09,64.68 101.66,64.68 101.5,64.84 101.15,64.84 U30.N3
  BOTTOM w0.102: 102.17,64.76 102.28,64.86 103.02,64.86 103.21,65.05 103.55,65.05 103.66,64.95 103.66,63.14 104.04,62.76 105.69,62.76 106.04,63.12 106.04,65.2 106.88,66.04 106.88,66.94 106.98,67.04 107.66,67.04 C604.2
PCIE_TXP6_LAN_C: length 12.6
  BOTTOM w0.102: C607.1 107.91,63.77 107.72,63.57 107.47,63.57 107.24,63.35 107.24,62.25 107.07,62.09 107.07,61.29 106.5,60.72 106.5,60.5 106.4,60.4 106.2,60.4 106.09,60.5 106.09,60.72 105.87,60.95 105.48,60.95 105.26,60.72 105.26,60.5 105.15,60.4 104.95,60.4 104.85,60.5 104.85,60.72 104.62,60.95 104.1,60.95 102.67,62.38 102.67,63.02 102.15,63.53 101.81,63.53 101.5,63.84 101.38,63.84 101.28,63.74 101.28,63.61 U30.P2
PCIE_TXP7_WLAN_C: length 12.6
  BOTTOM w0.089: U30.N2 102.39,64.49 102.4,64.5 102.42,64.5
  BOTTOM w0.102: C605.1 107.91,66.01 107.77,66.15 107.62,66.15 107.5,66.03 107.5,65.39 107.34,65.23 107.11,65.23 106.54,64.65 106.54,62.65 106.37,62.48 106.37,61.94 106.27,61.84 105.88,61.84 105.78,61.94 105.78,62.04 105.55,62.27 105.17,62.27 104.64,61.75 104.32,61.75 103.27,62.79 103.27,63.96 102.73,64.5 102.42,64.5
PCIE_TXP9_LAN: length 105.3
  TOP w0.102: v1(44.91,100.46) 45.07,100.62 45.07,100.85 44.7,101.22 44.7,102.34 44.84,102.47 U2.13
  IN3 w0.089: v1(109.07,63.79) 108.84,63.56 108.7,63.56 108.14,64.12 108.14,68.47 103.95,72.66 103.95,74.41 102.8,75.55 102.8,78.09 101.53,79.36 101.53,83.3 97.24,87.59 96.18,87.59 95.5,88.28 92.91,88.28 91.46,89.72 90.44,89.72 89.12,91.05 86.17,91.05 84.31,92.9 76.08,92.9 69.91,99.07 69.91,101.79 61.5,110.2 56.35,110.2 55.56,110.98 50.57,110.98 49.89,110.3 48.62,110.3 45.76,107.44 45.76,103.75 44.64,102.64 44.64,101.63 45.12,101.15 45.12,100.67 v1(44.91,100.46)
  BOTTOM w0.102: C607.2 108.36,63.9 108.47,63.79 v1(109.07,63.79)
PCIE_TXP10_WLAN: length 118.7
  IN1 w0.089: v1(109.19,65.84) 109.51,65.53 110.31,65.53 110.68,65.16 110.68,64.23 113.84,61.07 118.5,61.07 120.71,58.86 120.71,55.88 118.12,53.29 118.12,44.31 118.81,43.62 118.81,40.5 120.46,38.85 120.46,30.88 121.81,29.53 124.43,29.53 125.98,27.98 128.44,27.98 129.13,27.29 129.73,27.29 131.48,25.54 133.26,25.54 134.43,24.37 135.17,24.37 138.42,21.12 146.15,21.12 146.48,21.45 155.35,21.45 156.04,22.13 160.03,22.13 160.39,21.78 162.19,21.78 162.85,22.44 165.31,22.44 166.28,21.47 172.79,21.47 172.97,21.3 174.25,21.3 176.36,23.4 177.63,23.4 178.16,23.94 179.3,23.94 179.51,24.15 179.51,24.67 v1(179.26,24.93)
  BOTTOM w0.102: C605.2 108.74,65.52 108.87,65.52 v1(109.19,65.84) ; v1(179.26,24.93) 179.47,25.14 179.47,25.39 179.68,25.6 180.44,25.6 181.13,24.92 181.13,24.03 182.52,22.63 CN11.35
PCIE_TXP13_SSD: length 144
  TOP w0.102: R740.1 35.51,6.19 35.51,5.74 v1(35.47,5.7)
  IN3 w0.089: v1(112.84,67.81) 113.5,67.81 113.73,67.58 113.73,66.79 113.22,66.28 113.22,65.77 114.49,64.5 114.49,59.68 113.8,58.99 113.8,56.09 117.92,51.98 117.92,44.35 115.2,41.63 115.2,38.67 114.62,38.09 114.62,36.56 113.73,35.67 113.73,34.66 113.85,34.53 113.85,33.94 112.08,32.16 112.08,31.68 107.88,27.49 107.88,24.75 107,23.86 105.34,23.86 103.82,22.34 103.82,21.58 101.71,19.47 94.59,19.47 93.73,20.33 84.19,20.33 80.1,16.24 78.86,16.24 77.01,14.39 74.75,14.39 74.14,13.78 56.72,13.78 55.83,14.67 54.11,14.67 52.69,13.24 50.18,13.24 45.1,8.16 41.79,8.16 39.46,5.83 37.94,5.83 36.98,4.86 35.92,4.86 35.65,5.13 35.65,5.52 v1(35.47,5.7)
  BOTTOM w0.102: v1(112.84,67.81) 112.6,67.56 112.34,67.56 112.2,67.7 112.2,69.51 109.71,72 109.08,72 108.83,72.25 107.09,72.25 C597.1
PCIE_TXP13_SSD_C: length 3.7
  TOP w0.102: R740.2 35.49,7.23 35.66,7.41 35.66,7.82 v1(35.49,7.99)
  BOTTOM w0.102: CN19.13 36.85,8.75 36.74,8.63 36.14,8.63 v1(35.49,7.99)
PCIE_TXP14_SSD: length 141.7
  TOP w0.102: R742.1 33.69,8.64 33.69,8.36 33.64,8.31 33.64,7.08 v1(33.46,6.89)
  IN3 w0.089: v1(111.34,68.01) 111.99,68.01 112.33,67.68 112.33,66.79 112.2,66.66 112.2,65.77 113.6,64.38 113.6,59.93 113.09,59.42 113.09,55.84 116.85,52.08 116.85,45.02 116.39,44.56 115.21,44.56 114.18,43.54 114.18,40.8 113.09,39.7 113.09,36.82 112.33,36.05 112.33,34.02 111.21,32.9 111.21,31.98 110.13,30.9 109.71,30.9 107.15,28.33 106.49,28.33 106,27.85 105.93,27.85 104.58,26.5 104.58,24.34 102.93,22.69 102.93,22.08 102.22,21.37 96.51,21.37 96.15,21.02 83.91,21.02 79.82,16.93 78.58,16.93 76.73,15.07 74.46,15.07 73.9,14.51 68.43,14.51 67.92,15.02 56.62,15.02 56.29,15.35 51.29,15.35 44.79,8.85 41.52,8.85 39.21,6.54 35.32,6.54 34.61,5.83 33.81,5.83 33.51,6.13 33.51,6.84 v1(33.46,6.89)
  BOTTOM w0.102: v1(111.34,68.01) 111.17,67.84 111,67.84 110.91,67.93 110.91,69.57 109.66,70.81 108.56,70.81 108.52,70.85 108.52,70.85 108.36,71.01 C599.1
PCIE_TXP14_SSD_C: length 2.7
  TOP w0.102: R742.2 33.88,10.07 33.88,10.69 v1(33.74,10.83)
  BOTTOM w0.102: v1(33.74,10.83) 33.85,10.72 CN19.25
PCIE_TXP15_SSD: length 137.7
  TOP w0.102: R744.1 30.8,8.74 v1(30.8,8.37)
  IN3 w0.089: v1(109.14,69.31) 109.71,69.31 110.3,68.73 110.3,67.8 111.06,67.04 111.06,66.28 111.36,65.98 111.36,63.28 112.41,62.24 112.41,55.56 115.5,52.46 115.5,46.85 113.3,44.64 113.3,40.92 112.33,39.96 112.33,37.01 111.86,36.55 111.55,36.55 111.19,36.18 111.19,33.86 110.3,32.97 110.3,32.24 109.84,31.79 109.59,31.79 106.87,29.07 105.47,29.07 103.82,27.42 103.82,25.51 101.61,23.3 99.71,23.3 98.99,22.59 96.45,22.59 95.57,21.7 83.64,21.7 79.57,17.64 78.33,17.64 76.55,15.86 74.26,15.86 73.76,15.35 68.74,15.35 67.72,16.37 66.48,16.37 65.82,15.71 56.95,15.71 56.62,16.04 50.96,16.04 44.46,9.54 41.24,9.54 38.95,7.25 35.27,7.25 34.56,7.96 32.68,7.96 31.99,7.28 31.22,7.28 30.8,7.7 v1(30.8,8.37)
  BOTTOM w0.102: v1(109.14,69.31) 109.14,69.21 109,69.07 108.75,69.07 C601.1
PCIE_TXP15_SSD_C: length 2.7
  TOP w0.102: v1(30.8,10.91) 30.99,10.72 30.99,10.22 R744.2
  BOTTOM w0.102: v1(30.8,10.91) 30.85,10.85 CN19.37
PCIE_TXP16_SSD: length 135.9
  TOP w0.102: v1(27.8,8.11) 28,8.32 28,8.88 27.88,8.99 R746.1
  IN3 w0.089: v1(109.19,66.77) 109.19,67.08 109.26,67.14 109.65,67.14 110.17,66.63 110.17,65.43 110.48,65.13 110.48,62.89 111.52,61.85 111.52,55.2 114.54,52.17 114.54,47.33 112.2,44.99 112.2,41.26 110.3,39.36 110.3,34.44 109.71,33.84 109.45,33.84 109.05,33.45 109.05,32.56 108.04,31.54 107.56,31.54 106.49,30.47 105.44,30.47 102.74,27.77 102.74,26.24 100.68,24.18 99.28,24.18 98.66,23.56 95.99,23.56 95.02,22.59 83.26,22.59 79.2,18.53 77.96,18.53 76.59,17.16 71.3,17.16 70.87,16.72 68.7,16.72 68.17,17.26 66.07,17.26 65.41,16.6 57.36,16.6 56.48,17.49 50.61,17.49 43.55,10.43 40.87,10.43 39.63,9.18 28.43,9.18 28.18,8.93 28.18,8.49 v1(27.8,8.11)
  BOTTOM w0.102: v1(109.19,66.77) 108.88,67.08 108.66,67.08 C604.1
PCIE_TXP16_SSD_C: length 2.5
  TOP w0.102: v1(27.82,10.81) 28.07,10.57 28.07,10.22 R746.2
  BOTTOM w0.102: CN19.49 27.85,10.78 v1(27.82,10.81)
PCIE_WAKE#: length 22.4
  TOP w0.102: R279.1 C380.2 100.97,30.08 v1(100.72,29.83)
  IN2 w0.089: v2(94.99,42.9) 94.99,41.88 95.31,41.57 95.31,38.59 93.99,37.27 93.99,35.6 93.89,35.5 93.89,34.3 95.44,32.75 98.36,32.75 98.74,33.13 99.63,33.13 101.28,31.48 101.28,30.42 100.72,29.86 v1(100.72,29.83)
  BOTTOM w0.102: U30.AW12 94.6,43.29 v2(94.99,42.9)
PCIE_WLAN_WAKE#: length 134.2
  TOP w0.102: v1(191.95,27.43) 191.95,27.38 191.15,26.57 191.15,23.69 191.76,23.08 191.76,20.75 192.72,19.79 192.72,16.65 v1(192.39,16.32) 192.39,14.41 192.57,14.24 R403.1 192.97,13.96 193.39,13.54 193.91,13.54 194.37,13.08 Q24.3
  IN2 w0.089: v1(191.95,27.43) 191.87,27.43 191.25,28.05 188.67,28.05 187.7,29.02 187.7,30.16 185.56,32.31 181.69,32.31 180.34,30.95 176.88,30.95 176.21,31.62 174,31.62 173.24,32.37 171.89,32.37 171.61,32.65 171.61,33.16 171.49,33.29 171.02,33.29 168.87,35.43 166.83,35.43 166.62,35.63 163.86,35.63 163.13,34.9 160.36,34.9 160.1,35.17 158.9,35.17 158.52,34.78 158.15,34.78 157.41,35.51 155.72,35.51 153.06,38.17 151.39,38.17 148.3,41.26 147.89,41.26 146.62,39.99 139.32,39.99 138.11,38.78 131.84,38.78 131.52,39.1 129.51,39.1 127.22,41.39 124.65,41.39 121.73,44.31 121.73,45.2 120.46,46.47 120.46,46.72 120.84,47.1 120.84,49.01 117.66,52.18 115,52.18 113.98,53.2 111.57,53.2 111.31,52.95 110.93,52.95 v1(110.42,53.45) 110.04,53.07 110.04,52.57 109.79,52.32 108.02,52.32 106.92,51.22 104.28,51.22 103.19,52.31 102.3,52.31 101.27,53.33 100.15,53.33 99.63,53.85 v2(99.63,54.52)
  BOTTOM w0.102: v2(99.63,54.52) 99.21,54.94 U30.AE6 ; v1(110.42,53.45) 110.2,53.23 R576.1
PCIE_ZVSS: length 7
  BOTTOM w0.102: U25.AU41 103.2,115.26 102.82,115.65 102.82,116.64 103.02,116.85 105.68,116.85 106.64,117.82 R481.1
PD#: length 17.1
  TOP w0.102: v1(200.9,22.41) 201.07,22.24 R327.1 201.07,21.63 R334.1 202.15,21.17 202.37,20.94 C441.2 ; C441.2 202.26,20.7 201.94,20.38 201.94,19.77 201.66,19.49 201.66,19.09 202.68,18.07 D15.2 ; C441.2 v1(203.25,20.7)
  BOTTOM w0.102: U35.47 201.33,23.08 200.9,22.64 v1(200.9,22.41) 200.34,21.86 200.34,20.81 200.01,20.48 199.6,20.48 199.53,20.41 198.08,20.41 197.98,20.51 195.32,20.51 D33.2
PEG_RXN0: length 52.9
  TOP w0.102: v1(95.64,109.82) 95.69,109.87 95.69,109.89 95.91,110.11 96.14,110.11 96.23,110.02 C44.1
  IN1 w0.089: v2(93.99,70.41) 93.99,70.14 93.93,70.08 93.78,70.08 93.61,70.24 93.61,71.15 94.27,71.81 94.62,71.81 95.24,72.43 99.25,72.43 99.91,73.09 99.91,73.57 100.01,73.67 100.01,77.46 98.69,78.78 98.69,86.02 95.26,89.45 95.26,93.16 94.37,94.05 93.81,94.05 92.72,95.14 92.72,101.28 93.64,102.2 93.64,108.93 94.82,110.11 95.43,110.11 95.64,109.89 v1(95.64,109.82)
  BOTTOM w0.102: v2(93.99,70.41) 93.91,70.32 93.69,70.32 93.51,70.51 U30.F13
PEG_RXN0_C: length 8.3
  TOP w0.102: v1(103.13,111.97) 102.93,111.78 102.93,111.5 102.74,111.31 101.86,111.31 101.53,110.98 98.16,110.98 97.05,109.88 96.85,109.88 C44.2
  BOTTOM w0.102: U25.AU35 103.13,111.9 v1(103.13,111.97)
PEG_RXN1: length 56.5
  TOP w0.102: v1(95.99,108.57) 95.99,108.48 95.9,108.39 95.62,108.39 95.18,108.83 95.18,111.4 95.41,111.63 96.14,111.63 96.23,111.54 C27.1
  IN1 w0.089: v2(92.99,68.7) 93.18,68.52 93.32,68.52 93.43,68.62 93.43,68.97 93.76,69.3 94.24,69.3 94.55,69.62 94.55,70.38 96.12,71.94 99.44,71.94 100.95,73.45 100.95,77.24 99.3,78.9 99.3,86.09 96.12,89.27 96.12,93.03 94.72,94.43 94.72,94.91 93.58,96.04 93.58,101.29 94.12,101.82 94.12,108.06 94.45,108.39 95.8,108.39 95.8,108.39 v1(95.99,108.57)
  BOTTOM w0.102: U30.H14 92.51,69.19 v2(92.99,68.7)
PEG_RXN1_C: length 9.2
  TOP w0.102: C27.2 96.95,111.51 97.49,111.51 97.83,111.85 98.72,111.85 99.88,113.02 101.15,113.02 101.66,112.51 102.86,112.51 103.37,113.02 103.37,113.28 103.41,113.32 v1(103.72,113.32)
  BOTTOM w0.102: U25.AU39 103.54,113.62 103.72,113.44 v1(103.72,113.32)
PEG_RXN2: length 55.5
  TOP w0.102: v1(95.34,113.45) 95.41,113.37 96.08,113.37 C17.1
  IN1 w0.089: v2(90.99,70.31) 91.16,70.14 91.65,70.14 92.5,71 92.5,71.38 94.09,72.96 94.47,72.96 94.82,73.32 98.16,73.32 99.05,74.2 99.05,76.54 98.74,76.85 98.74,77.42 97.78,78.39 97.78,85.68 94.35,89.11 94.35,91.25 93.22,92.38 93.22,93.39 91.82,94.79 91.82,101.81 92.67,102.66 92.67,109.31 94.68,111.31 94.68,112.92 95,113.24 95.13,113.24 v1(95.34,113.45)
  BOTTOM w0.102: U30.F15 91.12,70.31 v2(90.99,70.31)
PEG_RXN2_C: length 10.4
  TOP w0.102: v1(104.81,112.61) 104.4,113.02 104.4,113.76 104.04,114.12 99.67,114.12 98.8,113.25 96.95,113.25 C17.2
  BOTTOM w0.102: U25.AR38 104.3,112.71 104.41,112.61 v1(104.81,112.61)
PEG_RXN3: length 60.8
  TOP w0.102: C16.1 96.01,114.5 95.53,114.5 95.32,114.3 95.07,114.3 v1(94.8,114.03)
  IN1 w0.089: v2(92.01,67.98) 92.01,68.06 92.59,68.64 92.59,69.12 92.31,69.4 91.77,69.4 91.62,69.25 90.8,69.25 90.61,69.44 90.61,71.2 92.17,72.76 93.15,72.76 93.92,73.52 94.3,73.52 94.58,73.8 97.88,73.8 98.23,74.15 98.23,77.2 97.22,78.22 97.22,80.5 96.07,81.65 96.07,86.7 93.86,88.91 93.86,90.97 92.59,92.24 92.59,93.33 91.25,94.68 91.25,101.97 92.16,102.88 92.16,109.48 94.17,111.49 94.17,113.4 v1(94.8,114.03)
  BOTTOM w0.102: v2(92.01,67.98) 91.62,67.59 U30.K15
PEG_RXN3_C: length 13.3
  TOP w0.102: v2(104.79,111.82) 105.25,112.29 105.25,113.75 104.2,114.79 101.53,114.79 100.85,115.48 99.93,115.48 99.01,114.56 96.95,114.56 C16.2
  BOTTOM w0.102: v2(104.79,111.82) 104.79,112.01 105.4,112.62 U25.AN38
PEG_RXP0: length 52.6
  TOP w0.102: v1(95.64,110.45) 95.95,110.32 96.08,110.32 C37.1
  IN1 w0.089: v1(95.64,110.45) 95.3,110.31 94.73,110.31 93.43,109.01 93.43,102.28 92.52,101.37 92.52,95.06 93.73,93.85 94.29,93.85 95.06,93.08 95.06,89.37 98.49,85.94 98.49,78.69 99.81,77.37 99.81,73.76 99.71,73.65 99.71,73.17 99.16,72.63 95.15,72.63 94.53,72.01 94.19,72.01 93.41,71.23 93.41,70.16 93.69,69.87 93.79,69.87 v2(93.99,69.71)
  BOTTOM w0.102: U30.G13 v2(93.99,69.71)
PEG_RXP0_C: length 8.2
  TOP w0.102: C37.2 96.68,110.2 96.79,110.1 96.96,110.1 98.07,111.2 101.45,111.2 101.77,111.52 102.65,111.52 102.72,111.59 102.72,111.83 102.57,111.98 v1(102.49,111.98)
  BOTTOM w0.102: v1(102.49,111.98) 102.49,111.73 U25.AV35
PEG_RXP1: length 56.9
  TOP w0.102: v1(95.97,107.94) 95.73,108.18 95.53,108.18 94.97,108.74 94.97,111.49 95.32,111.85 96.08,111.85 C20.1
  IN1 w0.089: v1(95.97,107.94) 95.72,108.19 94.53,108.19 94.32,107.98 94.32,101.74 93.79,101.21 93.79,96.13 94.92,94.99 94.92,94.52 96.33,93.11 96.33,89.35 99.5,86.18 99.5,78.98 101.15,77.33 101.15,73.37 99.53,71.74 96.2,71.74 94.75,70.29 94.75,69.53 94.32,69.1 93.85,69.1 93.63,68.88 93.63,68.53 93.41,68.31 93.19,68.31 v2(92.99,68.11)
  BOTTOM w0.102: U30.J14 92.79,68.11 v2(92.99,68.11)
PEG_RXP1_C: length 9.1
  TOP w0.102: C20.2 96.95,111.73 97.4,111.73 97.74,112.06 98.63,112.06 99.79,113.23 101.24,113.23 101.75,112.72 102.77,112.72 103.15,113.11 103.15,113.28 103.08,113.35 v2(102.63,113.35)
  BOTTOM w0.102: v2(102.63,113.35) 103.06,112.92 U25.AU38
PEG_RXP2: length 56
  TOP w0.102: v1(95.34,112.81) 95.68,113.16 96.13,113.16 96.23,113.05 C19.1
  IN1 w0.089: v2(90.99,69.63) 91.3,69.94 91.73,69.94 92.7,70.91 92.7,71.29 94.17,72.76 94.55,72.76 94.91,73.11 98.24,73.11 99.25,74.12 99.25,76.63 98.94,76.93 98.94,77.51 97.98,78.47 97.98,85.76 94.55,89.19 94.55,91.33 93.42,92.46 93.42,93.48 92.03,94.87 92.03,101.73 92.87,102.58 92.87,109.22 94.88,111.23 94.88,112.84 95.09,113.04 95.26,113.04 95.34,112.97 v1(95.34,112.81)
  BOTTOM w0.102: U30.G15 91.35,69.99 v2(90.99,69.63)
PEG_RXP2_C: length 10.2
  TOP w0.102: v2(103.77,112.64) 104.08,112.64 104.18,112.74 104.18,113.67 103.95,113.91 99.76,113.91 98.89,113.04 96.95,113.04 C19.2
  BOTTOM w0.102: v2(103.77,112.64) 104.07,112.34 104.09,112.34 U25.AR37
PEG_RXP3: length 61.1
  TOP w0.102: C10.1 95.9,114.72 95.44,114.72 95.23,114.51 94.96,114.51 v1(94.8,114.67)
  IN1 w0.089: v2(92.01,68.78) 92.18,68.61 92.28,68.61 92.39,68.73 92.39,69.03 92.22,69.2 91.86,69.2 91.71,69.05 90.71,69.05 90.41,69.35 90.41,71.28 92.09,72.96 93.07,72.96 93.83,73.73 94.22,73.73 94.49,74 97.79,74 98.03,74.24 98.03,77.12 97.01,78.13 97.01,80.42 95.87,81.56 95.87,86.62 93.66,88.83 93.66,90.88 92.39,92.15 92.39,93.25 91.04,94.59 91.04,102.05 91.96,102.96 91.96,109.57 93.97,111.58 93.97,113.48 94.4,113.91 94.4,114.26 v1(94.8,114.67)
  BOTTOM w0.102: U30.J15 91.62,68.39 v2(92.01,68.78)
PEG_RXP3_C: length 13.2
  TOP w0.102: v1(105.93,111.82) 105.57,111.82 105.47,111.92 105.47,113.84 104.29,115.01 101.62,115.01 100.94,115.7 99.85,115.7 98.92,114.77 96.95,114.77 C10.2
  BOTTOM w0.102: v1(105.93,111.82) 105.5,111.82 105.4,111.92 U25.AN37
PEG_TXN0: length 57.4
  IN1 w0.089: v1(103.24,115.81) 103.24,115.89 103.03,116.09 102.7,116.09 102.45,115.84 100.26,115.84 99.35,114.92 99.35,110.7 98.46,109.82 98.46,108.32 98.33,108.19 98.33,95.57 97.93,95.16 97.93,92.75 99.12,91.55 99.12,88.64 101.23,86.53 101.23,84.4 102.04,83.59 102.04,78.85 103.69,77.2 103.69,75.97 106.52,73.14 109.21,73.14 109.37,73.3 v1(109.37,73.53)
  BOTTOM w0.102: v1(109.37,73.53) 109.37,73.35 109.19,73.17 108.69,73.17 108.62,73.24 C594.1 ; U25.AT40 103.7,113.92 103.47,113.92 103.43,113.97 103.43,114.1 103.52,114.18 103.52,114.48 103.45,114.55 103.45,114.8 103.51,114.85 103.51,115.74 103.44,115.81 v1(103.24,115.81)
PEG_TXN1: length 54.1
  IN1 w0.089: v1(107.61,74.36) 107.61,74.16 107.55,74.1 107.45,74.1 107.33,73.98 106.92,73.98 106.49,74.41 106.49,75.04 105.6,75.93 105.6,79.01 103.9,80.71 103.23,80.71 102.8,81.14 102.8,85.92 99.88,88.84 99.88,92.06 98.74,93.2 98.74,94.38 99.02,94.66 99.02,107.45 99.15,107.58 99.15,109.49 100.6,110.93 100.6,113.98 101.71,115.1 103.62,115.1 103.97,115.45 103.97,115.75 104.21,115.99 104.4,115.99 104.46,115.93 v1(104.46,115.77)
  BOTTOM w0.102: v1(107.61,74.36) 107.61,74.31 107.32,74.02 106.91,74.02 106.84,74.08 C592.1 ; v1(104.46,115.77) 104.46,115.61 104,115.15 104,114.9 104.07,114.82 104.07,114.56 103.97,114.46 103.97,114.26 104.04,114.19 104.17,114.19 U25.AR40
PEG_TXN2: length 55.6
  IN1 w0.089: v1(107,116.83) 107,116.95 106.87,117.08 106.36,117.08 105.9,116.62 105.9,115.99 104.33,114.41 102.04,114.41 101.28,113.65 101.28,110.57 99.83,109.12 99.83,107 99.71,106.87 99.71,96.21 101.03,94.89 101.03,88.67 103.57,86.13 103.57,85.2 104.84,83.93 104.84,80.79 106.49,79.14 106.49,76.57 107.22,75.83 107.43,75.83 v1(107.61,76.02)
  BOTTOM w0.102: U25.AP40 104.77,113.97 104.63,114.11 104.63,114.28 104.71,114.35 104.97,114.35 105.17,114.55 105.17,114.8 105.08,114.89 105.08,115.19 105.6,115.71 105.6,116.06 106.61,117.07 106.88,117.07 107,116.95 v1(107,116.83) ; v1(107.61,76.02) 107.38,75.79 107.11,75.79 C590.1
PEG_TXN3: length 50
  IN1 w0.089: v1(107.01,115.22) 106.83,115.4 106.37,115.4 104.69,113.73 102.37,113.73 102.04,113.4 102.04,110.35 101,109.31 101,108.29 100.77,108.06 100.77,105.7 100.95,105.52 100.95,97.38 101.74,96.59 101.74,88.92 105.52,85.13 105.52,81.12 108.39,78.25 108.39,77.46 108.11,77.18 107.83,77.18 v1(107.65,76.99)
  BOTTOM w0.102: C589.1 107.07,77.18 107.12,77.2 107.44,77.2 v1(107.65,76.99) ; v1(107.01,115.22) 106.8,115.43 106.44,115.43 106.17,115.16 106.17,114.92 106.33,114.76 106.33,114.61 106.18,114.46 106.18,114.03 106.12,113.97 U25.AM40
PEG_TXP0: length 56.9
  IN1 w0.089: v1(103.24,116.45) 103.08,116.29 102.62,116.29 102.37,116.04 100.18,116.04 99.15,115.01 99.15,110.79 98.26,109.9 98.26,108.4 98.13,108.27 98.13,95.65 97.72,95.24 97.72,92.66 98.92,91.47 98.92,88.56 101.03,86.45 101.03,84.31 101.84,83.5 101.84,78.77 103.49,77.12 103.49,75.88 106.44,72.93 109.21,72.93 109.37,72.77 v1(109.37,72.75)
  BOTTOM w0.102: U25.AT41 103.75,115.07 103.72,115.1 103.72,115.96 v1(103.24,116.45) ; C596.1 108.81,72.95 109.16,72.95 v1(109.37,72.75)
PEG_TXP1: length 53.6
  IN1 w0.089: v1(104.46,116.41) 104.25,116.19 104.13,116.19 103.77,115.83 103.77,115.54 103.53,115.3 101.63,115.3 100.39,114.07 100.39,111.02 98.94,109.57 98.94,107.66 98.82,107.54 98.82,94.74 98.54,94.46 98.54,93.12 99.68,91.98 99.68,88.76 102.6,85.84 102.6,81.05 103.15,80.51 103.82,80.51 105.4,78.93 105.4,75.85 106.28,74.96 106.28,74.32 106.84,73.77 107.41,73.77 v1(107.61,73.69)
  BOTTOM w0.102: C593.1 106.99,73.8 107.34,73.8 v1(107.61,73.69) ; U25.AR41 104.89,115.61 104.89,115.98 v1(104.46,116.41)
PEG_TXP2: length 55.2
  IN1 w0.089: v1(107,117.46) 106.82,117.28 106.28,117.28 105.7,116.71 105.7,116.07 104.24,114.62 101.96,114.62 101.08,113.74 101.08,110.65 99.63,109.21 99.63,107.08 99.5,106.95 99.5,96.13 100.82,94.8 100.82,88.58 103.36,86.04 103.36,85.12 104.63,83.85 104.63,80.71 106.28,79.06 106.28,76.48 107.14,75.63 107.33,75.63 v1(107.61,75.34)
  BOTTOM w0.102: U25.AP41 104.86,114.68 104.86,115.28 105.38,115.8 105.38,116.15 106.52,117.29 106.82,117.29 v1(107,117.46) ; C591.1 107.11,75.57 107.38,75.57 v1(107.61,75.34)
