# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DQA0_22: length 14.4
  IN1 w0.114: v1(126.07,112.58) 126.5,113.02 128.71,113.02 128.76,112.97 130.19,112.97 131,113.78 132.02,113.78 132.52,113.27 134.26,113.27 134.38,113.38 v1(134.38,114.18)
  BOTTOM w0.102: U25.B35 122.83,111.65 123.1,111.65 123.25,111.8 124.83,111.8 125.62,112.58 v1(126.07,112.58)
  BOTTOM w0.127: v1(134.38,114.18) 134.78,113.78 VRAM1.T11
DQA0_23: length 11.8
  IN1 w0.114: v1(132.93,112.54) 132.88,112.59 v1(127.49,112.59)
  BOTTOM w0.102: U25.A35 123.47,111.59 125.06,111.59 125.58,112.12 127.02,112.12 v1(127.49,112.59)
  BOTTOM w0.127: v1(132.93,112.54) 132.93,112.74 VRAM1.U11
DQA0_24: length 12.9
  IN1 w0.114: v1(126.74,110.59) 127.2,110.13 132.34,110.13 133.54,108.93 v1(133.54,108.57)
  BOTTOM w0.102: U25.B33 122.87,110.32 123.18,110.02 123.43,110.02 123.58,110.17 126.32,110.17 v1(126.74,110.59)
  BOTTOM w0.127: v1(133.54,108.57) 133.59,108.57 VRAM1.U4
DQA0_25: length 14.3
  IN1 w0.114: v1(128.19,110.57) 132.39,110.57 134.35,108.6 v1(134.35,108.58)
  BOTTOM w0.102: U25.B32 122.51,109.77 122.82,109.46 123.1,109.46 123.18,109.54 123.43,109.54 123.61,109.36 124.65,109.36 125.02,109.73 126.57,109.73 126.97,110.13 127.75,110.13 v1(128.19,110.57)
  BOTTOM w0.127: VRAM1.T4 134.77,108.18 134.38,108.58 v1(134.35,108.58)
DQA0_26: length 14.1
  IN1 w0.114: v1(123.79,109.76) 124.22,109.33 125.22,109.33 125.75,109.87 126.17,109.87 126.4,109.64 126.4,108.98 126.63,108.75 131.86,108.75 132.41,108.19 132.41,107.26 v1(133.54,106.14)
  BOTTOM w0.102: U25.A32 123.78,109.77 v1(123.79,109.76)
  BOTTOM w0.127: VRAM1.U2 v1(133.54,106.14)
DQA0_27: length 14.8
  IN1 w0.114: v1(134.38,106.18) 133.64,106.92 133.28,106.92 132.76,107.45 132.76,108.34 131.86,109.24 126.84,109.24 v1(126.84,109.23)
  BOTTOM w0.102: U25.B31 122.85,109.22 123.16,108.92 124.78,108.92 125.29,108.41 126.02,108.41 v1(126.84,109.23)
  BOTTOM w0.127: VRAM1.T2 v1(134.38,106.18)
DQA0_28: length 16.9
  IN1 w0.114: v1(136.78,107.78) 136.37,107.37 133.41,107.37 133.1,107.68 133.1,108.63 132.05,109.67 v1(128.33,109.67)
  BOTTOM w0.102: v1(128.33,109.67) 126.86,108.21 125.21,108.21 124.7,108.72 123,108.72 U25.A30
  BOTTOM w0.127: VRAM1.N4 v1(136.78,107.78)
DQA0_29: length 17.7
  IN1 w0.114: v1(123.76,107.85) 123.78,107.83 123.79,107.83 124.72,106.89 125.44,106.89 125.54,106.79 129.98,106.79 132.56,104.21 135.66,104.21 136.33,104.89 136.33,105.74 v1(136.78,106.18)
  BOTTOM w0.102: U25.B29 122.85,108.12 123.19,107.78 123.68,107.78 v1(123.76,107.85)
  BOTTOM w0.127: VRAM1.N2 v1(136.78,106.18)
DQA0_30: length 20.1
  IN1 w0.114: v1(138.38,106.18) 137.96,105.76 137.96,104.89 136.6,103.53 132.28,103.53 130.32,105.48 127.56,105.48 126.77,106.27 v1(126.77,106.37)
  BOTTOM w0.102: U25.B28 122.52,107.57 122.85,107.25 123.1,107.25 123.17,107.33 123.43,107.33 123.66,107.1 126.05,107.1 v1(126.77,106.37)
  BOTTOM w0.127: VRAM1.M2 v1(138.38,106.18)
DQA0_31: length 19.9
  IN1 w0.114: v1(137.58,107.78) 137.58,105.05 136.4,103.87 132.42,103.87 129.97,106.32 v1(128.13,106.32)
  BOTTOM w0.102: U25.A28 123,107.53 123.51,107.53 123.74,107.3 127.15,107.3 v1(128.13,106.32)
  BOTTOM w0.127: VRAM1.M4 v1(137.58,107.78)
DQA1_0: length 26.5
  IN3 w0.114: v1(138.38,92.59) 137.88,93.09 137.88,98.89 130.94,105.83 125.19,105.83 v1(124.68,106.35)
  BOTTOM w0.102: v1(124.68,106.35) 124.34,106.68 123.17,106.68 122.83,107.02 U25.B27
  BOTTOM w0.127: v1(138.38,92.59) 138.38,92.59 138.38,91.8 VRAM2.F4
DQA1_1: length 24.9
  IN3 w0.114: v1(126.02,106.38) 126.43,106.79 128.38,106.79 129,106.18 131.08,106.18 138.4,98.86 v1(138.4,93.41)
  BOTTOM w0.102: U25.A27 123.43,106.89 125.51,106.89 v1(126.02,106.38)
  BOTTOM w0.127: VRAM2.F2 v1(138.4,93.41)
DQA1_2: length 24.6
  IN3 w0.114: v1(136.8,93.37) 136.89,93.46 136.89,99.4 130.82,105.47 126.43,105.47 v1(126.03,105.07)
  BOTTOM w0.102: U25.B26 122.5,106.47 122.84,106.13 123.06,106.13 123.2,106.26 123.86,106.26 124.39,105.73 125.37,105.73 v1(126.03,105.07)
  BOTTOM w0.127: VRAM2.E2 137.18,93 v1(136.8,93.37)
DQA1_3: length 24.8
  IN3 w0.114: v1(136.78,92.59) 136.39,92.98 136.39,93.64 136.55,93.8 136.55,99.26 130.79,105.02 v1(128.08,105.02)
  BOTTOM w0.102: v1(128.08,105.02) 127.29,105.8 125.7,105.8 125.57,105.93 124.48,105.93 123.94,106.47 U25.A26
  BOTTOM w0.127: VRAM2.E4 136.78,91.79 v1(136.78,92.59)
DQA1_4: length 22.7
  IN3 w0.114: v1(135.13,94.47) 135.32,94.47 135.39,94.55 135.39,94.57 135.64,94.81 135.65,94.81 135.91,95.07 135.91,99.4 130.74,104.58 127.16,104.58 v1(126.72,105.02)
  BOTTOM w0.102: v1(126.72,105.02) 126.35,104.66 124.5,104.66 123.78,105.37 U25.A24
  BOTTOM w0.127: v1(135.13,94.47) 135.13,93.35 VRAM2.B2
DQA1_5: length 19.9
  IN3 w0.114: v1(126.96,103.24) 127.75,102.46 130.06,102.46 133.07,99.45 133.07,94.99 v1(132.9,94.83)
  BOTTOM w0.102: v1(126.96,103.24) 126.55,103.65 126.14,103.65 125.74,104.05 124.19,104.05 123.73,104.51 123.18,104.51 122.86,104.82 U25.B23
  BOTTOM w0.127: v1(132.9,94.83) 132.9,93.59 133.28,93.2 133.77,93.2 VRAM2.A2
DQA1_6: length 22.1
  IN3 w0.114: v1(127.62,103.24) 128.07,102.8 130.2,102.8 133.41,99.59 133.41,94.73 133.15,94.47 133.15,92.44 133.57,92.02 133.71,92.02 134.38,91.35 v1(134.38,90.99)
  BOTTOM w0.102: U25.A23 123.72,104.82 124.29,104.25 125.87,104.25 126.26,103.86 127.01,103.86 v1(127.62,103.24)
  BOTTOM w0.127: VRAM2.B4 v1(134.38,90.99)
DQA1_7: length 23.2
  IN3 w0.114: v1(132.9,90.16) 132.48,90.58 132.48,91.06 131.75,91.78 131.75,93.7 131.55,93.91 131.55,97.21 130.96,97.8 130.96,99.5 129.56,100.9 v1(129.56,101.23)
  BOTTOM w0.102: U25.B22 122.25,103.6 122.46,103.39 122.72,103.39 122.82,103.49 123.07,103.49 123.15,103.41 123.58,103.41 124.16,102.83 126.71,102.83 127.73,101.82 128.97,101.82 v1(129.56,101.23)
  BOTTOM w0.127: v1(132.9,90.16) 133.67,90.92 133.67,91.08 VRAM2.A4
DQA1_8: length 25.2
  IN3 w0.114: v1(128.93,100.28) 129.37,99.85 129.64,99.85 130.28,99.22 130.28,97.51 130.86,96.93 130.86,93.63 131.07,93.42 131.07,91.5 131.79,90.78 131.79,90.15 134.35,87.59 v1(134.35,87.12)
  BOTTOM w0.102: U25.B20 122.5,103.17 122.82,102.86 123.1,102.86 123.18,102.93 123.49,102.93 124,102.42 126.38,102.42 127.57,101.23 127.57,100.98 127.77,100.77 128.51,100.77 128.93,100.35 v1(128.93,100.28)
  BOTTOM w0.127: VRAM2.A11 134.35,86.16 v1(134.35,87.12)
DQA1_9: length 25.4
  IN3 w0.114: v1(128.13,101.21) 128.56,100.77 129.21,100.77 130.62,99.36 130.62,97.65 131.2,97.07 131.2,93.77 131.41,93.56 131.41,91.64 132.13,90.92 132.13,90.29 134.44,87.98 135.05,87.98 135.42,87.61 v1(135.42,87.22)
  BOTTOM w0.102: U25.A20 123.53,103.17 124.08,102.63 126.47,102.63 127.89,101.21 v1(128.13,101.21)
  BOTTOM w0.127: VRAM2.B11 135.24,86.25 135.24,87.03 v1(135.42,87.22)
DQA1_10: length 29
  IN3 w0.114: v1(134.39,83.79) 134.24,83.64 132.51,83.64 126.83,89.32 126.83,91.74 126.55,92.01 125.14,93.43 125.14,94.17 123.16,96.15 123.16,99.51 123.97,100.32 124.46,100.32 125.53,101.38 v1(125.64,101.38)
  BOTTOM w0.102: v1(125.64,101.38) 125,102.02 123.83,102.02 123.6,102.25 123.23,102.25 122.85,102.62 U25.B19
  BOTTOM w0.127: VRAM2.A13 v1(134.39,83.79)
DQA1_11: length 31
  IN3 w0.114: v1(126.92,101.23) 126.49,100.8 125.43,100.8 124.44,99.81 123.94,99.81 123.51,99.37 123.51,96.29 125.48,94.31 125.48,93.57 127.19,91.86 127.19,89.44 132.37,84.26 134.99,84.26 135.19,84.06 v1(135.19,83.79)
  BOTTOM w0.102: v1(126.92,101.23) 126.92,101.42 126.12,102.22 123.91,102.22 123.68,102.45 123.48,102.45 U25.A19
  BOTTOM w0.127: VRAM2.B13 134.78,84.19 v1(135.19,83.79)
DQA1_12: length 29
  IN3 w0.114: v1(126.93,100.28) 126.29,99.64 125.83,99.64 125.24,99.05 125.24,98.46 124.86,98.09 124.86,96.01 127.95,92.93 127.95,92.57 128.46,92.06 128.46,89.15 131.58,86.02 136.19,86.02 v1(136.78,85.43)
  BOTTOM w0.102: v1(126.93,100.28) 126.79,100.28 126.33,100.75 125.14,100.75 125.09,100.8 123.97,100.8 123.62,101.15 123.2,101.15 122.83,101.52 U25.B17
  BOTTOM w0.127: v1(136.78,85.43) 137.14,85.79 VRAM2.E11
DQA1_13: length 28.3
  IN3 w0.114: v1(125.58,100.28) 124.9,99.6 124.9,98.61 124.52,98.23 124.52,95.87 125.82,94.57 125.82,93.71 128.12,91.42 128.12,89 132.17,84.95 136.43,84.95 v1(137.58,83.8)
  BOTTOM w0.102: U25.A16 123,100.93 123.55,100.93 123.89,100.6 124.88,100.6 125.19,100.28 v1(125.58,100.28)
  BOTTOM w0.127: v1(137.58,83.8) 137.18,84.19 VRAM2.E13
DQA1_14: length 31.3
  IN3 w0.114: v1(138.38,83.79) 138,84.17 138,85.95 137.24,86.71 132.2,86.71 130.49,88.42 130.49,90.24 129.77,90.96 129.77,92.88 127.24,95.41 126.63,95.41 125.61,96.44 125.61,97.85 125.79,98.03 126.41,98.03 v1(127.28,98.9)
  BOTTOM w0.102: v1(127.28,98.9) 126.65,99.53 125.46,99.53 124.6,100.39 123.8,100.39 123.47,100.73 123.15,100.73 123.05,100.62 122.85,100.62 122.49,100.97 U25.B16
  BOTTOM w0.127: VRAM2.F13 v1(138.38,83.79)
DQA1_15: length 25.9
  IN3 w0.114: v1(137.56,85.42) 136.61,86.37 132.06,86.37 130.15,88.28 130.15,90.1 129.43,90.82 129.43,92.74 127.32,94.86 126.51,94.86 125.21,96.16 125.21,97.94 125.61,98.34 125.61,98.49 v1(125.99,98.87)
  BOTTOM w0.102: v1(125.99,98.87) 125.83,98.87 124.51,100.19 123.72,100.19 123.49,100.42 U25.A15
  BOTTOM w0.127: VRAM2.F11 137.94,85.79 v1(137.56,85.42)
DQA1_16: length 30.8
  IN1 w0.114: v1(127.94,98.82) 128.32,99.19 137.05,99.19 139.4,96.84 143.99,96.84 146.87,93.95 146.87,92.29 v1(146.38,91.79)
  BOTTOM w0.102: v1(127.94,98.82) 127.47,98.34 125.81,98.34 125.44,98.72 125.44,98.98 124.43,99.99 123.63,99.99 123.5,100.12 123.13,100.12 123.06,100.19 122.8,100.19 122.6,100.38 U25.B15
  BOTTOM w0.127: VRAM2.U4 v1(146.38,91.79)
DQA1_17: length 27.7
  IN1 w0.114: v1(129.21,98.78) 136.97,98.78 139.28,96.47 143.82,96.47 146.38,93.91 v1(146.38,93.39)
  BOTTOM w0.102: v1(129.21,98.78) 128.58,98.14 125.73,98.14 125.23,98.64 125.23,98.89 124.34,99.78 123.55,99.78 123.46,99.87 U25.A14
  BOTTOM w0.127: VRAM2.U2 v1(146.38,93.39)
DQA1_18: length 29.2
  IN1 w0.114: v1(146.38,92.59) 145.88,93.09 145.88,93.87 143.65,96.1 139.17,96.1 136.92,98.35 127.04,98.35 v1(126.17,97.48)
  BOTTOM w0.102: v1(126.17,97.48) 125.98,97.48 125.02,98.44 125.02,98.81 124.26,99.58 123.47,99.58 123.38,99.67 123.2,99.67 123.09,99.56 122.79,99.56 122.48,99.87 U25.B14
  BOTTOM w0.127: VRAM2.T2 v1(146.38,92.59)
DQA1_19: length 31.7
  IN1 w0.114: v1(124.49,98.78) 125.33,99.62 130.11,99.62 130.2,99.53 137.19,99.53 139.51,97.22 144.15,97.22 147.25,94.11 147.25,91.87 v1(146.38,90.99)
  BOTTOM w0.102: v1(124.49,98.78) 124.34,98.63 123.95,98.63 123.6,98.98 123.18,98.98 122.84,99.32 U25.B13
  BOTTOM w0.127: VRAM2.T4 v1(146.38,90.99)
DQA1_20: length 24.9
  IN1 w0.114: v1(126.61,96.08) 126.61,95.54 127.33,94.82 131.51,94.82 131.98,94.35 133.03,94.35 133.5,94.82 133.96,94.82 134.81,93.97 136.82,93.97 137.22,93.56 137.22,92.44 138.17,91.5 142.73,91.5 v1(143.22,91)
  BOTTOM w0.102: v1(126.61,96.08) 126.34,96.08 124.47,97.96 123.76,97.96 123.49,98.22 U25.A11
  BOTTOM w0.127: v1(143.22,91) 142.83,91.39 VRAM2.M4
DQA1_21: length 24.9
  IN1 w0.114: v1(127.88,95.98) 128.6,95.25 136.32,95.25 136.89,94.68 136.89,94.4 137.45,93.84 137.48,93.84 137.73,93.59 137.73,92.66 138.55,91.84 143.14,91.84 v1(143.18,91.79)
  BOTTOM w0.102: v1(127.88,95.98) 127.47,95.57 126.54,95.57 124.36,97.75 123.68,97.75 123.6,97.83 123.23,97.83 122.84,98.22 U25.B11
  BOTTOM w0.127: VRAM2.N4 v1(143.18,91.79)
DQA1_22: length 23.8
  IN1 w0.114: v1(128.51,96) 128.91,95.59 136.86,95.59 140.28,92.18 142.77,92.18 v1(143.18,92.59)
  BOTTOM w0.102: U25.A10 123,97.63 123.51,97.63 123.59,97.55 124.27,97.55 126.46,95.36 127.98,95.36 128.51,95.9 v1(128.51,96)
  BOTTOM w0.127: VRAM2.N2 v1(143.18,92.59)
DQA1_23: length 23.6
  IN1 w0.114: v1(142.38,92.59) 142.38,92.62 141.16,93.84 139.11,93.84 136.93,96.02 v1(129.79,96.02)
  BOTTOM w0.102: U25.B10 122.5,97.67 122.83,97.35 123.09,97.35 123.16,97.43 123.43,97.43 123.51,97.35 124.19,97.35 126.38,95.16 128.93,95.16 129.6,95.83
  BOTTOM w0.127: 129.6,95.83 v1(129.79,96.02) ; VRAM2.M2 v1(142.38,92.59)
DQA1_24: length 26.4
  IN1 w0.114: v1(142.38,86.22) 141.92,86.68 141.92,87.34 140.51,88.76 138.7,88.76 137.68,89.78 136.33,89.78 135.59,90.51 135.59,91.16 135.35,91.41 134.45,91.41 133.77,92.08 127.85,92.08 127.5,92.44 127.5,92.77 v1(127.49,92.77)
  BOTTOM w0.102: v1(127.49,92.77) 127.49,93.35 126.6,94.25 126.25,94.25 124.42,96.08 123.67,96.08 123.43,96.33 123.16,96.33 123.11,96.27 122.79,96.27 122.49,96.57 U25.B8
  BOTTOM w0.127: VRAM2.M11 142.38,86.19 v1(142.38,86.22)
DQA1_25: length 25.8
  IN1 w0.114: v1(126.55,93.6) 126.55,92.83 127.66,91.72 132.42,91.72 132.44,91.74 133.63,91.74 133.97,91.4 133.97,90.82 135.35,89.44 137.53,89.44 138.56,88.42 139.22,88.42 140.4,87.24 140.4,87.1 140.77,86.73 141.25,86.73 142.18,85.81 142.55,85.81 142.94,86.19 v1(143.18,86.19)
  BOTTOM w0.102: v1(126.55,93.6) 126.27,93.88 126.27,93.94 124.33,95.88 123.45,95.88 U25.A7
  BOTTOM w0.127: VRAM2.N11 v1(143.18,86.19)
DQA1_26: length 27.4
  IN1 w0.114: v1(143.18,83.77) 143.09,83.86 142.88,83.86 142.38,84.35 141.67,84.35 141.39,84.64 136.99,84.64 136.37,85.26 136.37,85.93 135.82,86.47 134.41,86.47 133.94,86.95 133.94,87.49 132.92,88.51 132.8,88.51 131.15,90.16 v1(129.02,90.16)
  BOTTOM w0.102: v1(129.02,90.16) 126.02,93.15 126.02,93.9 124.25,95.68 123.2,95.68 122.86,96.02 U25.B7
  BOTTOM w0.127: v1(143.18,83.77) 143.18,83.79 VRAM2.N13
DQA1_27: length 26.4
  IN1 w0.114: v1(127.65,90.16) 128.79,89.01 131.81,89.01 132.95,87.87 133.07,87.87 133.54,87.41 133.54,86.86 134.19,86.21 134.19,85.84 135.39,84.64 136.5,84.64 136.92,84.22 141.32,84.22 141.75,83.79 v1(142.36,83.79)
  BOTTOM w0.102: v1(127.65,90.16) 127.65,91.15 125.82,92.98 125.82,93.79 124.13,95.47 U25.A6
  BOTTOM w0.127: VRAM2.M13 142.38,83.79 v1(142.36,83.79)
DQA1_28: length 27.7
  IN1 w0.114: v1(124.23,93.93) 124.89,93.93 127.56,91.25 132.07,91.25 132.19,91.38 133.34,91.38 133.54,91.17 133.54,90.77 135.21,89.1 137.39,89.1 138.42,88.07 138.67,88.07 139.47,87.27 139.47,86.9 139.99,86.38 141.11,86.38 142.03,85.46 142.8,85.46 143.12,85.78 145.17,85.78 v1(145.58,86.19)
  BOTTOM w0.102: U25.A4 123.49,94.37 123.93,93.93 v1(124.23,93.93)
  BOTTOM w0.127: VRAM2.T11 v1(145.58,86.19)
DQA1_29: length 33.8
  IN1 w0.114: v1(124.93,91.22) 124.93,90.26 127.07,88.11 127.73,88.11 128.13,87.72 130.24,87.72 132.26,85.7 132.26,83.66 134.57,81.35 142.39,81.35 142.78,81.75 142.8,81.75 143.2,82.16 145.13,82.16 145.68,82.7 145.68,83.69 v1(145.58,83.79)
  BOTTOM w0.102: v1(124.93,91.22) 124.93,92.59 123.72,93.8 123.72,93.85 123.44,94.13 123.14,94.13 123.04,94.03 122.86,94.03 122.52,94.37 U25.B4
  BOTTOM w0.127: VRAM2.T13 v1(145.58,83.79)
DQA1_30: length 33.7
  IN1 w0.114: v1(124.47,91.93) 124.47,90.21 126.91,87.77 127.59,87.77 127.98,87.37 130.09,87.37 131.91,85.55 131.91,83.52 134.42,81.01 142.53,81.01 142.93,81.4 142.94,81.4 143.35,81.81 145.28,81.81 146.03,82.56 146.03,83 146.05,83 146.34,83.29 146.65,83.29 v1(147.17,83.81)
  BOTTOM w0.102: U25.A3 123.37,93.77 124.47,92.67 v1(124.47,91.93)
  BOTTOM w0.127: v1(147.17,83.81) 146.78,84.19 VRAM2.U13
DQA1_31: length 29.2
  IN1 w0.114: v1(123.91,92.49) 125.77,92.49 127.35,90.91 131.56,90.91 132.73,89.74 134.08,89.74 135.07,88.75 136.34,88.75 137.09,88 137.09,87.12 137.61,86.6 139.25,86.6 139.81,86.04 140.96,86.04 141.88,85.12 142.95,85.12 143.26,85.44 145.63,85.44 v1(146.38,86.19)
  BOTTOM w0.102: v1(123.91,92.49) 123.91,92.92 123.43,93.41 123.02,93.41 U25.B3
  BOTTOM w0.127: VRAM2.U11 v1(146.38,86.19)
DRAM_RST_A: length 66.7
  TOP w0.127: v1(139.92,97.89) 140.73,98.69 140.73,105.08 v1(140.93,105.29) ; R21.2 v1(124.52,123.56)
  IN1 w0.114: v1(149.67,116.45) 148.07,118.04 134.14,123.81 124.78,123.81 v1(124.52,123.56)
  IN3 w0.114: v1(139.92,97.89) 139.92,98.83 143.06,101.97 144.97,101.97 146.24,103.24 147.51,103.24 149.16,104.89 149.16,115.94 v1(149.67,116.45)
  BOTTOM w0.127: v1(139.92,97.89) 139.92,93.45 VRAM2.J2 ; v1(140.93,105.29) 140.78,105.44 140.78,106.18 VRAM1.J2
DRAM_RST_A_R: length 16.4
  TOP w0.102: R40.1 R42.2 124.42,118.38 v1(124.42,118.38) 124.17,118.12 121.07,118.12 119.59,116.65 118.35,116.65 117.41,115.71 117.41,111.49 v2(116.9,110.98)
  BOTTOM w0.102: v2(116.9,110.98) 116.9,110.32 U25.L32
EC_FPBACK#: length 214.2
  TOP w0.102: U15.86 182.49,24.16 v1(182.66,23.99) ; v1(55.94,109.46) 55.94,109.08 56.19,108.84 Q2.2
  IN3 w0.089: v1(60.69,117.46) 61.23,116.93 61.23,116.19 61.81,115.61 62.44,115.61 62.9,116.06 65.47,116.06 68.59,112.94 69.8,112.94 71.13,111.61 71.13,110.46 72.19,109.41 74.22,109.41 75.02,108.61 75.02,107.53 75.34,107.21 75.34,104.5 76.64,103.2 76.64,98.58 77.24,97.98 82.15,97.98 83.22,96.92 92.55,96.92 93.91,98.28 97.95,98.28 103.13,93.11 105.8,93.11 107,91.9 107,90.42 109.52,87.9 109.52,82.48 110.96,81.04 111.72,81.04 115.89,76.87 117.21,76.87 117.44,76.64 117.44,73.95 118.45,72.94 124.81,72.94 125.61,72.13 125.61,67.4 125.35,67.14 125.35,64.28 123.91,62.84 123.91,46.57 124.9,45.58 124.9,41.9 126.24,40.56 128.57,40.56 130.45,38.68 136.47,38.68 139.05,36.1 141.49,36.1 142.25,35.34 142.25,33.31 141.54,32.59 141.54,30.03 144.58,26.99 152.96,26.99 153.54,27.57 157.79,27.57 159.8,29.58 170.23,29.58 170.88,28.93 170.88,28.18 172.51,26.55 175.25,26.55 175.63,26.93 181.08,26.93 181.8,26.22 181.8,24.85 v1(182.66,23.99)
  BOTTOM w0.102: v1(60.69,117.46) 59.32,116.09 59.32,112.97 57.78,111.43 57.78,110.41 57.34,109.97 56.32,109.97 55.94,109.59 v1(55.94,109.46)
EC_ODD_EJ#: length 79.5
  TOP w0.102: v1(185.1,28.03) 183.98,29.15 R282.1 ; R367.1 129.48,16.71 v1(129.5,16.69)
  IN2 w0.089: v1(130.62,22.72) 131.29,23.39 132.88,23.39 133.17,23.68 140.21,23.68 141.04,24.51 142.52,24.51 144.18,26.17 156.91,26.17 157.83,25.25 162.11,25.25 162.69,25.84 164.91,25.84 165.33,26.26 167.8,26.26 168.8,27.25 170.47,27.25 171.28,26.45 175.21,26.45 175.96,27.2 184.28,27.2 v1(185.1,28.03)
  BOTTOM w0.102: v1(130.62,22.72) 132.05,22.72 132.18,22.59 132.65,22.59 133.54,21.7 135.82,21.7 137.35,20.18 137.35,19.16 136.45,18.26 129.47,18.26 129.35,18.14 CN17.16 129.35,16.84 v1(129.5,16.69)
EC_ODD_EJ_R#: length 3.4
  TOP w0.102: R282.2 183.3,28.59 v1(183.09,28.38) 182.81,28.09 C400.1 182.39,27.55 182.2,27.36 U15.94
EC_PWROK: length 23.7
  TOP w0.102: v1(156.58,20.71) 156.42,20.86 D13.1 156.42,22.62 v1(156.32,22.72) ; v1(169.3,20.18) 169.3,19.49 168.72,18.91 167.91,18.91 167.63,18.63 167.63,17.93 168.49,17.07 168.49,16.29 167.22,15.02 U15.33
  IN1 w0.089: v1(156.58,20.71) 159.29,20.71 159.57,20.43 163.13,20.43 163.26,20.56 164.65,20.56 165.48,19.73 167.55,19.73 167.57,19.76 168.88,19.76 v1(169.3,20.18)
EC_SPI1_CLK: length 28.3
  TOP w0.102: R251.1 177.61,31.79 v1(177.35,31.53) 177.35,31.41 176.8,30.85 176.59,30.85 176.42,30.67 U15.105
  BOTTOM w0.102: v1(177.35,31.53) 177.35,30.85 176.59,30.09 171.83,30.09 171,29.26 171,25.13 169.61,23.74 169.61,21.78 169.14,21.31 C667.1 165.3,21.31 164.4,22.21 162.75,22.21 161.99,21.45 161.99,20.24
EC_SPI1_SI: length 27.5
  TOP w0.102: R253.1 178.6,31.48 178.55,31.48 177.62,30.55 U15.102 177.62,28.77 v1(177.48,28.64)
  BOTTOM w0.102: U37.5 163.26,21.37 163.59,21.7 164.27,21.7 165.16,20.81 169.23,20.81 170.5,22.08 170.5,23.99 171.41,24.9 171.41,29.09 171.89,29.58 176.54,29.58 v1(177.48,28.64)
EC_SPI1_SO: length 26.3
  TOP w0.102: U15.103 177.22,30.76 v1(178,31.55) 178.37,31.92 R252.1
  BOTTOM w0.102: v1(178,31.55) 177.56,31.99 176.82,31.99 175.32,30.49 171.66,30.49 170.6,29.43 170.6,26.51 170.11,26.02 169.86,26.02 169.35,25.51 169.35,25.26 168.46,24.37 161.1,24.37 160.72,24.75 U37.2
EC_SPI_CS0#: length 31.7
  TOP w0.102: R283.1 160.21,28.56 160.68,29.03 v1(161.1,29.03) ; v1(180.5,33.03) 180.5,32.34 180.18,32.02 R254.1 179.8,32.02 178.88,31.1 178.52,31.1 178.02,30.6 U15.101
  IN1 w0.102: v1(161.1,29.03) 163.03,29.03 163.86,29.86 165.06,29.86 165.21,30.01 172.75,30.01 173.2,30.47 178.5,30.47 180.5,32.47 v1(180.5,33.03)
  BOTTOM w0.102: U37.1 159.45,27.38 v1(161.1,29.03)
EC_SPI_HOLD#: length 4.8
  TOP w0.102: v1(161.22,22.34) 159.95,22.34 v1(159.83,22.47) 159.42,22.87 R683.1
  BOTTOM w0.102: U37.7 160.72,21.83 v1(161.22,22.34)
EC_SPI_WP#: length 5.4
  TOP w0.102: v1(160.44,27.93) 160.31,27.8 R284.2 159.67,27.47 v1(159.95,27.19)
  BOTTOM w0.102: v1(159.95,27.19) 160.44,27.67 161.48,27.67 161.99,27.16 161.99,25.71
EC_THMTRIP#: length 90.1
  TOP w0.102: v2(109.64,52.69) 109.21,52.69 107.68,51.17 107.68,48.65 107.78,48.55 107.78,46.04 108.37,45.45 109.64,45.45 110.27,44.82 111.16,44.82 111.26,44.92 111.26,45.38 111.47,45.58 111.87,45.58 112.15,45.86 112.15,45.93 112.25,46.04 113.45,46.04 113.67,46.26 R732.2 ; v1(168.5,32.87) 168.5,32.74 168.74,32.5 168.74,31.73 168.77,31.7 168.77,31.05 168.42,30.7 U15.125
  IN1 w0.089: v1(162.49,36.31) 162.47,36.28 162.47,36 162.88,35.6 165.44,35.6 166.71,34.33 166.71,32.73 166.97,32.47 168.13,32.47 168.5,32.84 v1(168.5,32.87)
  IN2 w0.089: v1(162.49,36.31) 162.39,36.31 162.22,36.49 155.76,36.49 153.38,38.87 151.74,38.87 148.93,41.69 148.93,43.29 147.56,44.66 147.56,45.58 147.1,46.04 145.53,46.04 145.25,46.32 142.66,46.32 141.93,47.04 136.19,47.04 135.53,47.7 129.46,47.7 128.28,48.88 123.81,48.88 121.65,51.04 120.31,51.04 118.3,53.05 115.4,53.05 114.51,53.94 110.3,53.94 109.64,53.28 v2(109.64,52.69)
EC_TYPEC_CHG_HI: length 163.7
  TOP w0.102: v1(24.95,18.35) 26.48,19.87 26.48,22.08 27.49,23.1 v1(27.49,24.37) ; v1(166.74,27.36) U15.3
  IN2 w0.089: v1(166.74,27.36) 165.1,27.36 164.79,27.66 159.83,27.66 158.94,26.77 157.87,26.77 156.34,28.31 154.23,28.31 153.03,27.11 143.97,27.11 143.45,27.63 143.03,27.63 142.78,27.39 142.78,26.77 141.84,25.82 140.58,25.82 139.36,24.61 131.55,24.61 130.53,23.59 123.89,23.59 122.58,22.29 109.1,22.29 107.91,21.09 104.96,21.09 104.86,21.2 98.99,21.2 98.87,21.32 94.81,21.32 92.15,23.98 76.08,23.98 75.42,23.32 71.05,23.32 70.11,22.38 63.25,22.38 62.48,23.14 61.23,23.14 60.47,22.38 56.26,22.38 55.5,23.14 51.68,23.14 51.45,22.91 50.66,22.91 48.38,25.18 44.99,25.18 42.19,22.39 37.12,22.39 36.11,23.4 33.35,23.4 33.11,23.65 28.22,23.65 v1(27.49,24.37)
  BOTTOM w0.102: R700.1 20.17,18.15 20.45,17.87 22.52,17.87 22.67,18.02 24.62,18.02 v1(24.95,18.35)
EC_TYPEC_EN: length 4.1
  TOP w0.102: U15.80 182.74,21.76 182.94,21.96 184.16,21.96 v1(184.47,22.26) 184.54,22.34 R324.1
EC_TYPEC_EN_R: length 179.6
  TOP w0.102: R345.1 24.95,19.8 25.54,20.38 25.54,22.67 26.1,23.23 v1(26.1,24.12) ; v1(186.57,23.23) 185.69,22.34 R324.2
  IN2 w0.089: v1(186.57,23.23) 186.13,23.67 183.39,23.67 183.2,23.48 182.18,23.48 181.82,23.84 178.28,23.84 177.62,24.5 173.21,24.5 172.26,23.54 169.51,23.54 169.06,24 166.08,24 165.31,23.23 163.32,23.23 161.91,21.82 158.19,21.82 156.07,23.94 146.1,23.94 144.75,22.59 142.37,22.59 141,21.22 133.45,21.22 131.7,19.47 122.67,19.47 121.93,18.73 115.94,18.73 114.94,19.72 111.88,19.72 109.66,17.51 99.05,17.51 97.1,19.47 93.25,19.47 90.71,22.01 78.87,22.01 78.11,21.25 69.61,21.25 69.4,21.45 64.35,21.45 64.08,21.17 51.46,21.17 48.03,24.6 45.21,24.6 42.4,21.78 36.83,21.78 35.92,22.69 33.23,22.69 32.85,23.07 27.14,23.07 v1(26.1,24.12)
EC_WLAN_RST#: length 25.9
  TOP w0.102: U15.87 182.62,24.56 182.87,24.8 182.87,25.31 183.07,25.51 184.47,25.51 184.52,25.46 185.18,25.46 v1(185.61,25.89) ; v1(199.86,16.85) 200.82,17.82 D17.1
  IN2 w0.089: v1(185.61,25.89) 186.47,25.03 189.39,25.03 190.94,23.48 190.94,21.83 192.11,20.66 193.95,20.66 196.7,17.92 198.93,17.92 199.86,16.99 v1(199.86,16.85)
ECAGND: length 11.6
  TOP w0.203: U15.75 182.45,19.76 v1(182.59,19.62) 183.07,19.13 C448.2 183.61,19.42 L6.1
  TOP w0.254: L6.1 184.33,19.3 184.72,18.91 185.51,18.91 186.32,18.1 186.32,17.16 185.9,16.74 184.33,16.74 183.99,16.4 183.99,15.42 C484.1
EDCA0_0: length 29.9
  IN3 w0.114: v1(145.58,106.98) 145.32,106.72 144.41,106.72 144.29,106.6 143.44,106.6 142.74,107.3 139.9,107.3 139.58,107.62 139.58,108.05 137.21,110.42 132.09,110.42 129.72,112.8 128.71,112.8 128.31,113.2 120.84,113.2 v1(120.31,112.67)
  BOTTOM w0.102: v1(120.31,112.67) 119.95,112.67 U25.G38
  BOTTOM w0.127: VRAM1.C2 v1(145.58,106.98)
EDCA0_1: length 32.3
  IN3 w0.114: v1(144.77,116.59) 143.77,117.59 139.89,117.59 137.72,119.75 121.34,119.75 119.59,118.01 v1(119.59,117.74)
  BOTTOM w0.102: 119.59,117.61 119.59,117.17 120.36,116.41 120.36,116.07 120.25,115.97 U25.F41
  BOTTOM w0.127: 119.59,117.61 v1(119.59,117.74) ; VRAM1.C13 144.77,115.79 v1(144.77,116.59)
EDCA0_2: length 15.4
  IN1 w0.114: v1(125.59,113.93) 126.2,114.54 128.08,114.54 128.81,115.28 132.5,115.28 132.68,115.46 134.82,115.46 135.3,114.98 v1(135.98,114.98)
  BOTTOM w0.102: v1(125.59,113.93) 125.59,113.8 125.03,113.24 124.55,113.24 124.32,113.02 123.73,113.02 123.53,112.83 123.13,112.83 122.83,112.52 U25.B37
  BOTTOM w0.127: VRAM1.R13 v1(135.98,114.98)
EDCA0_3: length 14.9
  IN1 w0.114: v1(125.49,108.81) 126.24,108.06 131.35,108.06 131.77,107.65 131.77,106.99 132.47,106.29 132.47,105.81 132.75,105.52 133.67,105.52 133.84,105.7 134.48,105.7 134.71,105.93 134.9,105.93 v1(135.15,106.18)
  BOTTOM w0.102: U25.A31 123.37,109.16 125.15,109.16 v1(125.49,108.81)
  BOTTOM w0.127: VRAM1.R2 135.18,106.18 v1(135.15,106.18)
EDCA1_0: length 25.9
  IN3 w0.114: v1(128.9,103.22) 129.27,103.59 130.33,103.59 134.07,99.84 134.07,94.01 134.08,94 133.98,93.9 133.98,93.02 134.4,92.59 v1(135.18,92.59)
  BOTTOM w0.102: U25.B24 122.51,105.37 122.82,105.07 123.07,105.07 123.15,105.14 123.71,105.14 124.39,104.46 126.13,104.46 126.38,104.21 126.5,104.21
  BOTTOM w0.127: 126.5,104.21 126.88,104.21 127.26,104.58 127.68,104.58 127.81,104.46 127.81,103.75 127.94,103.63 128.19,103.63 128.32,103.75 128.32,104.46 128.45,104.58 128.79,104.58 128.9,104.47 v1(128.9,103.22) ; v1(135.18,92.59) VRAM2.C2
EDCA1_1: length 26.5
  IN3 w0.114: v1(127.6,100.28) 127.6,99.81 128.21,99.2 129.37,99.2 129.63,98.95 129.63,97.24 130.21,96.66 130.21,93.36 130.42,93.15 130.42,91.23 131.14,90.51 131.14,89.88 133.06,87.97 v1(133.06,87.3)
  BOTTOM w0.102: v1(127.6,100.28) 127.11,100.77 126.63,100.77 126.45,100.95 125.34,100.95 125.21,101.08 125.21,101.41 124.8,101.81 123.74,101.81 123.51,102.04 122.98,102.04 U25.A18
  BOTTOM w0.127: VRAM2.C13 135.22,84.56 133.72,84.56 133.06,85.23 v1(133.06,87.3)
EDCA1_2: length 25.9
  IN1 w0.114: v1(129.06,97.43) 136.92,97.43 138.9,95.45 142.72,95.45 v1(144.78,93.39)
  BOTTOM w0.102: U25.B12 122.48,98.77 122.81,98.44 123.09,98.44 123.17,98.53 123.48,98.53 123.84,98.16 124.55,98.16 125.88,96.83 128.46,96.83 v1(129.06,97.43)
  BOTTOM w0.127: VRAM2.R2 v1(144.78,93.39)
EDCA1_3: length 32.4
  IN1 w0.114: v1(144.78,83.79) 144.18,83.2 143.33,83.2 142.53,82.4 141.93,82.4 141.13,83.2 133.64,83.2 132.9,83.93 132.9,85.97 130.5,88.37 128.39,88.37 128,88.76 127.8,88.76 126.76,89.8 v1(126.07,89.8)
  BOTTOM w0.102: U25.B6 122.49,95.47 122.83,95.13 123.06,95.13 123.2,95.26 124.04,95.26 125.56,93.74 125.56,92.82 126.07,92.32 v1(126.07,89.8)
  BOTTOM w0.127: VRAM2.R13 v1(144.78,83.79)
EDP_HPD: length 62.7
  IN3 w0.089: v1(88.96,84.06) 87.31,85.71 82.28,85.71 80.71,87.29 73.29,87.29 67.12,93.46 65.85,93.46 64.12,95.19 64.12,96.71 61.91,98.92 60.44,98.92 59.22,100.14 59.22,100.54 59.5,100.82 59.5,101.08 58.61,101.97 57.29,101.97 v1(56.78,101.46)
  BOTTOM w0.089: 94.51,72.84 94.81,73.14 94.81,73.49 94.68,73.63
  BOTTOM w0.102: v1(56.78,101.46) 57.64,102.32 57.64,104.19 57.57,104.26 C557.2 57.06,104.42 R505.1 ; 94.68,73.63 94.68,74.07 94.21,74.54 93.66,74.54 93.41,74.79 93.41,75.04 93.28,75.17 92.39,75.17 91.37,76.19 91.37,78.06 91.12,78.32 R567.1 90.87,78.57 91.12,78.83 91.12,83.68 90.46,84.34 89.24,84.34 v1(88.96,84.06) ; U30.C12 94.51,72.84
EDP_HPD_R: length 3
  BOTTOM w0.102: R505.2 56.61,105.85 v1(56.55,105.9) 56.42,105.78 55.92,105.78 55.56,106.13 55.56,106.46 55.72,106.62 CN2.25
EN: length 3.3
  TOP w0.102: R371.1 205.65,16.72 205.67,16.75 R372.2 205.96,16.91 206.18,17.13 206.8,17.13 207.06,16.87 U18.7
EQ1: length 11.3
  TOP w0.102: R407.2 v1(205.47,13.09) 204.99,13.58 R406.1 ; v1(213.14,15.63) 212.91,15.87 U18.17
  IN3 w0.089: v1(213.14,15.63) 212.18,15.63 211.52,14.97 208.94,14.97 207.05,13.09 v1(205.47,13.09)
EQ2: length 13.3
  TOP w0.102: v1(213.17,17.13) 212.91,16.87 U18.19 ; R398.1 v1(205.29,14.46) R399.2 205.96,14.18 206.06,14.08 206.46,14.08 206.94,13.6 v1(206.94,13.58)
  IN3 w0.089: v1(213.17,17.13) 211.64,17.13 211.14,17.64 208.98,17.64 207.58,16.24 207.58,14.21 v1(206.94,13.58)
EQ_SEL_A0: length 3.7
  BOTTOM w0.102: R569.2 22.54,73.49 v1(22.34,73.7) 22.13,73.49 R568.1 21.52,73.72 21.4,73.85 21.4,74.28 21.13,74.54 U28.5
FAN1_RPM: length 28.4
  TOP w0.102: v1(173.16,15.35) 172.82,15.01 U15.47
  BOTTOM w0.102: FAN1.2 178.68,28.87 177.76,27.95 175.73,27.95 173.8,26.02 172.97,26.02 172.68,25.73 172.68,23.31 172.55,23.18 172.55,21.8 172.81,21.55 173.57,21.55 174.86,20.26 176.64,20.26 176.9,20.51 176.9,21.15 R690.2 177.25,21.2 177.25,18.35 v1(176.85,17.94) 176.34,17.44 176.34,17.26 175.58,16.5 173.92,16.5 173.16,15.73 v1(173.16,15.35)
FAN_PWM: length 19.1
  TOP w0.102: v1(165.54,14.95) 165.57,14.97 U15.32 166.63,15.76 v1(167.37,16.5)
  BOTTOM w0.102: Q36.1 173.78,20.96 174.71,20.03 176.87,20.03 176.97,19.93 176.97,18.78 176.08,17.89 176.08,17.39 175.42,16.72 168.69,16.72 168.46,16.5 v1(167.37,16.5)
FAN_PWM_C: length 15.4
  BOTTOM w0.102: FAN1.3 180.62,30.13 180.78,29.96 180.78,28.38 181.04,28.13 181.04,26.43 v1(180.88,26.28) 180.45,26.71 178.57,26.71 178.37,26.5 178.37,25.31 177.81,24.75 177.81,23.58 177.05,22.82 176.36,22.82 176.24,22.94 R684.2 175.07,23.23 174.8,22.96 Q36.3
FB_VMEMIO: length 6
  BOTTOM w0.102: TP51.1 121.73,88.66 121.73,90.44 122.34,91.05 122.34,92.72 122.24,92.82 122.24,93.49 U25.C3
G781THERM#: length 2.1
  BOTTOM w0.102: R605.2 19.65,37.73 v1(19.7,37.68) 19.71,37.67 U32.4
G5335-AGND: length 9.3
  IN2 w0.406: v2(145.65,62.74) 146.86,62.74 147.74,61.86 148.4,61.86 148.42,61.84 v1(148.47,61.84)
  BOTTOM w0.152: PC215.2 149.03,63.14 149.16,63 149.16,62.17 149.01,62.01 148.65,62.01 v1(148.47,61.84) 148.19,61.55 PC219.2
  BOTTOM w0.203: PR248.1 146.37,61.96 146.18,62.15 PR251.1 145.41,62.15 145.12,61.86 PR250.2
  BOTTOM w0.254: PU10.4 145.47,62.92 v2(145.65,62.74) 145.65,62.59 145.79,62.44 PR251.1
G5335-AGND-1: length 36.3
  IN2 w0.457: v1(146.01,42.43) 146.68,43.1 v1(146.68,45.42)
  BOTTOM w0.203: PR316.1 130.21,35.83 130.36,35.67 131.13,35.67 132.04,36.59 141.44,36.59 142.53,37.68 145.58,37.68 147.08,39.18 148.98,39.18 149.29,39.48 149.29,40.44 148.41,41.32 148.24,41.32 PR304.2 147.96,41.77 PR303.1 148.54,42.17 147.79,42.17 147.79,42.17 146.75,42.17 146.63,42.29 PR302.1 146.63,43.03 146.52,43.14 PR300.1 ; PC246.2 146.87,45.23 v1(146.68,45.42) 146.68,45.65 146.5,45.83 146.5,45.84 146.36,45.98 145.42,45.98 145.19,45.75 PC245.2
  BOTTOM w0.254: v1(146.01,42.43) 145.95,42.49 PU11.4
  BOTTOM w0.406: v1(146.01,42.43) 146.23,42.65 PR302.1
G5335-BST: length 3.6
  BOTTOM w0.102: v1(150.25,66.97) 150.01,67.21 PR243.2
  BOTTOM w0.219: PU10.20 148.49,65.79 149.25,66.55 PR243.2
G5335-BST-1: length 4.7
  BOTTOM w0.254: PU11.20 142.72,45.4 143.13,45.8 143.13,46.67 142.87,46.93 141.61,46.93 140.92,46.24 PR294.2
G5335-EN: length 9.1
  TOP w0.203: PR29.1 149.29,63.49 147.89,62.09 147.89,61.14 v1(148.1,60.93)
  BOTTOM w0.152: PU10.2 146.47,63.09 146.79,62.77 146.89,62.77 147.31,62.34 147.31,61.78 PC219.1
  BOTTOM w0.203: PR253.2 148.13,60.9 v1(148.1,60.93) 147.91,60.93 147.54,61.29 PC219.1
G5335-EN-1: length 4.7
  BOTTOM w0.102: PR299.2 148.14,44.01 148.63,43.52 v1(148.63,43.37)
  BOTTOM w0.152: PU11.2 145.41,43.49 146.1,44.18 146.59,44.18 PC246.1
  BOTTOM w0.203: PC246.1 147.48,44.46 147.76,44.18 PR299.2
G5335-FB: length 3.3
  BOTTOM w0.203: PR250.1 144.43,62.31 144.26,62.15 PR249.2 143.37,62.15 143.36,62.14 PC218.1
  BOTTOM w0.254: PU10.5 144.97,62.85 144.84,62.72 PR250.1
G5335-FB-1: length 5.6
  BOTTOM w0.102: PR304.1 147.43,41.22 v1(147.71,40.93)
  BOTTOM w0.203: PR305.2 145.83,41.22 145.83,40.46 PC248.1
  BOTTOM w0.254: PU11.5 145.42,41.99 145.68,41.72 146.29,41.72 PR305.2 146.32,41.69 PR304.1
G5335-LX:
  vias: v1(147.66,68.72)
G5335-LX-1:
  vias: v1(139.71,44.82)
G5335-PFM: length 2.9
  BOTTOM w0.203: PU10.3 145.97,63.07 146.57,62.46 146.78,62.46 147,62.25 PR248.2 147,61.58 147.01,61.57 PR252.1
G5335-PFM-1: length 2.8
  BOTTOM w0.203: PU11.3 145.55,42.99 145.94,43.38 145.94,43.59 146.23,43.87 PR300.2 PR301.1
G5335-PWRGD: length 1.5
  BOTTOM w0.152: PR247.2 147.61,62.46 146.97,63.11 PU10.1
G5335-PWRGD-1: length 1.4
  BOTTOM w0.152: PR298.2 145.99,44.46 145.52,43.99 PU11.1
G5335-SS: length 1.6
  BOTTOM w0.203: PU10.23 148.37,64.29 148.58,64.09 PC215.1
G5335-SS-1: length 1.3
  BOTTOM w0.203: PU11.23 144.22,45 144.52,45.3 PC245.1
G5335-TON: length 2.7
  BOTTOM w0.254: PR244.1 142.57,64.06 v1(143.67,62.95) 144.26,63.54 PU10.6
G5335-TON-1: length 2.3
  BOTTOM w0.203: PR308.1 144.37,39.94 144.61,40.18 144.61,40.96 144.62,40.98 144.62,41.13 144.97,41.48 PU11.6
G5335-VCC: length 4.4
  BOTTOM w0.102: v1(150.61,63.12) PR245.2
  BOTTOM w0.254: PU10.21 148.16,65.29 148.24,65.22 148.24,65.21 148.98,64.46 PC212.1
  BOTTOM w0.381: PR245.2 149.77,63.94 149.52,64.2 PC212.1
G5335-VCC-1: length 3
  BOTTOM w0.254: PU11.21 143.22,45.36 143.72,45.86 PC243.1
  BOTTOM w0.457: PR293.2 144.24,46.5 143.98,46.24 PC243.1
G_MBCLK_R: length 3.8
  TOP w0.102: U17.4 65.66,15.67 v1(65.7,15.63) 65.6,15.54 C486.1 65.7,14.79 66.35,15.45 R386.1 R387.2
G_MBDATA_R: length 3.7
  TOP w0.102: U17.6 67.06,17.7 67.27,17.49 v1(67.27,16.98) 67.65,16.98 67.8,17.13 C478.1 68.13,16.49 68.01,16.37 R379.2 68.36,16.21 68.39,16.24 R378.1
G_WAKEB: length 9.5
  BOTTOM w0.102: U25.AU40 103.2,114.57 102.9,114.88 102.9,115.28 102.61,115.56 102.61,116.73 102.94,117.05 105.59,117.05 106.36,117.82 106.36,118.48 106.26,118.58 106.26,119.77 106.61,120.13 R465.2
GENERICA: length 8.4
  BOTTOM w0.102: TP48.1 99.73,117.94 98.36,116.57 98.36,114.82 98.74,114.44 98.74,114.26 99.93,113.07 U25.BA38
GENINT2: length 48.3
  TOP w0.102: R307.1 v1(122.11,25.51)
  IN2 w0.089: v1(122.11,25.51) 122.11,25.64 121.55,26.2 114.79,26.2 113.78,25.18 112.38,25.18 111.69,24.5 106.19,24.5 103.61,27.07 97.18,27.07 95.31,28.94 95.31,29.83 94.3,30.85 93.91,30.85 92.51,32.26 92.51,38.96 93.18,39.64 93.18,43.35 v2(92.13,44.4)
  BOTTOM w0.102: U30.AU14 92.13,44.41 v2(92.13,44.4)
GFX_TX0N_C: length 8.6
  BOTTOM w0.102: U30.F2 101.33,70.57 101.33,70.67 101.42,70.77 101.75,70.77 101.98,70.53 102.56,70.53 105.21,73.18 107.76,73.18 107.88,73.13 108.1,73.13 108.17,73.19 C594.2
GFX_TX0P_C: length 8.8
  BOTTOM w0.102: U30.F4 101.34,70.19 101.48,70.19 101.55,70.22 101.8,70.32 102.65,70.32 105.3,72.96 107.68,72.96 C596.2
GFX_TX1N_C: length 7.3
  BOTTOM w0.102: C592.2 106.07,74.09 105.13,74.09 102.4,71.36 102.23,71.36 102.06,71.18 101.68,71.18 101.32,71.54 100.88,71.54 100.83,71.49 U30.E4
GFX_TX1P_C: length 7.3
  BOTTOM w0.102: C593.2 106.16,73.87 105.22,73.87 102.49,71.14 102.32,71.14 102.15,70.97 101.59,70.97 101.23,71.32 100.97,71.32 100.87,71.23 100.87,71.12 U30.F3
GFX_TX2N_C: length 6.9
  BOTTOM w0.102: C590.2 106.11,75.78 105.26,75.78 104.77,75.29 104.77,74.73 102.09,72.05 101.91,72.05 101.8,72.15 U30.C1
GFX_TX2P_C: length 6.9
  BOTTOM w0.102: U30.E1 101.8,71.74 101.89,71.83 102.18,71.83 104.99,74.64 104.99,75.2 105.35,75.56 106.13,75.56 C591.2
GFX_TX3N_C: length 10.4
  BOTTOM w0.102: C589.2 106.14,77.2 105.85,77.2 103.22,74.57 102.01,74.57 101.74,74.31 101.74,72.96 101.46,72.68 101.46,72.17 101.11,71.82 100.5,71.82 100.24,71.56 99.57,71.56 U30.E6
GFX_TX3P_C: length 10.4
  BOTTOM w0.102: C587.2 106.1,77.42 105.76,77.42 103.13,74.79 101.92,74.79 101.52,74.4 101.52,73.05 101.24,72.77 101.24,72.26 101.02,72.04 100.41,72.04 100.15,71.78 99.91,71.78 99.86,71.83 99.86,71.94 U30.D5
GPF6: length 1.5
  TOP w0.102: U15.117 171.62,31.1 TP27.1
GPIO_0: length 10.2
  BOTTOM w0.102: v1(116.01,123.13) 116.01,122.01 115.48,121.47 R451.2 R460.2 115.48,120.31 115.76,120.03 115.76,118.72 113.41,116.37 113.41,114.87 113.33,114.79 113.33,114.55 U25.W40
GPIO_1: length 9.1
  BOTTOM w0.102: U25.AA40 112.23,114.55 112.23,114.8 112.33,114.9 112.33,116.85 113.04,117.56 113.04,119.34 112.99,119.39 112.99,120.11 113.04,120.15 113.04,121.37 113.5,121.83 R443.2 R441.2
GPIO_2: length 16.1
  TOP w0.102: v1(112.56,111.64) 113.09,112.18 113.09,112.73 113.22,112.86 113.22,113.78 119.01,119.57 v1(119.31,119.57) 119.82,120.08 120.25,120.08 120.51,119.82 120.86,119.82 120.97,119.92 R38.2 120.68,120.16 120.58,120.26 120.58,120.86 120.46,120.99 120.46,121.3 R26.2
  BOTTOM w0.102: v1(112.56,111.64) 112.24,111.32 U25.AA35
GPIO_8_ROMSO: length 25.3
  TOP w0.102: v1(109.13,118.22) 108.9,118.22 108.42,118.7 R24.2 TP5.1 107.86,122.51 R16.2 R17.1
  IN1 w0.089: v1(109.13,118.22) 109.13,118.2 108.72,117.79 108.72,117.44 110.11,116.05 110.11,114.98 109.15,114.03 107.88,114.03 107.45,113.6 107.45,112.58 106.49,111.62 106.49,108.95 104.96,107.43 104.33,107.43 103.57,106.67 103.57,106.29 104.38,105.47 v1(104.81,105.47)
  BOTTOM w0.102: U25.AP25 104.81,105.53 v1(104.81,105.47)
GPIO_9_ROMSI: length 28.6
  TOP w0.102: R32.1 118.65,121.37 TP6.1 v1(118.68,122.08)
  IN1 w0.089: v1(118.68,122.08) 118.68,119.47 117.11,117.89 116.34,117.89 116.04,118.2 114.41,118.2 109.9,113.69 109.9,112.24 109.54,111.87 108.52,111.87 107.76,111.11 107.76,108.83 106.87,107.94 106.87,105.9 106.41,105.45 v1(105.6,105.45)
  BOTTOM w0.102: v1(105.6,105.45) 105.6,105.52 U25.AM25 ; v1(118.68,122.08) 118.63,122.03 R445.2 118.02,122.32 117.92,122.41 R440.2
GPIO_10_ROMSCK: length 26.2
  TOP w0.102: R25.1 117.92,122.67 117.79,122.8 TP4.1 118.04,123.05 118.38,122.72 v1(118.68,122.72)
  IN1 w0.089: v1(106.26,106.46) 106.26,107.61 107.57,108.91 107.57,111.19 108.44,112.06 109.46,112.06 109.63,112.24 109.63,113.96 114.14,118.48 115.12,118.48 115.5,118.86 117.56,118.86 118.27,119.57 118.27,122.31 v1(118.68,122.72)
  BOTTOM w0.102: U25.AM27 106,106.72 v1(106.26,106.46)
GPIO_11: length 5.7
  BOTTOM w0.102: R470.2 R484.2 115.48,118.77 113.1,116.39 U25.W41
GPIO_12: length 6.3
  BOTTOM w0.102: U25.Y40 112.55,114.2 112.91,114.56 112.91,114.75 112.79,114.88 112.79,116.66 113.5,117.38 113.5,118.57 113.55,118.62 R483.2 113.55,119.39 113.5,119.44 R469.2
GPIO_13: length 7
  BOTTOM w0.102: R450.2 R459.2 113.5,120.42 113.27,120.19 113.27,120.06 113.22,120.01 113.22,119.48 113.27,119.44 113.27,117.47 112.56,116.76 112.56,116.4 112.55,116.39 U25.Y41
GPIO_15: length 11.6
  IN3 w0.089: v1(112.27,117.4) 112.71,117.84 112.71,120.64 112.2,121.14 112.2,122.01 113.02,122.82 113.02,123.76 v1(112.71,124.07)
  BOTTOM w0.102: R437.2 R438.2 112.84,123.94 v1(112.71,124.07) ; U25.AA41 112,117.13 v1(112.27,117.4)
GPIO_20: length 6.6
  BOTTOM w0.102: U25.AB40 111.45,114.22 111.77,114.54 111.77,114.79 111.69,114.87 111.69,117.46 112.08,117.84 112.46,117.84 112.76,118.14 R482.2 112.71,119.09 112.71,119.72 R468.2
GPIO_21_PCC: length 4.2
  BOTTOM w0.102: TP45.1 111.64,118.38 111.45,118.18 U25.AB41
GPIO_22_ROMCSB: length 28.8
  TOP w0.102: v1(109.15,117.59) 109.08,117.59 108.14,118.53 108.14,121.14 107.31,121.97 106.81,121.97 106.67,122.11 106.67,123.1 107.12,123.56 108.27,123.56 108.42,123.71 R8.2 TP1.1 107.86,124.16 R5.2 R6.1
  IN1 w0.089: v1(104.02,106.46) 104.74,107.17 105.47,107.17 107.38,109.08 107.38,112.13 107.66,112.41 107.66,113.42 108.01,113.78 109.18,113.78 110.3,114.9 110.3,116.45 v1(109.15,117.59)
  BOTTOM w0.102: v1(104.02,106.46) 104.02,107.25 104.2,107.43 104.8,107.43 U25.AP27
GPIO_28_FDO: length 15.9
  TOP w0.102: v1(114.74,112.56) 115.25,113.07 115.25,114.52 119.18,118.45 120.42,118.45 120.81,118.84 121.22,118.84 122.06,119.67 122.06,122.51 122.21,122.66 R22.1 R23.2
  BOTTOM w0.102: v1(114.74,112.56) 114.57,112.56 U25.U38
GPIO_29: length 18
  TOP w0.102: v1(113.62,112.45) 114.06,112.88 114.06,113.97 118.99,118.91 120.23,118.91 120.62,119.29 121.02,119.29 121.6,119.87 R11.2 121.88,123.33 122.06,123.51 122.06,124.62 121.83,124.86 R4.2
  BOTTOM w0.102: U25.W37 113.3,112.12 v1(113.62,112.45)
GPIO_30: length 17.5
  TOP w0.102: R3.1 120.56,124.86 120.46,124.75 120.46,123.43 120.56,123.33 R10.2 121.06,123.33 121.22,123.18 121.22,123.05 121.35,122.92 121.35,119.95 120.92,119.52 120.52,119.52 120.14,119.14 118.9,119.14 113.63,113.87 v1(113.63,113.16)
  BOTTOM w0.102: v1(113.63,113.16) 113.39,112.92 U25.W38
GPIO_5441: length 4.7
  TOP w0.102: U19.23 18.11,18.26 v1(17.38,18.99) 17.21,19.16 17.21,20.56 16.98,20.79 R338.2 R337.2
GPIO_SVC: length 10.2
  TOP w0.102: R98.2 95.79,98.61 97.24,100.06 98.1,100.06 99.78,101.74 102.86,101.74 v1(103.26,102.14)
  BOTTOM w0.102: v1(103.26,102.14) 103.6,101.8 U25.AU17
GPIO_SVD: length 10.4
  TOP w0.102: v1(102.47,102.17) 102.27,101.97 99.5,101.97 97.82,100.29 97.15,100.29 95.39,98.54 94.8,98.54 94.65,98.38 R97.2
  BOTTOM w0.102: v1(102.47,102.17) 102.8,101.84 U25.AV17
GPIO_SVT: length 13.3
  TOP w0.102: R96.2 93.96,98.62 94.56,98.62 94.73,98.79 95.32,98.79 97.1,100.57 97.78,100.57 99.4,102.2 101.38,102.2 101.79,102.6 103.57,102.6 v1(104.02,102.14)
  BOTTOM w0.102: U25.AR17 104.4,101.77 v1(104.02,102.14)
GPU_CLR_REQ6#: length 27.6
  TOP w0.102: v1(90.87,38.09) 90,37.22 90,33.26 89.34,32.6 89.34,30.42 89.5,30.26 89.5,28.99 89.72,28.76 R301.2 89.96,28.62 89.7,28.35 R300.1 89.7,27.83 89.82,27.71 v1(89.82,26.2) Q17.3
  IN2 w0.089: v1(90.87,38.09) 91.55,38.77 91.55,39.38 91.76,39.58 91.76,41.9 91.63,42.02 91.63,47.89 v2(91.14,48.38)
  BOTTOM w0.102: v2(91.14,48.38) 91.51,48.02 U30.AN15
GPU_EDP_HPD: length 6.6
  TOP w0.102: TP13.1 97.85,102.86 100.77,102.86 102.17,104.25 v1(102.42,104.25)
  BOTTOM w0.102: v1(102.42,104.25) 102.8,103.87 U25.AV21
GPU_GPIO6: length 28.1
  TOP w0.102: v1(130.24,120.43) 129.7,120.97 R34.1 129.7,121.3 129.25,121.75 R29.1 129.25,122.06 129.7,122.51 R19.2 R15.1 130.11,123.43 130.4,123.14 D1.2 D2.2
  IN1 w0.089: v1(130.24,120.43) 129.68,119.87 126.9,119.87 126.01,118.99 124.01,118.99 123.18,118.15 119.31,118.15 115.25,114.09 115.25,111.37 v1(114.74,110.86)
  BOTTOM w0.102: v1(114.74,110.86) 114.67,110.86 U25.U35
GPU_PCIE_CLKREQ#: length 156.8
  TOP w0.102: R37.2 106.46,120.26 v1(105.69,119.48) ; Q17.1 90.96,24.05 90.55,24.46 90.55,28.52 90.41,28.67 R301.1 90.41,29.53 90.23,29.7 90.23,30.72 v1(89.98,30.97)
  IN1 w0.089: v1(105.69,119.48) 105.69,118.82 104.68,117.82 101.24,117.82 100.77,117.35 99.12,117.35 97.47,115.7 97.47,115.68 97.29,115.51 93.23,115.51 90.02,118.72 86.18,118.72 83.57,116.1 75.63,116.1 74.99,115.47 74.99,113.88 75.44,113.44 75.44,108.27 77,106.71 77,105.39 77.55,104.84 77.86,104.84 78.07,104.63 78.07,103.9 77.15,102.98 77.15,99.67 80.56,96.26 85.52,96.26 92.77,89.01 92.77,88.12 94.8,86.09 94.8,83.43 v1(95.44,82.79)
  IN3 w0.089: v1(95.44,82.79) 94.42,81.77 94.42,73.9 92.77,72.25 92.77,70.92 92.58,70.73 92.58,65.96 92.9,65.65 93.15,65.65 93.48,65.31 93.48,58.56 93.28,58.36 93.28,50.09 94.6,48.77 94.6,42.23 94.04,41.67 94.04,37.96 91.48,35.39 91.48,32.35 90.1,30.97 v1(89.98,30.97)
  BOTTOM w0.102: R464.2 105.85,119.65 v1(105.69,119.48) 105.59,119.48 105.29,119.19 105.29,118.22 104.53,117.46 101.79,117.46 101.53,117.21 101.53,117.03 101.26,116.75 101.26,116.09 101.67,115.67 101.67,114.83 101.79,114.72 101.79,114.21 102.03,113.97 U25.AV40
GPU_PWM_PROCHOT#: length 88.9
  TOP w0.102: PR24.1 70.11,108.98 v1(70.06,109.03) ; D2.1 132.9,122.07 132.9,123.56 132.65,123.81 129.35,123.81 129.25,123.71 R15.2 R14.1 128.68,123.71 128.59,123.81 v1(127.06,123.81) v1(126.3,123.05)
  IN1 w0.089: v1(126.3,123.05) 123.76,123.05 123.25,123.56 123.25,124.67 122.74,125.18 122.74,125.34 122.21,125.87 106.89,125.87 106.69,125.67 106.69,125.2 106.17,124.68 106.17,122.99 105.6,122.41 103.95,122.41 102.04,120.51 102.04,119.87 101.41,119.24 100.65,119.24 100.04,118.63 95.85,118.63 94.93,117.72 92.83,117.72 90.29,120.26 85.91,120.26 85.15,119.49 75.12,119.49 73.77,120.84 70.87,120.84 67.88,117.85 67.88,111.21 v1(70.06,109.03)
HDDPWRON: length 31.9
  TOP w0.102: v1(199.22,16.85) 199.66,16.42 201.33,16.42 201.71,16.04 201.71,14.86 R402.1 201.42,14.57 Q25.2 202,13.46 202.76,14.22 R404.2 ; U15.83 182.01,22.96 182.59,23.53 182.84,23.53 183.12,23.81 183.12,24.8 v1(183.32,25.01)
  IN2 w0.089: v1(199.22,16.85) 199.22,17.36 198.86,17.73 196.62,17.73 193.87,20.47 192.03,20.47 190.71,21.79 190.71,23.44 189.31,24.84 186.28,24.84 185.86,25.26 183.58,25.26 v1(183.32,25.01)
HDMI_HPD: length 10.2
  BOTTOM w0.102: CN4.19 10.05,81.35 10.72,82.02 C574.1 RV5.1 15.12,81.69 15.12,80.81 15.43,80.5 15.81,80.5 16.83,79.49 16.83,79.36 17.12,79.07 U28.21
HDMI_HPD_CON: length 106.1
  TOP w0.102: v1(26.35,83.68) 26.25,83.58 25.61,83.58 24.57,82.54 24.57,81.29 R141.1
  IN1 w0.089: v1(26.35,83.68) 26.86,83.68 27.87,84.7 27.87,89.52 31.3,92.95 42.73,92.95 42.99,93.2 49.97,93.2 51.12,94.35 51.12,96.07 52.59,97.55 52.92,97.55 53.83,98.46 55.26,98.46 55.56,98.16 57.97,98.16 58.48,97.65 59.75,97.65 61.91,95.49 62.93,95.49 69.91,88.51 v1(69.91,88.12)
  IN2 w0.089: v1(87.23,83.2) 87.23,84.24 87.82,84.82 88.83,84.82 89.39,84.26 89.39,82.97 88.96,82.54 88.96,80 88.45,79.49 87.56,79.49 86.04,77.96 86.04,71.87 85.53,71.36 85.53,67.42 86.06,66.9 v2(86.06,66.45)
  IN3 w0.089: v1(69.91,88.12) 70.17,88.12 72.07,86.22 80.22,86.22 81.85,84.59 85,84.59 86.39,83.2 v1(87.23,83.2)
  BOTTOM w0.102: R533.2 v1(87.23,83.2)
  BOTTOM w0.112: v2(86.06,66.45) 86.16,66.45 U30.L21
HDMI_HPD_DC: length 4.4
  TOP w0.102: v1(24.34,79.07) 24.33,79.06 v1(23.71,79.06) 23.68,79.08 23.68,80.25 23.97,80.53 R141.2 23.97,81.42 24.06,81.52 R138.1
  BOTTOM w0.102: U28.40 v1(24.34,79.07)
HDMI_HPD_PCH: length 10.2
  BOTTOM w0.102: U25.AU25 102.92,105.24 102.07,105.24 101.89,105.07 101.61,105.07 101.53,105.15 101.29,105.15 101.2,105.07 100.9,105.07 100.8,105.17 100.29,105.17 99.25,104.13 99.25,102.22 97.34,100.32 TP50.1
HDMI_RST#: length 6.2
  BOTTOM w0.102: v1(22.34,84.06) 22.19,83.91 R534.2 22.39,83.4 22.55,83.23 22.55,82.98 22.72,82.82 C573.1 23.86,82.82 24.12,82.56 24.12,82.05 23.91,81.85 23.23,81.85 23.02,81.65 22.39,81.65 22.33,81.59 U28.35
HDMI_SCLK: length 36.8
  TOP w0.102: v1(18.46,89.25) Q6.3 17.33,87.87 16.44,88.76 15.43,88.76 15,88.33 15,87.18 14.7,86.88 R121.1 13.69,86.88 RV1.1 v1(13.65,85.84)
  IN1 w0.089: v1(20.51,73.65) 20.92,73.65 21.14,73.87 21.14,76.01 21.32,76.19 21.32,82.36 20.66,83.02 20.66,83.6 19.11,85.15 19.11,88.6 v1(18.46,89.25)
  IN2 w0.089: v1(13.65,85.84) 13.65,83.43 11.87,81.65 11.49,81.65 10.86,81.01 10.86,79.51 CN4.15
  BOTTOM w0.102: v1(20.51,73.65) 20.27,73.88 20.27,74.43 20.33,74.49 U28.7
HDMI_SDATA: length 34.1
  TOP w0.102: v1(14.42,85.83) RV2.1 16.41,86.85 R122.1 v1(17.51,86.88) 19.46,86.88 19.76,86.59 Q6.6 20.26,85.83 v1(20.51,85.58)
  IN1 w0.089: v1(20.51,85.58) 20.51,86.09 20.13,86.47 19.62,86.47 19.49,86.35 19.49,85.33 21.02,83.81 21.02,83.17 21.65,82.54 21.65,76.05 21.52,75.92 21.52,73.77 v1(20.89,73.14)
  IN2 w0.089: CN4.16 12.25,79.85 12.25,81.52 14.03,83.3 14.03,85.45 v1(14.42,85.83)
  BOTTOM w0.102: U28.8 19.93,73.59 20.38,73.14 v1(20.89,73.14)
HDMI_SEL#_A1: length 1.8
  BOTTOM w0.102: U28.32 21.13,81.51 21.4,81.77 21.4,82.05 21.17,82.28 R536.2
HDT_APU_TDI: length 11.1
  BOTTOM w0.102: R599.1 v1(111.44,40.63) 112,41.18 112,43.06 112.25,43.32 112.25,45.76 112.13,45.88 112.13,46.19 111.87,46.44 111.57,46.44 111.42,46.6 111.42,47.08 112.46,48.12 112.46,48.25 112.84,48.63 113.85,48.63
HDT_DBREQ#: length 8.8
  TOP w0.102: v1(115.84,41.39) 116.01,41.57 R219.1
  BOTTOM w0.102: v1(111.19,39.08) 111.64,39.08 112.23,39.66 112.23,42.18 112.33,42.28 CN7.16 115.63,42.28 115.84,42.07 v1(115.84,41.39)
HDT_TRST#: length 9.1
  TOP w0.102: v1(119.82,44.94) 119.77,44.89 117.08,44.89 116.42,44.23 115.71,44.23 115.25,44.69 114.14,44.69 R214.2
  BOTTOM w0.102: 117.92,46.09 118.93,46.09 119.82,45.2 v1(119.82,44.94)
HEPWR: length 10.4
  TOP w0.508: v1(46.29,122.29) 46.25,122.33 HE2.2 ; v1(36.38,122.59) 36.38,122.8 35.85,123.33 HE1.2
  BOTTOM w0.508: v1(46.29,122.29) 45.4,122.29 44.89,121.78 43.88,121.78 43.11,122.54 39.64,122.54
HP-L2: length 19
  IN3 w0.381: v1(207.17,35.67) 207.1,35.6 207.1,34.5 206.06,33.46 206.06,29.95 206.64,29.36 206.64,26.99 207.83,25.79 v1(207.83,25.64)
  BOTTOM w0.203: v1(207.83,25.64) 207.83,25.77 207.47,26.13 207.02,26.13 206.94,26.06 U35.32
  BOTTOM w0.381: R608.2 210.49,37.45 210.24,37.2 R613.1 209.87,36.18 209.64,35.96 R612.2 208.49,35.96 v1(208.32,36.13) 208.16,36.13 207.96,35.93 C631.2 207.94,35.13 207.39,35.67 v1(207.17,35.67)
HP-L3: length 5.2
  BOTTOM w0.305: CN8.4 212.52,41.4
  BOTTOM w0.381: 212.52,41.4 212.25,41.13 212.15,41.13 v1(211.27,40.25) C621.2 R608.1
HP-R2: length 18.9
  IN3 w0.381: v1(207.2,25.64) 206.89,25.94 206.34,25.94 205.75,26.53 205.75,28.99 205.17,29.58 205.17,33.83 206.16,34.83 206.16,35.92 206.81,36.56 v1(207.33,36.56)
  BOTTOM w0.203: v1(207.2,25.64) 207.09,25.64 207.07,25.66 U35.33 ; 206.95,37.45 R609.2 206.66,36.94
  BOTTOM w0.381: 206.95,37.45 207.21,37.19 R606.1 208.32,37.19 R607.2 ; 206.66,36.94 206.44,36.72 C626.2 207.04,36.27 v1(207.33,36.56)
HP-R3: length 7
  BOTTOM w0.305: 212.28,42.1 212.58,42.4 CN8.2
  BOTTOM w0.381: 212.28,42.1 211.97,42.1 v1(209.48,39.61) 209.48,38.6 C620.2 R607.1
HP_JD#: length 17.7
  IN1 w0.381: v1(201.61,31.23) 201.61,30.97 202.5,30.09 204.15,30.09 206.44,32.37 207.96,32.37 208.85,33.26 210.37,33.26 211.06,33.95 211.06,36.33 211.67,36.94 v1(212.02,36.94)
  BOTTOM w0.254: v1(212.02,36.94) 212.53,36.94 212.58,36.9 CN8.13
  BOTTOM w0.381: R651.2 201.15,32 201.61,31.54 v1(201.61,31.23)
HSYNC: length 17.1
  TOP w0.102: R35.2 122.49,120.51 122.34,120.36 122.34,119.39 122.46,119.27 R41.2 122.74,118.96 122.36,118.58 120.87,118.58 120.52,118.22 119.28,118.22 116.27,115.21 116.27,112.38 116.06,112.18 115.48,112.18 115.38,112.08 114.54,112.08 114.18,111.72 114.18,111.52 v1(113.63,110.96)
  BOTTOM w0.102: U25.W34 113.19,110.52 v1(113.63,110.96)
HWPG: length 38.1
  TOP w0.102: U15.21 164.45,20.16 v1(164.37,20.08) ; D23.2 158.25,11.92 159.35,13.02 159.35,14.35 R385.2 159.48,14.84 159,15.31 D22.2 D21.2 D20.2 D19.2 D18.2 152.26,15.85 152.12,15.99 v1(150.05,15.99) 148.91,15.99 148.63,16.27 148.63,16.66 148.27,17.02 148.27,18.27 148.52,18.53 149.41,18.53 149.54,18.66 v1(149.67,18.66) 149.67,18.78 149.77,18.88 149.77,19.52 150.05,19.8 Q19.5
  IN1 w0.089: v1(164.37,20.08) 163.67,20.08 162.8,19.21 150.23,19.21 v1(149.67,18.66)
HWPG_1.5V: length 66.4
  TOP w0.102: D22.1 157.91,13.61 v1(157.75,13.45) ; PR79.1 194.91,30.98 195.26,31.33 PR75.2 195.05,31.38 194.8,31.63 194.8,33.79 194.42,34.17 193.58,34.17 192.97,33.56 v1(192.97,32.09) 192.7,31.81 192.7,30.81 191.68,29.8 191.68,27.9 190.92,27.14 190.92,23.6 191.53,22.99 191.53,20.66 192.49,19.69 192.49,17.59 191.88,16.98 191.88,15.35 191.53,14.99 191.53,11.62 v1(191.32,11.42)
  IN1 w0.089: v1(157.75,13.45) 158.51,13.45 159.91,12.04 167.91,12.04 168.42,12.55 186.62,12.55 187.51,13.45 189.29,13.45 v1(191.32,11.42)
