# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TPDAT-1: length 4.2
  BOTTOM w0.102: CN12.3 74.32,21.61 73.34,22.59 v1(73.34,22.77) C661.1 73.1,23.6 72.47,22.96 L11.2
TPDATA: length 121.4
  TOP w0.102: U15.90 179.9,25.76 v1(179.44,26.22)
  IN2 w0.089: v1(71.56,22.34) 72.19,21.72 77.91,21.72 78.74,22.54 90.84,22.54 93.44,19.94 97.29,19.94 99.24,17.99 109.38,17.99 112.2,20.81 123.73,20.81 123.83,20.92 128.95,20.92 129.09,20.78 131.34,20.78 131.53,20.97 131.53,21.22 132.19,21.88 140.73,21.88 142.16,23.32 144.54,23.32 146.18,24.95 156,24.95 157.51,23.44 162.07,23.44 162.61,23.98 165.12,23.98 165.81,24.66 169.33,24.66 169.79,24.2 171.98,24.2 172.95,25.17 177.29,25.17 177.94,25.82 179.03,25.82 v1(179.44,26.22)
  BOTTOM w0.102: L11.1 72.22,24.09 71.97,24.34 R674.2 71.69,24.47 71.69,22.47 v1(71.56,22.34)
TPM_LRESET#: length 2.4
  TOP w0.102: U16.17 122.62,23.1 122.26,23.46 122.26,24.11 122.67,24.53 R308.2
TPM_PIRQ: length 2.7
  TOP w0.102: R307.2 122.11,24.37 121.98,24.24 121.98,23.2 122.59,22.6 U16.18
TRA_V_DAC: length 17.8
  TOP w0.508: C100.1 29.14,102.35 29.14,102.34 29.14,102.07 v1(29.65,101.56)
  BOTTOM w0.508: 34.99,100.82 34.9,100.91 U24.4 ; 34.99,100.82 32.07,100.82 ; 34.99,100.82 36.95,100.82 37.9,101.77 U24.1 ; 32.07,100.82 31.9,100.99 U24.7 ; 32.07,100.82 30.16,100.82 29.65,101.33 v1(29.65,101.56) 29.41,101.56 28.9,102.07 U24.10
TS_EN: length 219
  TOP w0.102: R75.1 57.69,105.81 57.59,105.9 57.59,106.54 57.77,106.72 59.02,106.72 59.24,106.95 59.24,107.05 59.57,107.38 61.1,107.38 61.43,107.71 v1(61.43,108.42) ; R319.1 185.81,23.1 v1(185.94,23.23)
  IN3 w0.089: v1(185.94,23.23) 185.23,23.23 184.9,23.56 182.48,23.56 181.61,24.43 181.61,26.14 181.01,26.74 178.38,26.74 177.54,25.89 172.78,25.89 170.62,28.05 170.62,28.69 170.12,29.2 165.54,29.2 165.37,29.37 163.43,29.37 162.67,28.61 159.5,28.61 158.56,27.68 158.56,27.09 158.22,26.74 157.06,26.74 156.72,26.4 154.87,26.4 154.48,26.8 144.5,26.8 141.35,29.95 141.35,32.67 142.06,33.38 142.06,35.26 141.55,35.78 139.1,35.78 136.39,38.49 130.38,38.49 128.49,40.37 126.05,40.37 124.65,41.77 124.65,45.45 123.72,46.38 123.72,62.92 125.16,64.36 125.16,67.3 125.41,67.55 125.41,72.06 124.73,72.75 118.36,72.75 117.24,73.86 117.24,76.48 117.07,76.66 115.82,76.66 112.66,79.82 110.9,79.82 108.58,82.14 108.58,88.56 106.8,90.33 106.8,91.82 105.71,92.91 103.05,92.91 97.92,98.03 94.04,98.03 92.73,96.72 83.04,96.72 82.61,97.14 77.79,97.14 76.43,98.49 76.43,103.12 75.14,104.41 75.14,107.05 74.81,107.38 74.81,108.53 74.13,109.21 72.1,109.21 70.93,110.38 70.93,111.52 69.71,112.74 67.78,112.74 66.86,113.65 65.97,113.65 64.83,114.79 64.83,114.92 64.19,115.56 63.88,115.56 63.45,115.13 61.42,115.13 v1(61.02,115.53)
  BOTTOM w0.102: v1(61.02,115.53) 61.02,108.83 v1(61.43,108.42)
TS_EN_C: length 4.3
  TOP w0.102: R319.2 185,23 184.72,22.72 184.08,22.72 183.82,22.46 C424.1 182.87,22.46 v1(182.74,22.59) 182.3,22.16 U15.81
TS_EN_R: length 16.9
  TOP w0.102: R86.2 61.53,101.33 v1(61.94,100.93) 62.04,100.82 62.04,100.16 61.83,99.96 61.83,98.97 61.76,98.89 60.74,98.89 60.66,98.97 59.19,98.97 59.04,99.12 v1(59.04,100.95) ; R75.2 57.24,106.19 v1(57.15,106.28)
  BOTTOM w0.102: v1(59.04,100.95) 58.61,100.52 57.9,100.52 57.72,100.7 57.72,101.13 57.92,101.33 57.92,104.3 57.59,104.63 57.57,104.63 57.34,104.86 57.34,106.09 v1(57.15,106.28) 57.22,106.35 CN2.28
TS_INT#: length 13.4
  TOP w0.102: R87.2 62.77,101.61 63.08,101.31 63.08,101.07 v1(63.58,100.57) Q4.1
  BOTTOM w0.102: CN2.37 v1(61.72,105.95) 61.72,105.74 62.37,105.09 64.37,105.09 65.47,104 65.47,103.36 65.29,103.19 63.89,103.19 63.58,102.87 v1(63.58,100.57)
TS_PWR: length 193
  TOP w0.102: R210.2 R211.2 108.69,43.58 108.9,43.37 109.26,43.37 109.28,43.39 109.59,43.39 110.03,42.95 112.12,42.95 112.36,43.19 114.2,43.19 115.16,42.23 115.16,39.72 115,39.56 114.29,39.56 v1(113.68,38.95) ; Q42.1 88.16,125.78 86.66,124.28 v1(86.05,124.28) ; R80.1 58.13,104.67 ; 58.13,104.67 58.71,105.25 C74.1 58.71,105.75 58.81,105.85 59.58,105.85 C67.2 R81.2 60.58,103.9 v1(60.72,103.9) 60.72,103.69 61.2,103.21 61.2,102.88 61.23,102.86 61.23,102.52 R85.1 R86.1 R87.1 62.7,102.07 62.99,101.77 Q4.2 65.53,101.77 66.23,101.08 66.23,99.24 69.25,96.22 69.25,95.59 71.23,93.61 72.66,93.61 73.37,92.91 73.37,92.35 76.35,89.37 81.82,89.37 86.87,84.31 87.18,84.31 87.92,85.05 91.43,85.05 92.24,85.86 93.05,85.86 93.63,85.28 96.25,85.28 97.22,84.31 99.17,84.31 v1(100.16,83.32) ; 58.13,104.67 58.15,104.64 58.96,104.64 v1(58.96,104.63)
  IN1 w0.089: v1(61.96,116.8) 61.96,116.9 61.61,117.26 61.61,119.28 62.65,120.32 62.65,122.04 61.17,123.52 61.17,125.96 61.59,126.38 75.65,126.38 78.07,123.96 81.55,123.96 81.93,123.58 85.36,123.58 v1(86.05,124.28) ; v1(100.16,83.32) 99.99,83.15 99.99,79.26 101.66,77.58 101.66,73.01 100.01,71.36 100.01,70.85 100.14,70.73 100.14,70.34 99.86,70.06 99.5,70.06 99.43,70.14 98.41,70.14 98.3,70.03 97.54,70.03 96.84,69.33 95.74,69.33 95.26,68.85 95.26,67.37 95.76,66.88 98.4,66.88 99.25,66.03 100.14,66.03 100.65,65.52 102.6,65.52 110.6,57.51 110.6,54.78 112.46,52.93 112.46,50.54 114.16,48.84 114.16,39.43 v1(113.68,38.95)
  BOTTOM w0.102: v1(61.96,116.8) 61.35,116.19 61.07,116.19 60.46,115.58 60.46,109.33 58.72,107.59 CN2.31 58.72,106.73 58.48,106.49 58.48,105.12 v1(58.96,104.63) 59.02,104.58 59.02,102.14 59.19,101.97 R519.2
TS_RST#: length 6.5
  TOP w0.102: R84.1 58.85,101.74 57.91,102.68 57.91,103.37 57.37,103.91 57.37,104.64 57.97,105.24 57.97,106.21 v1(58.05,106.29)
  BOTTOM w0.102: v1(58.05,106.29) 58.22,106.46 CN2.30
TSPWRON#: length 204.2
  TOP w0.102: v1(92.75,125.92) 92.75,125.67 92.95,125.46 92.95,124.8 92.03,123.88 Q42.2 90.95,123.15 88.76,123.15 88.66,123.25 v1(88.61,123.25) 88.61,123.71 88.26,124.06 R735.1 ; U15.109 174.82,28.74 v1(174.64,28.56)
  IN3 w0.089: v1(88.61,123.25) 88.61,123.81 89.27,124.47 92.85,124.47 95.18,126.81 99.45,126.81 99.64,126.62 114.33,126.62 114.93,126.02 122.08,126.02 123.63,124.47 132.95,124.47 133.44,124.95 137.02,124.95 139.89,122.08 142.28,122.08 145.98,118.38 149.54,118.38 150.28,117.64 150.28,77.76 149.95,77.43 149.95,61.44 151.34,60.04 151.34,56.96 152.97,55.33 152.97,53.07 154.65,51.4 154.65,49.85 150.68,45.88 150.68,45.22 151.34,44.56 151.34,41.32 151.95,40.71 151.95,40.02 153.36,38.62 153.94,38.62 156.55,36 161.24,36 162.77,37.53 166.59,37.53 169,35.11 171.87,35.11 172.93,34.05 173.85,34.05 174.38,33.51 181.88,33.51 182.15,33.23 v1(182.15,33.03)
  BOTTOM w0.102: v1(182.15,33.03) 181.49,32.37 178.75,32.37 178.5,32.12 178.5,30.72 178.12,30.34 178.12,28.64 177.66,28.18 175.02,28.18 v1(174.64,28.56)
TX0_HDMI+: length 13.5
  TOP w0.102: R154.2 14.92,78.6 15.1,78.78 15.43,78.78 v1(15.48,78.73)
  BOTTOM w0.102: CN4.7 10.41,75.06 10.74,75.06 10.98,75.3 10.98,80.5 11.36,80.89 11.75,80.89 12.2,80.43 12.2,79.28 12.75,78.73 13.31,78.73 13.45,78.59 U27.9 U27.2 15.34,78.59 v1(15.48,78.73)
TX0_HDMI-: length 13.6
  TOP w0.102: v1(15.48,79.41) 15.43,79.36 R148.2
  BOTTOM w0.102: v1(15.48,79.41) 15.16,79.09 U27.1 U27.10 13.45,79.09 13.31,78.95 12.84,78.95 12.42,79.37 12.42,80.52 11.84,81.1 11.28,81.1 10.77,80.59 10.77,75.39 10.65,75.27 10.48,75.27 CN4.9
TX1_HDMI+: length 14.9
  TOP w0.102: R149.2 18.81,79.11 19.2,78.71 19.2,77.04 18.68,76.52 18.68,74.97 18.38,74.67 v1(17.82,74.67)
  BOTTOM w0.102: v1(17.82,74.67) 17.67,74.81 17.06,74.81 16.78,74.54 16.19,74.54 15.26,75.46 15.09,75.46 14.99,75.37 U29.7 U29.4 13.33,75.37 13.19,75.51 12.97,75.51 12.47,75.01 12.47,73.84 12.23,73.59 11.99,73.59 CN4.4
TX1_HDMI-: length 14.8
  TOP w0.102: v1(17.82,75.3) 18.24,74.88 18.29,74.88 18.46,75.06 18.46,76.6 18.98,77.13 18.98,78.62 18.72,78.89 18.29,78.89 17.94,78.54 R155.2
  BOTTOM w0.102: v1(17.82,75.3) 17.82,75.27 17.58,75.03 16.97,75.03 16.69,74.75 16.28,74.75 15.35,75.68 15.18,75.68 14.99,75.87 U29.6 U29.5 13.33,75.87 13.19,75.72 12.88,75.72 12.25,75.09 12.25,73.93 12.14,73.81 11.99,73.81 CN4.6
TX2_HDMI+: length 20.5
  TOP w0.102: v1(15.59,73.7) 15.61,73.67 16.29,73.67 16.34,73.72 18.32,73.72 18.62,73.6 19.19,73.6 19.96,74.37 19.96,79.32 18.71,80.58 R143.2
  BOTTOM w0.102: CN4.1 10.26,71.91 10.74,71.91 11.35,71.3 12.44,71.3 13.14,72 13.14,73.76 13.24,73.87 U29.1 U29.10 15.03,73.87 15.1,73.94 15.55,73.94 15.59,73.9 v1(15.59,73.7)
TX2_HDMI-: length 20.5
  TOP w0.102: R146.2 17.94,80.11 18.04,80.21 18.15,80.21 18.3,80.36 18.62,80.36 19.75,79.23 19.75,74.46 19.1,73.81 18.67,73.81 18.36,73.94 16.27,73.94 v1(16.09,74.11)
  BOTTOM w0.102: CN4.3 10.05,72.4 10.16,72.29 10.31,72.29 10.48,72.12 10.83,72.12 11.44,71.51 12.36,71.51 12.93,72.08 12.93,73.85 13.15,74.08 13.27,74.08 13.56,74.37 U29.2 U29.9 15.07,74.37 15.28,74.15 16.05,74.15 v1(16.09,74.11)
TXC_HDMI+: length 10.3
  TOP w0.102: R169.1 14.64,75.4 14.31,75.4 C206.2 13.75,75.4 13.47,75.4 13.36,75.51 13.36,76.61 14.1,77.34 15.12,77.34 v1(15.47,76.99)
  BOTTOM w0.102: v1(15.47,76.99) 15.37,77.09 U27.5 U27.6 13.63,77.09 13.43,77.3 13.29,77.3 12.97,76.98 12.22,76.98 12.07,76.83 12.07,76.67 CN4.10
TXC_HDMI-: length 10.4
  TOP w0.102: R171.1 14.64,75.19 14.31,75.19 C206.1 13.75,75.19 13.38,75.19 13.14,75.42 13.14,76.7 14.01,77.56 15.39,77.56 v1(15.47,77.64)
  BOTTOM w0.102: CN4.12 12.88,77.2 13.2,77.51 13.45,77.51 13.53,77.59 U27.7 U27.4 15.42,77.59 v1(15.47,77.64)
TYPEC1_DDI1_HPD: length 7.9
  TOP w0.102: TP14.1 98.7,102.44 100.96,102.44 102.26,103.75 102.68,103.75 v1(103.19,104.25)
  BOTTOM w0.102: v1(103.19,104.25) 103.6,103.84 U25.AU21
TYPEC_SBU1: length 9.3
  TOP w0.102: TP39.1 11.24,13.64 D24.2 v1(11.23,14.48)
  IN3 w0.089: v1(11.23,14.48) 10.35,15.36 10.35,17.77 9.94,18.17 9.38,18.17 8.22,17 v1(7.94,17)
  BOTTOM w0.102: v1(7.94,17) 7.58,16.65 CN15.A8
TYPEC_SBU2: length 13.3
  IN3 w0.089: v1(11.06,17.87) 10.52,17.87 9.96,18.43 9.36,18.43 8.57,17.64 7.81,17.64 7.47,17.3 7.47,14.74 6.74,14.01 6.74,13.96 6.11,13.96 5.23,14.84 CN15.B8
  BOTTOM w0.102: TP86.1 10.35,20.12 11.29,19.17 D36.2 11.11,18.66 11.11,17.92 v1(11.06,17.87)
TYPEC_STRAP: length 5.9
  TOP w0.102: R339.2 184,20.86 185.15,20.86 185.58,20.43 v1(185.69,20.43) ; R339.2 183.33,20.43 183.32,20.42 182.95,20.42 182.82,20.56 U15.77 ; R339.2 R332.1
UART0_RXD: length 6.8
  BOTTOM w0.099: U30.BA17 90,41.53 90.31,41.23 90.31,40.95 90.1,40.73 90.1,40.23 90.01,40.14
  BOTTOM w0.102: TP64.1 89.34,35.62 89.34,36.89 89.88,37.43 89.88,39.26 90.01,39.39 90.01,40.14
UART0_TXD: length 4.6
  BOTTOM w0.089: 90.91,39.57 91.04,39.71 91.04,40.32 91,40.36 91,41.09 U30.BC16
  BOTTOM w0.102: TP65.1 90.36,37.32 90.36,38.59 90.73,38.96 90.73,39.4 90.91,39.57
USB3_SS0RX+: length 2
  BOTTOM w0.102: U39.8 16.17,17 16.05,17.12 16.05,17.45 15.79,17.72 15.79,18.05 15.91,18.18 C695.2
USB3_SS0RX+_RE: length 3.4
  BOTTOM w0.102: C703.1 13.98,13.98 13.98,14.18 14.04,14.24 14.29,14.24 14.49,14.04 15.7,14.04 16.17,14.52 U39.4
USB3_SS0RX+_RE_C: length 8.2
  TOP w0.102: U19.5 16.23,14.86 16.1,14.98 16.1,15.06 16.02,15.14 15.8,15.14 15.68,15.02 15.68,13.73 15.44,13.49 15.04,13.49 14.93,13.38 R408.1 14.46,13.41 13.79,13.41 13.49,13.1 13.49,12.45 v1(13.7,12.24)
  BOTTOM w0.102: v1(13.7,12.24) 13.52,12.41 13.52,12.69 13.87,13.03 13.87,13.25 13.97,13.35 C703.2
USB3_SS0RX-: length 2
  BOTTOM w0.102: U39.7 15.77,17.09 15.84,17.16 15.84,17.36 15.57,17.63 15.57,18.07 15.47,18.18 C694.2
USB3_SS0RX-_RE: length 3.4
  BOTTOM w0.102: C702.1 13.77,14.17 13.77,14.27 13.96,14.46 14.38,14.46 14.58,14.26 15.61,14.26 15.77,14.43 U39.5
USB3_SS0RX-_RE_C: length 8.2
  TOP w0.102: v1(13.06,12.24) 13.27,12.45 13.27,13.19 13.7,13.63 14.47,13.63 R401.1 14.93,13.82 15.05,13.7 15.35,13.7 15.47,13.82 15.47,15.11 15.71,15.36 U19.4
  BOTTOM w0.102: v1(13.06,12.24) 13.31,12.49 13.31,12.78 13.65,13.12 13.65,13.25 13.55,13.35 C702.2
USB3_SS0TX+: length 2.1
  BOTTOM w0.102: U39.11 17.37,16.97 17.28,17.06 17.28,17.33 17.7,17.75 17.7,18.07 17.8,18.18 C697.2
USB3_SS0TX+_RE: length 1.6
  BOTTOM w0.102: U39.1 17.37,14.5 17.24,14.37 17.24,13.77 C706.1
USB3_SS0TX+_RE_C: length 7.7
  TOP w0.102: v1(16.81,10.65) 16.6,10.85 16.6,11.58 R416.1 16.74,12.4 16.74,12.67 17.21,13.14 17.21,13.85 17.33,13.98 17.45,13.98 17.61,13.82 U19.7
  BOTTOM w0.102: C706.2 17.24,13.1 17.14,12.99 17.14,12.24 16.6,11.7 16.6,10.86 v1(16.81,10.65)
USB3_SS0TX-: length 2.1
  BOTTOM w0.102: U39.10 16.97,17.02 17.06,17.12 17.06,17.42 17.49,17.84 17.49,18.05 17.36,18.18 C696.2
USB3_SS0TX-_RE: length 1.6
  BOTTOM w0.102: C705.1 17.02,13.87 17.02,14.39 16.97,14.44 U39.2
USB3_SS0TX-_RE_C: length 7.7
  TOP w0.102: U19.6 16.76,14.17 16.86,14.07 16.91,14.07 16.99,13.99 16.99,13.23 16.52,12.76 16.52,12.28 16.3,12.06 R415.1 16.39,11.61 16.39,10.85 v1(16.18,10.65)
  BOTTOM w0.102: v1(16.18,10.65) 16.38,10.85 16.38,11.79 16.92,12.33 16.92,12.99 16.82,13.1 C705.2
USB30_RX0+: length 139.2
  IN1 w0.089: v2(102.92,58.9) 102.8,58.78 102.8,58.66 102.96,58.51 103.59,58.51 104.02,58.08 104.3,58.08 106.28,56.09 106.28,53.54 105.6,52.85 105.6,46 106.56,45.04 106.56,44.63 106.03,44.1 106.03,42.84 105.27,42.07 105.27,39.82 104.33,38.88 104.33,38.25 102.65,36.57 102.65,33.36 102.09,32.8 102.09,31.56 101.92,31.38 101.92,27.32 101.28,26.69 101.28,25.24 95.96,19.93 89.99,19.93 89.07,20.84 83.88,20.84 80.43,17.39 71.69,17.39 71.03,16.72 64.1,16.72 63.18,17.64 48.8,17.64 43.41,12.25 29.7,12.25 29.19,11.75 25.67,11.75 25.04,12.38 22.88,12.38 20.59,14.68 20.59,14.93 17.37,18.15 15.84,18.15 15.59,18.4 15.59,18.84 v1(16.02,19.27)
  BOTTOM w0.102: v1(16.02,19.27) 15.67,18.92 15.67,18.79 15.84,18.63 C695.1 ; v2(102.92,58.9) 103.06,58.77 103.06,58.71 102.86,58.52 101.83,58.52 101.53,58.81 101.28,58.81 101.15,58.68 101.15,58.62 101.28,58.49 U30.AA2
USB30_RX0-: length 139.2
  IN1 w0.089: v2(103.48,58.9) 104.11,58.28 104.39,58.28 106.49,56.18 106.49,53.45 105.8,52.77 105.8,46.09 106.77,45.12 106.77,44.55 106.23,44.01 106.23,42.75 105.47,41.99 105.47,39.74 104.53,38.8 104.53,38.16 102.86,36.49 102.86,33.28 102.3,32.72 102.3,31.47 102.12,31.3 102.12,27.24 101.48,26.61 101.48,25.16 96.05,19.72 89.9,19.72 88.99,20.64 83.97,20.64 80.51,17.18 71.77,17.18 71.11,16.52 64.01,16.52 63.1,17.44 48.88,17.44 43.5,12.05 29.78,12.05 29.27,11.54 25.59,11.54 24.95,12.18 22.79,12.18 20.38,14.59 20.38,14.85 17.28,17.94 15.76,17.94 15.38,18.32 v1(15.38,19.27)
  BOTTOM w0.102: v1(15.38,19.27) 15.45,19.2 15.45,18.78 C694.1 ; v2(103.48,58.9) 103.48,58.83 102.95,58.3 101.67,58.3 101.59,58.23 101.47,58.19 arc(101.32,58.18) 101.18,58.26 101.14,58.3 arc(101.11,58.33) 101.08,58.35 arc(101.07,58.36) 101.06,58.37 arc(100.84,58.46) U30.AA4
USB30_RX1+: length 126.7
  TOP w0.102: v1(23.94,54.72) 23.74,54.52 23.54,54.52 C278.2 22.89,54.5 22.48,54.5 C285.2
  IN3 w0.089: v2(97.28,56.49) 97.11,56.32 97.11,56.14 96.85,55.88 96.47,55.88 96.25,55.66 96.25,54.77 95.95,54.47 95.95,52.18 97.12,51.01 97.12,48.72 97.98,47.87 97.98,46.21 97.6,45.83 97.6,42.24 96.2,40.85 96.2,34.78 95.9,34.48 95.9,33.34 94.22,31.66 93.39,31.66 89.71,27.98 83.75,27.98 83.32,27.55 80.66,27.55 80.03,26.91 63.44,26.91 62.42,25.89 58.74,25.89 58.3,26.33 53.19,26.33 52.1,27.42 47.11,27.42 45.08,29.45 35.17,29.45 33.44,31.18 31.19,31.18 29.37,33 29.37,34.68 23.73,40.32 23.73,42.95 22.59,44.1 22.59,47.19 23.1,47.7 23.1,54.43 23.27,54.6 23.81,54.6 v1(23.94,54.72)
  BOTTOM w0.102: v2(97.28,56.49) 97.28,56.41 U30.AD8
USB30_RX1+_C: length 10.8
  TOP w0.102: CN6.6 13.1,51.79 13.35,51.55 13.56,51.55 14.07,52.06 14.39,52.06 16.32,53.99 16.6,53.99 16.7,54.08 U7.10 17.46,54.08 17.56,53.99 19.34,53.99 19.43,53.9 20.14,53.9 20.9,54.66 21.31,54.66 21.55,54.9 C285.1
USB30_RX1-: length 126.7
  TOP w0.102: C289.2 22,54.06 22.23,54.29 22.78,54.29 C292.2 23.45,54.07 23.45,54.24 23.52,54.31 23.8,54.31 23.94,54.17 v1(23.94,53.96)
  IN3 w0.089: v2(96.57,56.49) 96.64,56.55 96.84,56.55 96.9,56.49 96.9,56.22 96.77,56.09 96.39,56.09 96.05,55.75 96.05,54.86 95.74,54.55 95.74,52.1 96.92,50.93 96.92,48.64 97.78,47.78 97.78,46.3 97.39,45.92 97.39,42.33 96,40.93 96,34.87 95.69,34.56 95.69,33.42 94.14,31.86 93.31,31.86 89.62,28.18 83.67,28.18 83.24,27.75 80.58,27.75 79.94,27.11 63.35,27.11 62.33,26.1 58.82,26.1 58.39,26.53 53.27,26.53 52.18,27.62 47.19,27.62 45.16,29.65 35.26,29.65 33.53,31.38 31.28,31.38 29.58,33.08 29.58,34.77 23.94,40.41 23.94,43.04 22.79,44.18 22.79,47.1 23.3,47.61 23.3,54.34 23.35,54.39 23.71,54.39 23.94,54.16 v1(23.94,53.96)
  BOTTOM w0.102: U30.AD9 96.95,56.03 96.95,56.25 96.7,56.49 v2(96.57,56.49)
USB30_RX1-_C: length 10.8
  TOP w0.102: C289.1 21.55,54.26 21.37,54.45 20.99,54.45 20.23,53.68 U7.1 18.57,53.68 18.48,53.77 16.41,53.77 14.48,51.84 14.16,51.84 13.1,50.78 CN6.5
USB30_RX2+: length 118.5
  TOP w0.102: v1(24.19,33.51) 24.19,33.39 24.06,33.26 23.8,33.26 C354.1 23.05,33.25 22.52,33.25 C357.2
  IN1 w0.089: v2(94.95,55.5) 95.18,55.26 95.18,54.85 95.69,54.34 95.69,53.45 96.33,52.82 96.68,52.82 97.5,52 97.5,48.06 97.78,47.78 97.78,46.17 97.39,45.79 97.39,44.14 97.01,43.76 97.01,35.68 97.22,35.48 97.22,32.91 96.73,32.43 96.73,30.4 96.38,30.04 96.38,27.25 94.79,25.66 94.79,25.15 94.01,24.37 92.39,24.37 91.27,25.49 88.12,25.49 87.79,25.16 82.33,25.16 79.97,22.8 77.35,22.8 76.82,23.33 68.87,23.33 68.57,23.63 65.2,23.63 64.87,23.3 63.65,23.3 61.94,25.01 56.49,25.01 56.06,24.57 50.21,24.57 48.51,26.28 43.14,26.28 41.31,24.45 38.37,24.45 37.63,23.71 31.11,23.71 26.55,28.26 26.55,30.01 25.84,30.72 25.84,32.63 25.39,33.08 24.42,33.08 24.19,33.31 v1(24.19,33.51)
  BOTTOM w0.102: U30.AD12 94.51,55.94 v2(94.95,55.5)
USB30_RX2+_C: length 10.4
  TOP w0.102: C357.1 21.31,33.27 18.09,33.27 17.97,33.38 U13.10 17.46,33.38 17.34,33.27 16.91,33.27 16.14,32.5 14.49,32.5 13.56,31.57 13.18,31.57 13.1,31.65 CN9.6
USB30_RX2-: length 118.5
  TOP w0.102: v1(24.19,32.75) 24.19,32.8 23.95,33.04 23.84,33.04 C362.1 23.03,33.04 22.54,33.04 C360.2
  IN1 w0.089: v1(24.19,32.75) 24.32,32.88 25.3,32.88 25.64,32.54 25.64,30.64 26.35,29.92 26.35,28.18 31.02,23.51 37.71,23.51 38.45,24.24 41.4,24.24 43.22,26.07 48.42,26.07 50.13,24.37 56.15,24.37 56.58,24.8 61.86,24.8 63.56,23.1 64.96,23.1 65.29,23.43 68.48,23.43 68.79,23.13 76.74,23.13 77.27,22.59 80.05,22.59 82.42,24.95 87.87,24.95 88.2,25.28 91.19,25.28 92.31,24.17 94.09,24.17 94.99,25.07 94.99,25.58 96.58,27.16 96.58,29.96 96.94,30.31 96.94,32.35 97.42,32.83 97.42,35.56 97.22,35.77 97.22,43.67 97.6,44.06 97.6,45.71 97.98,46.09 97.98,47.87 97.7,48.14 97.7,52.08 96.76,53.02 96.41,53.02 95.9,53.54 95.9,54.43 95.39,54.93 95.39,55.23 v2(95.63,55.47)
  BOTTOM w0.102: v2(95.63,55.47) 95.31,55.8 U30.AD11
USB30_RX2-_C: length 10.4
  TOP w0.102: C360.1 21.26,33.05 20.05,33.05 19.98,32.98 U13.1 19.26,32.98 19.19,33.05 17,33.05 16.23,32.28 14.58,32.28 13.65,31.36 13.23,31.36 13.1,31.23 CN9.5
USB30_RX+_TYPEC1: length 11.3
  TOP w0.102: CN15.B11 5.52,13.69 8.71,13.69 9.21,14.18 9.21,15.18 9.29,15.26 9.45,15.26 9.6,15.12 RV3.10 RV3.1 10.87,15.12 11.03,15.27 11.2,15.27 11.43,15.04 11.96,15.04 R396.1 12.3,15.04 12.95,15.04 13.7,15.78 13.96,15.78 C483.1
USB30_RX+_TYPEC1_C: length 2.3
  TOP w0.102: U19.3 16.2,15.86 16.05,16 15.7,16 15.49,15.8 15.13,15.8 C483.2
USB30_RX+_TYPEC2: length 10.6
  TOP w0.102: v1(12.58,17.7) 12.76,17.88 13.25,17.88 R363.1 13.63,17.97 14.31,17.97 14.42,17.86 C460.1
  BOTTOM w0.102: v1(12.58,17.7) 12.58,17.84 12.65,17.91 13.03,17.91 13.14,17.79 13.14,17.44 12.74,17.03 11.72,17.03 11.52,16.83 11.16,16.83 11.09,16.9 11.09,17.03 11,17.12 RV7.1 RV7.10 9.57,17.12 9.43,16.97 9.24,16.97 8.2,18.01 7.82,18.01 7.68,18.15 CN15.A11
USB30_RX+_TYPEC2_C: length 3.1
  TOP w0.102: U19.1 16.76,17.53 16.41,17.88 15.06,17.88 14.87,17.69 C460.2
USB30_RX-_TYPEC1: length 11.3
  TOP w0.102: CN15.B10 5.52,13.91 8.62,13.91 8.99,14.27 8.99,15.27 9.2,15.48 9.46,15.48 9.6,15.61 RV3.9 RV3.2 10.85,15.61 10.98,15.48 11.29,15.48 11.52,15.25 11.95,15.25 R383.1 12.31,15.25 12.86,15.25 13.61,16 13.92,16 C481.1
USB30_RX-_TYPEC1_C: length 2.3
  TOP w0.102: U19.2 16.18,16.36 16.04,16.22 15.61,16.22 15.4,16.01 15.15,16.01 C481.2
USB30_RX-_TYPEC2: length 10.6
  TOP w0.102: C453.1 14.2,18.19 13.51,18.19 R355.1 13.22,18.13 12.79,18.13 v1(12.58,18.34)
  BOTTOM w0.102: CN15.A10 7.68,17.65 7.82,17.79 8.11,17.79 9.15,16.76 9.45,16.76 9.6,16.62 RV7.9 RV7.2 11.61,16.62 11.81,16.81 12.83,16.81 13.36,17.35 13.36,17.88 13.12,18.12 12.79,18.12 v1(12.58,18.34)
USB30_RX-_TYPEC2_C: length 3
  TOP w0.102: U19.24 16.88,17.71 16.5,18.1 15.17,18.1 C453.2
USB30_TX0+: length 138.2
  IN1 w0.089: v2(103.43,57.38) 103.24,57.19 103.24,57.06 103.32,56.98 104.72,56.98 105.73,55.98 105.73,53.83 104.96,53.07 104.96,45.91 105.17,45.71 105.17,44.3 104.82,43.95 104.6,43.95 104.33,43.67 104.33,42.37 103.82,41.86 103.82,40.62 103.14,39.94 103.14,37.75 102.17,36.78 102.17,33.56 101.61,33.01 101.61,31.81 101.41,31.61 101.41,29.07 100.65,28.31 100.65,25.28 95.85,20.48 90.33,20.48 89.5,21.32 83.69,21.32 80.31,17.94 71.39,17.94 70.76,17.31 69.95,17.31 69.7,17.56 66.02,17.56 65.46,18.12 47.95,18.12 43.33,13.5 31.73,13.5 31.17,12.94 27.97,12.94 27.41,13.5 24.87,13.5 23.35,15.01 23.35,15.65 22.08,16.92 22.08,18.57 20.81,19.84 20.81,20 18.73,22.08 17.08,22.08 16.74,21.74 16.74,21.54 v1(16.95,21.32)
  BOTTOM w0.102: U30.AA1 102.1,57.99 arc(102.1,57.99) 102.1,57.99 102.97,57.99 103.21,57.75 103.21,57.6 v2(103.43,57.38) ; C697.1 17.74,18.63 17.55,18.82 17.55,19.58 16.53,20.6 16.53,20.9 v1(16.95,21.32)
USB30_TX0-: length 138.3
  IN1 w0.089: v2(102.85,57.38) 103.04,57.19 103.04,56.98 103.23,56.78 104.63,56.78 105.52,55.89 105.52,53.92 104.76,53.16 104.76,45.82 104.96,45.62 104.96,44.39 104.73,44.15 104.52,44.15 104.13,43.76 104.13,42.45 103.61,41.94 103.61,40.71 102.93,40.02 102.93,37.83 101.97,36.87 101.97,33.65 101.41,33.09 101.41,31.9 101.2,31.69 101.2,29.15 100.44,28.39 100.44,25.37 95.76,20.69 90.42,20.69 89.58,21.53 83.6,21.53 80.22,18.15 71.31,18.15 70.67,17.51 70.04,17.51 69.78,17.77 66.1,17.77 65.54,18.32 47.86,18.32 43.24,13.7 31.64,13.7 31.08,13.14 28.05,13.14 27.49,13.7 24.95,13.7 23.56,15.1 23.56,15.73 22.29,17 22.29,18.66 21.02,19.93 21.02,20.09 18.82,22.29 17,22.29 16.53,21.83 16.53,21.54 v1(16.32,21.32)
  BOTTOM w0.102: v2(102.85,57.38) 103,57.53 103,57.66 102.88,57.77 102.1,57.77 arc(102.09,57.77) 102.07,57.77 101.85,57.68 arc(101.79,57.66) 101.72,57.67 arc(101.63,57.71) 101.55,57.78 arc(101.31,57.93) 101.03,57.99 U30.AA3 ; C696.1 17.33,18.75 17.33,19.49 16.32,20.51 v1(16.32,21.32)
USB30_TX1+: length 165.4
  TOP w0.102: v1(24.32,59.85) 24.5,60.03 25.44,60.03 26.14,59.33 26.14,58.24 25.88,57.99 25.5,57.99 25.31,58.18 C262.2
  IN1 w0.089: v1(24.32,59.85) 24.53,60.06 24.79,60.06 24.95,59.9 24.95,42.31 22.77,40.13 21.5,40.13 21.07,39.69 21.07,31.27 22.21,30.13 22.21,29.65 23.11,28.75 23.49,28.75 24.37,27.88 24.37,23.78 26.27,21.87 26.27,18.19 29.52,14.95 36.9,14.95 37.69,15.73 41.24,15.73 43.96,18.45 46.12,18.45 48.03,20.36 61.45,20.36 62.21,19.59 64.41,19.59 64.89,20.08 67.09,20.08 67.65,19.52 76.14,19.52 76.83,20.2 80.61,20.2 83.2,22.8 90.44,22.8 91.27,21.96 95.09,21.96 97.61,24.48 97.61,25.02 99.12,26.53 99.12,29.7 99.38,29.96 99.38,31.61 100.21,32.45 100.21,36.61 99.86,36.97 99.86,38.03 100.9,39.07 100.9,41.95 101.51,42.56 101.51,46.16 102.74,47.38 102.74,47.76 103.36,48.39 103.36,51.88 102.4,52.84 102.4,54.05 102.55,54.21 102.67,54.21 102.77,54.25 v2(103.1,54.58)
  BOTTOM w0.089: v2(103.1,54.58) 102.7,54.99 U30.AE1
USB30_TX1+_C: length 1.3
  TOP w0.102: C262.1 24.45,58.25 24.32,58.25 R179.1
USB30_TX1+_C_R: length 12.5
  TOP w0.102: R179.2 23.04,58.24 22.57,58.24 C261.1 21.77,58.26 21.45,58.26 20.4,57.21 17.41,57.21 17.33,57.29 U7.6 16.58,57.29 16.5,57.21 15.2,57.21 14.96,56.97 14.2,56.97 13.61,57.55 13.23,57.55 13.1,57.69 CN6.9
USB30_TX1-: length 165.4
  TOP w0.102: C266.2 25.43,57.77 25.97,57.77 26.35,58.15 26.35,59.42 25.53,60.25 24.55,60.25 v1(24.32,60.48)
  IN1 w0.089: v2(102.54,54.58) 102.54,54.49 102.2,54.14 102.2,52.76 103.16,51.79 103.16,48.47 102.53,47.85 102.53,47.47 101.31,46.24 101.31,42.64 100.7,42.03 100.7,39.15 99.66,38.11 99.66,36.88 100.01,36.53 100.01,32.53 99.17,31.69 99.17,30.04 98.92,29.79 98.92,26.61 97.41,25.11 97.41,24.56 95.01,22.16 91.36,22.16 90.52,23 83.11,23 80.52,20.41 76.74,20.41 76.06,19.72 67.74,19.72 67.18,20.28 64.81,20.28 64.32,19.8 62.29,19.8 61.53,20.56 47.94,20.56 46.04,18.66 43.88,18.66 41.16,15.94 37.6,15.94 36.82,15.15 29.6,15.15 26.48,18.27 26.48,21.96 24.57,23.86 24.57,27.96 23.58,28.95 23.2,28.95 22.41,29.74 22.41,30.21 21.27,31.36 21.27,39.61 21.59,39.93 22.86,39.93 25.16,42.23 25.16,59.98 24.87,60.27 24.53,60.27 v1(24.32,60.48)
  BOTTOM w0.089: v2(102.54,54.58) 102.33,54.8 102.07,54.8 101.96,54.69 101.68,54.69 101.52,54.85 101.14,54.85 U30.AE3
USB30_TX1-_C: length 1.3
  TOP w0.102: C266.1 24.46,58.04 24.3,58.04 R180.1
USB30_TX1-_C_R: length 12.5
  TOP w0.102: R180.2 23.08,58.03 22.53,58.03 C267.1 21.77,58.04 21.54,58.04 20.49,56.99 19.35,56.99 19.24,56.89 U7.5 18.6,56.89 18.49,56.99 15.29,56.99 15.05,56.76 14.11,56.76 13.52,57.34 13.22,57.34 13.1,57.22 CN6.8
USB30_TX2+: length 129.4
  TOP w0.102: C346.2 24.41,38.22 24.63,38.22 v1(24.7,38.29)
  IN1 w0.089: v2(103.43,55.85) 103.43,55.22 103.25,55.04 102.24,55.04 101.66,54.47 101.66,47.36 100.82,46.52 100.82,43.44 100.22,42.84 99.97,42.84 99.6,42.47 99.6,40.19 99.12,39.7 99.12,36.69 99.5,36.31 99.5,34.4 98.94,33.84 98.94,32.36 98.33,31.75 98.33,29.86 98.44,29.75 98.44,26.99 96.56,25.11 96.56,24.47 94.73,22.64 91.65,22.64 90.82,23.48 82.92,23.48 80.33,20.89 69.43,20.89 68.97,21.35 64.65,21.35 64.37,21.07 47.69,21.07 46.62,22.13 41.33,22.13 40.64,22.82 30.66,22.82 28.48,25.01 26.7,25.01 25.13,26.57 25.13,29.49 21.78,32.85 21.78,36.09 23.98,38.29 v1(24.7,38.29)
  BOTTOM w0.102: v2(103.43,55.85) 103.06,55.49 103.06,55.49 102.79,55.22 102.03,55.22 101.79,55.46 101.43,55.46 U30.AD2
USB30_TX2+_C: length 1.3
  TOP w0.102: C346.1 23.31,38.06 23.17,38.06 R229.1
USB30_TX2+_C_R: length 12.4
  TOP w0.102: CN9.9 13.1,37.69 13.21,37.58 13.63,37.58 14.52,36.69 16.83,36.69 17.04,36.48 17.38,36.48 17.48,36.58 U13.6 18.1,36.58 18.21,36.48 20.12,36.48 20.24,36.6 20.24,37.74 20.52,38.03 20.71,38.03 C345.1 21.52,38.09 21.93,38.09 R229.2
USB30_TX2-: length 129.3
  TOP w0.102: v1(24.7,37.63) 24.5,37.83 24.32,37.83 24.16,37.68 C348.2
  IN1 w0.089: v2(102.87,55.85) 103.23,55.5 103.23,55.31 103.17,55.25 102.15,55.25 101.46,54.55 101.46,47.44 100.62,46.6 100.62,43.52 100.14,43.04 99.88,43.04 99.4,42.56 99.4,40.27 98.92,39.79 98.92,36.6 99.3,36.22 99.3,34.49 98.74,33.93 98.74,32.45 98.13,31.84 98.13,29.77 98.23,29.67 98.23,27.07 96.35,25.19 96.35,24.56 94.64,22.85 91.74,22.85 90.9,23.68 82.84,23.68 80.25,21.09 69.51,21.09 69.06,21.55 64.56,21.55 64.28,21.27 47.77,21.27 46.7,22.34 41.41,22.34 40.73,23.02 30.75,23.02 28.56,25.21 26.78,25.21 25.33,26.66 25.33,29.58 21.98,32.93 21.98,36 24.06,38.09 24.24,38.09 v1(24.7,37.63)
  BOTTOM w0.102: U30.AD4 101.39,55.82 101.51,55.82 101.65,55.68 101.88,55.68 102.12,55.43 102.7,55.43 102.87,55.6 v2(102.87,55.85)
USB30_TX2-_C: length 1.3
  TOP w0.102: R234.1 22.91,37.59 22.91,37.6 23.15,37.84 23.32,37.84 C348.1
USB30_TX2-_C_R: length 12.3
  TOP w0.102: CN9.8 13.1,37.15 13.31,37.36 13.54,37.36 14.43,36.47 16.74,36.47 16.95,36.26 19.29,36.26 19.36,36.18 U13.5 20,36.18 20.07,36.26 20.21,36.26 20.46,36.51 20.46,37.65 20.61,37.81 20.79,37.81 C349.1 21.55,37.87 21.9,37.87 R234.2
USB30_TX+_TYPEC1: length 20.6
  TOP w0.102: v1(19.24,9.51) 19.24,9.54 19,9.78 19,9.96 18.55,10.4 18.55,11.27 C512.1
  BOTTOM w0.102: CN15.A2 7.63,13.65 7.77,13.79 8.69,13.79 9.22,14.32 9.22,15.19 9.27,15.24 9.45,15.24 9.57,15.12 RV7.6 RV7.5 10.87,15.12 11.02,15.26 11.33,15.26 11.87,14.72 11.87,12.81 12.37,12.32 12.37,11.63 15.26,8.74 15.42,8.74 15.66,8.5 18.66,8.5 19.07,8.91 19.07,9.35 v1(19.24,9.51)
USB30_TX+_TYPEC1_C: length 1.8
  TOP w0.102: U19.9 18.61,12.94 18.48,12.81 18.48,12.15 C512.2
USB30_TX+_TYPEC2: length 24.6
  TOP w0.102: v1(12.7,16.37) 12.44,16.62 12.44,16.78 12.19,17.03 11.07,17.03 10.98,17.12 RV3.5 RV3.6 9.57,17.12 9.43,16.97 9.33,16.97 8.54,17.77 7.25,17.77 6.91,18.11 5.52,18.11 CN15.B2 ; v1(19.62,10.78) 19.84,11 19.84,11.33 19.72,11.44 C513.1
  IN1 w0.089: v1(12.7,16.37) 12.7,16.34 12.48,16.12 12.48,14.89 12.13,14.54 12.13,12.47 15.61,8.98 19.42,8.98 19.87,9.43 19.87,10.65 19.75,10.78 v1(19.62,10.78)
USB30_TX+_TYPEC2_C: length 2
  TOP w0.102: U19.10 19.11,13.07 19.25,12.93 19.25,12.71 19.51,12.45 19.62,12.45 19.75,12.32 19.75,12.15 C513.2
USB30_TX-_TYPEC1: length 20.5
  TOP w0.102: v1(18.6,9.51) 18.65,9.51 18.78,9.64 18.78,9.87 18.34,10.31 18.34,11.32 18.21,11.44 C511.1
  BOTTOM w0.102: v1(18.6,9.51) 18.86,9.26 18.86,9 18.57,8.71 15.75,8.71 15.51,8.95 15.35,8.95 12.58,11.72 12.58,12.41 12.09,12.9 12.09,14.81 11.42,15.47 11.12,15.47 10.98,15.61 RV7.4 RV7.7 9.6,15.61 9.43,15.45 9.18,15.45 9,15.28 9,14.41 8.6,14.01 7.76,14.01 7.62,14.15 CN15.A3
USB30_TX-_TYPEC1_C: length 1.8
  TOP w0.102: U19.8 18.11,12.93 18.26,12.78 18.26,12.19 C511.2
USB30_TX-_TYPEC2: length 24.6
  TOP w0.102: v1(20.25,10.78) 20.05,10.98 20.05,11.24 C514.1 ; CN15.B3 5.52,17.89 6.82,17.89 7.16,17.55 8.45,17.55 9.24,16.76 9.45,16.76 9.6,16.62 RV3.7 RV3.4 10.86,16.62 11.06,16.81 12.1,16.81 12.23,16.69 12.23,16.55 v1(12.05,16.37)
  IN1 w0.089: v1(12.05,16.37) 12.05,16.34 12.27,16.12 12.27,14.97 11.92,14.62 11.92,12.38 15.53,8.77 19.5,8.77 20.08,9.35 20.08,10.6 v1(20.25,10.78)
USB30_TX-_TYPEC2_C: length 2.1
  TOP w0.102: U19.11 19.61,13.06 19.47,12.91 19.47,12.8 19.6,12.67 19.71,12.67 19.96,12.41 19.96,12.19 C514.2
USB_BC_ON: length 192.6
  TOP w0.102: U10.4 21.96,47.03 v1(22.03,47.1) ; U15.97 179.62,29.05 177.23,26.66 v1(177.23,26.4)
  IN2 w0.089: v1(22.03,47.1) 22.03,46.85 22.95,45.93 23.33,45.93 23.94,45.33 23.94,43.55 25.4,42.09 25.4,34.34 26.52,33.22 26.52,29.63 26.26,29.38 26.26,27.96 26.1,27.8 25.8,27.8 25.42,27.42 25.42,27.05 26.07,26.4 26.07,24.87 27.68,23.27 32.95,23.27 33.32,22.9 36.05,22.9 36.96,21.99 42.33,21.99 45.13,24.79 48.11,24.79 51.42,21.47 64.11,21.47 64.28,21.64 70.19,21.64 71.29,22.74 75.65,22.74 75.78,22.87 76.85,22.87 77.02,22.69 77.74,22.69 78.42,23.38 91.15,23.38 93.78,20.75 97.63,20.75 98.48,19.9 103.85,19.9 104.91,18.83 108.75,18.83 111.56,21.65 123.17,21.65 123.74,22.22 127.72,22.22 127.87,22.07 131.23,22.07 132.17,23.01 133.03,23.01 133.33,23.3 140.39,23.3 141.22,24.13 142.68,24.13 144.34,25.79 156.31,25.79 157.31,24.79 164.57,24.79 165.65,25.87 169.35,25.87 169.48,26 176.83,26 v1(177.23,26.4)
USB_CHARGE_ON: length 197
  TOP w0.102: v1(23.55,47.11) R198.1 22.92,47.87 22.91,47.88 U10.5 ; U15.96 182.16,28.16 182.28,28.28 182.28,28.43 v1(182.03,28.69) 182.03,28.84 v1(181.54,29.32)
  IN2 w0.089: v1(182.03,28.69) 182.03,28.28 181.75,28.01 175.79,28.01 174.9,27.13 171.55,27.13 170.75,27.93 169.96,27.93 169.04,28.84 165.7,28.84 164.7,27.85 157.06,27.85 156.42,28.5 154.15,28.5 152.97,27.32 144.03,27.32 143.53,27.82 142.95,27.82 142.59,27.47 142.59,26.85 141.76,26.01 140.5,26.01 139.28,24.8 131.47,24.8 130.45,23.78 123.81,23.78 122.9,22.87 119.29,22.87 118.93,23.23 115.56,23.23 114.82,22.49 108.93,22.49 107.73,21.3 105.12,21.3 104.96,21.45 99.12,21.45 98.99,21.58 94.82,21.58 92.23,24.17 76,24.17 75.34,23.51 70.97,23.51 70.03,22.57 63.33,22.57 62.56,23.33 61.16,23.33 60.39,22.57 56.34,22.57 55.57,23.33 51.6,23.33 51.37,23.1 50.74,23.1 48.42,25.41 44.69,25.41 44.07,24.79 43.28,24.79 41.21,22.72 37.06,22.72 36.17,23.61 33.42,23.61 33.19,23.84 28.31,23.84 28,24.14 28,24.5 27.68,24.81 26.67,24.81 26.45,25.03 26.45,27.12 26.66,27.32 26.66,29.12 26.95,29.41 26.95,33.43 25.79,34.58 25.79,45.38 24.57,46.6 24.06,46.6 v1(23.55,47.11)
USB_CLT1: length 198.5
  TOP w0.102: U10.6 v1(22.67,48.38) ; U15.79 180.39,21.36 180.22,21.2 179.39,21.2 178.24,22.34 v1(178.24,22.72)
  IN2 w0.089: v1(178.24,22.72) 177.99,22.97 177.99,23.86 177.54,24.31 173.29,24.31 171.7,22.72 168.97,22.72 168.49,23.2 165.55,23.2 165.32,22.97 163.33,22.97 161.98,21.63 158.03,21.63 155.92,23.74 146.16,23.74 144.77,22.34 142.39,22.34 140.64,20.59 135.47,20.59 135.25,20.37 134.13,20.37 132.9,19.14 122.72,19.14 122.11,18.53 115.76,18.53 114.77,19.52 112.16,19.52 109.95,17.31 98.99,17.31 97.02,19.28 93.17,19.28 90.64,21.8 78.94,21.8 78.14,21 69.47,21 69.21,21.26 64.43,21.26 64.12,20.94 51.42,20.94 47.95,24.41 45.31,24.41 42.48,21.58 36.76,21.58 35.85,22.49 33.17,22.49 32.77,22.88 26.69,22.88 25.67,23.91 25.67,24.32 25.88,24.54 25.88,26.32 25.23,26.97 25.23,27.55 25.42,27.73 25.42,29.36 26.33,30.26 26.33,33.08 25.21,34.2 25.21,42.01 23.75,43.47 23.75,45.25 23.29,45.71 22.79,45.71 21.6,46.9 21.6,47.43 22.55,48.38 v1(22.67,48.38)
USB_OC0#: length 172.2
  TOP w0.102: U10.13 17.47,49.38 16.95,49.9 16.19,49.9 v1(15.68,50.41)
  IN3 w0.089: v1(79.69,15.23) 80.25,14.67 81.52,14.67 84.57,11.62 87.9,11.62 90.1,13.83 90.1,17.89 91.12,18.91 92.77,18.91 93.97,17.72 99.68,17.72 100.01,17.39 103.57,17.39 104.33,18.15 104.33,19.8 105.98,21.45 107.38,21.45 109.28,23.35 109.28,26.78 111.31,28.82 111.82,28.82 113.22,30.21 113.22,32.07 116.95,35.8 v1(117.41,35.8)
  BOTTOM w0.102: v1(15.68,50.41) 15.68,50.15 15.3,49.77 15.3,48.75 15.68,48.37 15.68,46.09 v1(16.06,45.71) 19.24,45.71 19.65,46.11 21.68,46.11 23.3,47.74 24.7,47.74 25.36,47.08 25.36,40.58 24.09,39.31 24.09,35.57 24.92,34.74 24.92,34 26.73,32.18 26.73,31.61 28,30.34 29.6,30.34 30.62,29.32 30.62,24.32 29.27,22.97 28.1,22.97 27.49,22.36 27.49,18.78 27.75,18.53 27.75,14.59 27.87,14.46 31.3,14.46 31.56,14.21 36.75,14.21 38.07,15.53 39.86,15.53 40.45,14.95 40.45,14.02 42.14,12.33 48.03,12.33 48.97,13.27 56.86,13.27 57.49,13.91 60.56,13.91 61.2,13.27 72.45,13.27 73.72,14.54 79.06,14.54 79.69,15.18 v1(79.69,15.23) ; v1(117.41,35.8) 117.41,35.06 117.33,34.98 D29.1
USB_OC1#: length 151.7
  IN3 w0.089: v1(80.33,15.23) 84.52,19.42 92.9,19.42 94.19,18.12 100.29,18.12 100.52,17.89 101.66,17.89 105.73,21.96 107.33,21.96 108.77,23.4 108.77,27.04 111.06,29.32 111.77,29.32 112.79,30.34 112.79,32.19 116.14,35.55 v1(116.14,35.8)
  BOTTOM w0.102: v1(116.14,35.8) 115.89,35.55 115.89,35.16 115.53,34.8 115.5,34.8 115.45,34.75 D28.1 ; U31.3 18.73,45.13 18.87,45.27 19.39,45.27 19.82,45.71 v1(22.85,45.71) 23.43,45.71 24.95,44.18 24.95,40.75 23.68,39.48 23.68,35.4 24.51,34.57 24.51,33.83 26.33,32.02 26.33,31.44 27.83,29.93 29.42,29.93 30.21,29.14 30.21,24.49 29.1,23.38 27.94,23.38 27.09,22.53 27.09,18.61 27.34,18.36 27.34,14.42 27.71,14.06 31.14,14.06 31.39,13.8 36.92,13.8 38.24,15.12 39.69,15.12 40.04,14.77 40.04,13.85 41.97,11.92 48.19,11.92 49.13,12.86 72.62,12.86 73.89,14.13 79.23,14.13 v1(80.33,15.23)
USB_OC2#: length 122.3
  IN1 w0.089: v1(142,27.27) 142.43,27.7 145.2,27.7 145.63,28.13 153.11,28.13 153.94,28.95 156.75,28.95 157.12,29.32 158.62,29.32 158.81,29.13 160.42,29.13 160.94,28.61 163.18,28.61 164.02,29.45 165.32,29.45 165.48,29.61 172.91,29.61 173.34,30.03 185.03,30.03 186.75,28.32 189.27,28.32 190.76,29.81 192.73,29.81 194.17,31.25 196.03,31.25 198.21,29.07 198.94,29.07 199.71,28.31 199.71,24.88 198.62,23.79 198.62,21.86 198.05,21.29 198.05,20.56 198.82,19.8 198.82,19.67 200.34,18.15 201.23,18.15 202.2,17.18 204.58,17.18 205.25,17.85 205.89,17.85 207.1,19.06 207.1,20.23 207.61,20.74 207.61,21.47 209.48,23.35 v1(212.79,23.35)
  IN3 w0.089: v1(142,27.27) 141.46,27.8 140.78,27.8 139.27,29.31 136.97,29.31 136.22,28.56 135.44,28.56 135.06,28.94 132.4,28.94 131.43,29.91 124.57,29.91 122.36,32.12 122.36,32.93 120.64,34.66 120.05,34.66 v1(118.93,35.77)
  BOTTOM w0.102: U38.3 212.64,23.2 v1(212.79,23.35) ; D30.1 118.79,34.98 119.04,34.73 v1(119.75,34.73) 119.75,35.55 119.52,35.77 v1(118.93,35.77)
USB_OCP_ALL#: length 46.8
  IN2 w0.089: v2(97.92,54.48) 98.32,54.09 99.12,54.09 100.14,53.07 101.15,53.07 102.17,52.06 103.06,52.06 104.09,51.03 107.24,51.03 108.27,52.06 110.81,52.06 111.69,52.95 113.85,52.95 114.82,51.98 117.49,51.98 120.58,48.88 120.58,47.36 120.2,46.98 120.2,46.45 120.58,46.07 120.58,41.9 v1(120.97,41.52)
  BOTTOM w0.102: R602.2 116.37,38.49 115.76,37.88 v1(115.76,37.83) ; v2(97.92,54.48) 97.69,54.48 97.18,54.99 U30.AE9 ; v1(120.97,41.52) 120.97,40.43 119.9,39.36 119.9,37.78 119.4,37.28 D30.2 D29.2 116.46,37.28 115.91,37.83 v1(115.76,37.83) ; v1(115.76,37.83) 115.76,37.5 115.31,37.05 D28.2
USBON#: length 234.3
  TOP w0.102: v1(175.96,26.4) 177.48,27.93 177.86,27.93 178.82,28.88 U15.99
  IN2 w0.089: v1(24.45,43.67) 25.6,42.52 25.6,34.5 26.76,33.35 26.76,29.6 26.45,29.3 26.45,27.39 26.26,27.2 26.26,24.95 27.76,23.46 33.03,23.46 33.28,23.2 36.03,23.2 37.04,22.19 42.27,22.19 45.06,24.98 48.22,24.98 51.52,21.68 53.5,21.68 54.34,22.52 55.58,22.52 56.42,21.68 64.04,21.68 64.2,21.83 70.11,21.83 71.21,22.93 75.57,22.93 75.7,23.06 77.24,23.06 77.35,22.95 77.71,22.95 78.33,23.57 91.23,23.57 93.86,20.94 97.71,20.94 97.94,20.71 104.56,20.71 105.47,19.8 108.9,19.8 110.96,21.86 123.11,21.86 123.69,22.44 127.77,22.44 127.95,22.26 131.15,22.26 132.09,23.2 132.95,23.2 133.25,23.49 140.29,23.49 141.12,24.32 142.6,24.32 144.26,25.98 156.44,25.98 157.44,24.98 162.22,24.98 162.88,25.64 165.03,25.64 165.46,26.07 169.27,26.07 169.4,26.19 175.75,26.19 v1(175.96,26.4) 176.57,27.01 187.03,27.01 188.02,26.02 189.07,26.02 191.47,23.62 191.47,21.85 192.27,21.04 194.27,21.04 196.99,18.32 199.28,18.32 199.71,17.89 200.09,17.89 201.36,16.62 205.41,16.62 207.71,18.92 207.71,19.7 208.7,20.69 211.64,20.69 212.06,21.1 v1(212.06,21.32)
  BOTTOM w0.102: v1(24.45,43.67) 23.18,43.67 21.72,45.13 U31.4 ; v1(212.06,21.32) U38.4
USBP0+: length 157.9
  TOP w0.102: v1(11.94,11.63) 11.69,11.39 11.57,11.39 11.41,11.55 R418.1
  IN1 w0.089: v1(11.94,11.63) 11.82,11.52 11.26,11.52 11.11,11.67 11.11,13.83 10.78,14.16 10.78,17.51 10.55,17.74 10.55,20.69 11.36,21.5 14.46,21.5 15.43,22.47 15.43,25.13 15.68,25.39 19.37,25.39 20.1,24.65 22.32,24.65 25.49,21.48 25.49,17.8 29.08,14.21 37.22,14.21 38,15 42.8,15 44.94,17.13 45.99,17.13 47.66,18.81 64.98,18.81 65.47,19.29 66.16,19.29 66.77,18.68 80.07,18.68 83.48,22.08 89.93,22.08 90.82,21.2 95.44,21.2 98.33,24.09 98.33,24.66 99.86,26.18 99.86,29.43 100.14,29.71 100.14,31.38 100.93,32.17 100.93,34.05 101.41,34.53 101.41,37.23 101.66,37.48 101.66,41.52 102.17,42.02 102.93,42.02 103.57,42.66 103.57,44.75 104.18,45.36 104.18,53.49 104.96,54.27 104.96,55.78 104.27,56.48 101.13,56.48 100.75,56.09 99.78,56.09 99.44,56.44 99.44,57.29 v2(99.64,57.49)
  BOTTOM w0.102: U30.AC6 99.21,56.81 99.34,56.67 99.5,56.67 99.59,56.76 99.59,57.44 v2(99.64,57.49)
USBP0-: length 157.9
  TOP w0.102: R419.1 11.41,10.98 11.57,11.14 11.69,11.14 11.94,10.9 v1(11.94,10.82)
  IN1 w0.089: v1(11.94,10.82) 11.94,11.07 11.72,11.29 11.17,11.29 10.88,11.58 10.88,13.73 10.55,14.06 10.55,17.42 10.32,17.65 10.32,20.79 11.26,21.73 14.37,21.73 15.2,22.56 15.2,25.23 15.59,25.61 19.46,25.61 20.2,24.88 22.41,24.88 25.72,21.58 25.72,17.89 29.17,14.44 37.12,14.44 37.91,15.23 42.71,15.23 44.84,17.36 45.89,17.36 47.57,19.04 64.89,19.04 65.37,19.52 66.25,19.52 66.86,18.91 79.98,18.91 83.38,22.31 90.02,22.31 90.91,21.42 95.34,21.42 98.11,24.19 98.11,24.75 99.63,26.28 99.63,29.53 99.91,29.81 99.91,31.48 100.7,32.26 100.7,34.14 101.18,34.62 101.18,37.32 101.43,37.58 101.43,41.61 102.08,42.25 102.84,42.25 103.34,42.75 103.34,44.84 103.95,45.45 103.95,53.58 104.74,54.37 104.74,55.69 104.18,56.25 101.22,56.25 100.84,55.87 99.69,55.87 99.21,56.35 99.21,57.29 v2(99,57.49)
  BOTTOM w0.102: U30.AC7 v2(99,57.49)
USBP1+: length 118.4
  TOP w0.102: v1(24.49,46.09) 23.71,46.09 23.45,45.84 22.55,45.84 22.41,45.84 22.26,45.99 R205.1
  IN3 w0.089: v2(97.47,58.48) 97.24,58.25 97.24,58.18 96.96,57.89 96.01,57.89 95.97,57.93 94.71,57.93 94.3,57.52 94.3,50.15 95.95,48.5 95.95,48.31 96.45,47.81 96.45,47.1 95.69,46.34 95.69,41.9 95.31,41.52 95.31,35.02 91.38,31.09 91.38,30.72 89.32,28.66 83.66,28.66 83.36,28.97 82.51,28.97 81.77,28.23 80.38,28.23 79.84,27.7 60.99,27.7 60.35,27.06 53.76,27.06 52.61,28.21 47.41,28.21 44.99,30.62 35.15,30.62 33.88,31.89 31.46,31.89 30.44,32.91 30.44,34.58 24.85,40.17 24.85,43.9 23.71,45.05 23.71,45.67 23.95,45.91 24.31,45.91 v1(24.49,46.09)
  BOTTOM w0.102: U30.AA8 97.7,58.25 v2(97.47,58.48)
USBP1+_C: length 3.1
  TOP w0.102: U10.10 20.38,50.9 20.25,51.02 20.25,52.11 20.41,52.27 20.55,52.27 20.66,52.15 R187.1
USBP1+_C_R: length 10.9
  TOP w0.102: R188.1 v1(22.16,51.55) ; R205.2 v1(23.3,46.34)
  IN1 w0.089: v1(23.3,46.34) 23.3,45.83 23.18,45.71 22.29,45.71 21.4,46.6 21.4,52.06 21.52,52.18 22.03,52.18 22.16,52.06 v1(22.16,51.55)
USBP1+_C_R_N: length 22.3
  TOP w0.102: v1(15.86,56.54) 15.98,56.42 16.62,56.42 16.68,56.49 U7.7 17.35,56.49 17.5,56.34 18.46,56.34 18.49,56.36 24.2,56.36 24.7,55.87 24.7,52.59 24.15,52.03 21.3,52.03 21.12,51.85 R188.2
  IN3 w0.089: v1(15.86,56.54) 15.98,56.42 16.46,56.42 17.05,55.83 17.05,54.5 16.57,54.01 15.98,54.01 CN6.3
USBP1+_U14: length 3.6
  TOP w0.102: U10.3 20.38,46.46 20.13,46.21 20.13,45.93 20.41,45.66 21.7,45.66 21.81,45.76 R204.2
USBP1-: length 118.5
  TOP w0.102: v1(24.49,45.45) 24.11,45.83 23.81,45.83 23.56,45.58 22.55,45.58 22.39,45.58 22.26,45.45 R208.1
  IN3 w0.089: v2(96.62,58.5) 96.62,58.7 96.7,58.77 96.9,58.77 97.01,58.66 97.01,58.27 96.86,58.12 96.11,58.12 96.07,58.16 94.61,58.16 94.07,57.61 94.07,50.06 95.72,48.4 95.72,48.22 96.23,47.71 96.23,47.2 95.46,46.44 95.46,41.99 95.08,41.61 95.08,35.11 91.15,31.18 91.15,30.82 89.22,28.89 83.75,28.89 83.45,29.2 82.42,29.2 81.68,28.46 80.28,28.46 79.75,27.93 60.89,27.93 60.26,27.29 53.85,27.29 52.71,28.43 47.5,28.43 45.09,30.85 35.24,30.85 33.97,32.12 31.56,32.12 30.67,33.01 30.67,34.68 25.08,40.26 25.08,44 23.94,45.14 23.94,45.58 24.04,45.68 24.26,45.68 v1(24.49,45.45)
  BOTTOM w0.102: U30.AA9 97.01,58.09 97.01,58.28 96.8,58.5 v2(96.62,58.5)
USBP1-_C: length 3.1
  TOP w0.102: R184.1 20.66,52.62 20.57,52.52 20.31,52.52 20,52.21 20,51.02 19.88,50.9 U10.11
USBP1-_C_R: length 10.8
  TOP w0.102: R208.2 v1(23.3,45.07) ; R185.1 v1(22.16,52.82)
  IN1 w0.089: v1(23.3,45.07) 22.9,45.48 22.19,45.48 21.17,46.5 21.17,52.15 21.43,52.41 21.75,52.41 v1(22.16,52.82)
USBP1-_C_R_N: length 22.2
  TOP w0.102: R185.2 21.12,52.34 21.17,52.28 24.04,52.28 24.45,52.69 24.45,55.76 24.1,56.11 19.36,56.11 19.33,56.08 U7.4 16.71,56.08 16.62,56.17 16.12,56.17 v1(15.86,55.91)
  IN3 w0.089: v1(15.86,55.91) 16.15,56.2 16.37,56.2 16.83,55.74 16.83,54.6 16.47,54.24 14.49,54.24 14.34,54.39 14.34,55.18 CN6.2
USBP1-_U14: length 3.6
  TOP w0.102: R207.2 21.81,45.35 21.75,45.4 20.3,45.4 19.87,45.83 19.87,46.53 19.88,46.53 U10.2
USBP2+: length 116.3
  TOP w0.102: v1(22.79,34.91) 22.67,35.04 22.29,35.04 22.13,34.88 R238.1
  IN1 w0.089: v2(95.67,57.54) 95.52,57.39 95.52,57.2 95.2,56.88 94.65,56.88 94.4,56.63 94.4,53.48 94.8,53.07 95.18,53.07 96.33,51.93 96.33,50.53 96.07,50.28 96.07,48.25 96.45,47.87 96.45,47.23 95.82,46.6 95.82,44.31 95.69,44.18 95.69,34.91 95.92,34.68 95.92,33.49 95.39,32.95 95.39,27.62 94.35,26.58 86.93,26.58 86.55,26.2 82,26.2 80.4,24.6 76.29,24.6 75.91,24.98 70.32,24.98 69.66,25.64 62.29,25.64 62.04,25.89 56.32,25.89 55.56,25.13 50.43,25.13 48.8,26.76 42.78,26.76 41.03,25.01 31.23,25.01 27.67,28.57 27.67,29.65 26.43,30.9 26.43,32.73 24.1,35.06 22.95,35.06 v1(22.79,34.91)
  BOTTOM w0.102: v2(95.67,57.54) 95.67,57.63 U30.AA11
USBP2+_C: length 9
  TOP w0.102: CN9.3 14.6,34.21 14.7,34.31 15.44,34.31 16.81,35.68 17.34,35.68 17.44,35.78 U13.7 18.09,35.78 18.43,35.44 19.02,35.44 19.36,35.1 20.57,35.1 20.63,35.04 21.3,35.04 R238.2
USBP2-: length 116.3
  TOP w0.102: v1(22.79,35.55) 22.54,35.29 22.29,35.29 22.13,35.45 R237.1
  IN1 w0.089: v2(94.96,57.54) 95.22,57.54 95.29,57.47 95.29,57.29 95.11,57.11 94.56,57.11 94.17,56.72 94.17,53.38 94.71,52.84 95.09,52.84 96.1,51.83 96.1,50.63 95.85,50.37 95.85,48.15 96.23,47.77 96.23,47.32 95.59,46.69 95.59,44.4 95.46,44.28 95.46,34.82 95.69,34.59 95.69,33.58 95.16,33.05 95.16,27.72 94.25,26.81 86.84,26.81 86.45,26.43 81.91,26.43 80.31,24.83 76.38,24.83 76,25.21 70.41,25.21 69.75,25.87 62.39,25.87 62.13,26.12 56.23,26.12 55.47,25.36 50.52,25.36 48.9,26.99 42.68,26.99 40.93,25.23 31.33,25.23 27.9,28.66 27.9,29.75 26.66,30.99 26.66,32.83 24.19,35.29 23.05,35.29 v1(22.79,35.55)
  BOTTOM w0.102: v2(94.96,57.54) U30.AA12
USBP2-_C: length 9
  TOP w0.102: CN9.2 14.6,34.67 14.7,34.57 15.34,34.57 16.71,35.94 17.22,35.94 17.32,36.04 18.19,36.04 18.53,35.7 19.12,35.7 19.44,35.38 U13.4 20.65,35.38 20.74,35.29 21.3,35.29 R237.2
USBP4+_DB: length 183.6
  IN1 w0.089: v2(97.26,60.58) 97.13,60.45 97.13,60.36 97.28,60.21 97.5,60.21 98.74,61.45 103.48,61.45 108.01,56.93 108.01,53.65 110.42,51.24 110.42,47.74 111.19,46.98 111.19,43.17 111.06,43.04 111.06,38.85 110.42,38.21 110.42,34.4 109.03,33.01 109.03,32.24 108.6,31.81 108.6,29.5 109.1,28.99 109.1,25 112.04,22.06 116.45,22.06 117.89,20.61 117.89,19.26 121.82,15.33 161.95,15.33 162.34,14.95 178.78,14.95 182.85,19.01 187.03,19.01 187.54,18.5 189.65,18.5 191.35,20.2 193.76,20.2 195.73,18.24 195.73,17.63 197.75,15.61 199.78,15.61 200.41,14.97 206.51,14.97 206.63,14.85 207.07,14.85 208.24,16.01 208.24,16.83 209.92,18.5 210.41,18.5 212.66,20.76 212.66,22.41 213.57,23.32 213.57,34.44 212.77,35.24 212.34,35.24 v1(212.11,35.01)
  BOTTOM w0.102: CN8.16 212.5,35.4 v1(212.11,35.01) ; U30.W8 97.86,59.99 98.09,60.21 98.09,60.4 97.91,60.58 v2(97.26,60.58)
USBP4-_DB: length 183.6
  IN1 w0.089: v2(96.68,60.48) 97.18,59.98 97.59,59.98 98.84,61.23 103.39,61.23 107.78,56.83 107.78,53.55 110.2,51.14 110.2,47.64 110.96,46.88 110.96,43.26 110.83,43.13 110.83,38.94 110.2,38.31 110.2,34.5 108.8,33.1 108.8,32.34 108.37,31.91 108.37,29.41 108.88,28.9 108.88,24.9 111.95,21.83 116.35,21.83 117.66,20.52 117.66,19.16 121.73,15.1 161.86,15.1 162.24,14.72 178.88,14.72 182.94,18.78 186.94,18.78 187.44,18.27 189.74,18.27 191.44,19.98 193.67,19.98 195.5,18.14 195.5,17.53 197.66,15.38 199.68,15.38 200.32,14.74 206.41,14.74 206.54,14.62 207.17,14.62 208.47,15.92 208.47,16.73 210.01,18.27 210.5,18.27 212.89,20.66 212.89,22.31 213.8,23.23 213.8,34.53 212.86,35.47 212.28,35.47 v1(212.11,35.64)
  BOTTOM w0.102: U30.W9 96.91,60.26 v2(96.68,60.48) ; v1(212.11,35.64) 212.36,35.9 CN8.15
USBP5+_CAM: length 91.7
  IN3 w0.089: v2(94.95,59.54) 94.95,59.79 94.91,59.83 94.58,59.83 94.17,60.25 94.17,65.78 93.38,66.56 93.38,72.1 94.93,73.65 94.93,74.15 95.57,74.79 95.57,81.77 95.85,82.05 95.85,83.69 95.57,83.96 91.63,83.96 89.83,85.76 89.22,85.76 88.07,86.9 83.76,86.9 82.29,88.38 75.18,88.38 74.29,89.27 72.96,89.27 70.95,91.27 70.95,92.42 68.11,95.26 67.73,95.26 67.27,95.72 67.27,96.49 63.99,99.76 63.99,100.77 62.42,102.35 62.42,102.63 61.05,104 55.05,104 53.55,102.5 52.18,102.5 51.37,101.69 51.37,101.46 50.73,100.82 50.15,100.82 v1(49.52,101.46)
  BOTTOM w0.102: v1(49.52,101.46) 49.8,101.18 49.8,101.09 49.68,100.98 49.08,100.98 48.98,101.08 48.71,101.08 48.19,101.59 48.19,102.48 47.84,102.83 47.84,103.97 46.98,104.84 46.98,105.07 47.08,105.17 R503.1 ; U30.W11 95.31,59.9 v2(94.95,59.54)
USBP5+_CAM_C: length 1.6
  BOTTOM w0.102: CN2.8 47.22,106.53 47.1,106.4 47.1,105.83 R503.2
USBP5-_CAM: length 91.7
  IN3 w0.089: v1(50.15,101.46) 50.15,101.15 50.25,101.05 50.64,101.05 51.14,101.55 51.14,101.78 52.09,102.73 53.46,102.73 54.96,104.23 61.15,104.23 62.65,102.73 62.65,102.44 64.22,100.87 64.22,99.86 67.5,96.58 67.5,95.81 67.82,95.49 68.2,95.49 71.18,92.51 71.18,91.37 73.05,89.5 74.38,89.5 75.27,88.61 82.38,88.61 83.86,87.13 88.17,87.13 89.31,85.99 89.92,85.99 91.72,84.19 95.67,84.19 96.07,83.78 96.07,81.96 95.79,81.68 95.79,74.69 95.16,74.06 95.16,73.55 93.61,72 93.61,66.65 94.39,65.87 94.39,60.34 94.68,60.06 94.84,60.06 94.92,60.14 v2(94.92,60.38)
  BOTTOM w0.102: v1(50.15,101.46) 50.05,101.36 50.05,100.98 49.79,100.72 48.98,100.72 48.88,100.82 48.6,100.82 47.94,101.48 47.94,102.37 47.59,102.73 47.59,103.87 46.72,104.73 46.72,104.99 R502.1 ; v2(94.92,60.38) 94.54,59.99 U30.W12
USBP5-_CAM_C: length 1.7
  BOTTOM w0.102: CN2.7 46.72,106.53 46.85,106.4 46.85,105.92 R502.2
USBP7+_FP: length 85
  IN1 w0.089: v1(57.36,23.5) 57.62,23.75 57.62,23.89 57.92,24.19 61.78,24.19 63.5,22.47 69.35,22.47 70.01,21.8 79.95,21.8 82.62,24.47 91.22,24.47 92.1,23.58 94.2,23.58 95.59,24.97 95.59,25.48 97.09,26.98 97.09,29.07 97.42,29.4 97.42,32.14 97.98,32.69 97.98,34.47 98.51,35.01 98.51,35.83 97.85,36.49 97.85,43.11 98.77,44.02 98.77,44.66 99.27,45.17 99.27,45.67 99.91,46.31 99.91,46.63 99.76,46.78 99.76,47.46 100.67,48.37 100.67,52.52 99.31,53.88 98.61,53.88 98.31,54.18 98.31,55.09 97.67,55.72 97.67,57 97.83,57.15 97.83,57.69 98.99,58.86 98.99,59.4 v2(98.92,59.47)
  BOTTOM w0.102: U30.Y7 98.51,59.06 v2(98.92,59.47) ; v1(57.36,23.5) 57.54,23.32 57.54,23.05 57.53,23.05 EC1.2 57.57,21.95 57.57,21.79 57.45,21.67 CN13.7
USBP7-_FP: length 85
  IN1 w0.089: v2(99.5,59.5) 99.22,59.22 99.22,58.76 98.06,57.59 98.06,57.06 97.9,56.91 97.9,55.82 98.54,55.18 98.54,54.28 98.7,54.11 99.4,54.11 100.9,52.61 100.9,48.28 99.99,47.36 99.99,46.87 100.14,46.72 100.14,46.21 99.5,45.58 99.5,45.07 98.99,44.56 98.99,43.93 98.08,43.01 98.08,36.59 98.74,35.93 98.74,34.91 98.21,34.38 98.21,32.6 97.65,32.04 97.65,29.3 97.32,28.97 97.32,26.88 95.82,25.39 95.82,24.88 94.3,23.35 92.01,23.35 91.12,24.24 82.71,24.24 80.05,21.58 69.91,21.58 69.25,22.24 63.41,22.24 61.68,23.96 58.02,23.96 57.85,23.79 57.85,23.65 v1(58,23.5)
  BOTTOM w0.102: v1(58,23.5) 57.79,23.29 57.79,23.04 EC2.1 57.83,22.04 57.83,21.79 57.95,21.67 CN13.6 ; U30.Y6 99.5,59.29 v2(99.5,59.5)
USBP8+_TS: length 91.2
  IN1 w0.089: v1(46.92,100.44) 46.7,100.22 46.7,100.1 47.4,99.4 48.75,99.4 52.21,102.86 53.97,102.86 54.6,103.49 62.29,103.49 63.69,102.09 65.66,102.09 77.22,90.54 82.61,90.54 88.56,84.59 88.56,82.76 88.05,82.26 88.05,80.91 88.33,80.63 88.71,80.63 89.09,80.25 89.09,79.87 90.49,78.47 90.74,78.47 91.55,77.66 91.55,77 89.98,75.42 89.98,71.61 89.44,71.08 89.44,68.79 90.04,68.19 90.3,68.19 91.55,66.94 94.47,66.94 95.95,65.46 95.95,63.26 96.2,63 96.2,60.06 96.25,60.01 96.25,58.24 96.37,58.12 96.81,58.12 97.09,57.84 97.09,57.75 v2(97.34,57.51)
  BOTTOM w0.102: U30.AC9 96.91,57.07 v2(97.34,57.51) ; v1(46.92,100.44) 46.74,100.63 46.74,101.12 46.24,101.62 46.24,102.68 46.48,102.92 R516.1
USBP8-_TS: length 91.3
  IN1 w0.089: v2(96.45,57.52) 96.75,57.52 96.86,57.62 96.86,57.75 96.72,57.89 96.27,57.89 96.02,58.14 96.02,59.91 95.97,59.96 95.97,62.91 95.72,63.16 95.72,65.37 94.37,66.71 91.45,66.71 90.2,67.96 89.95,67.96 89.22,68.69 89.22,71.18 89.75,71.71 89.75,75.52 91.32,77.09 91.32,77.56 90.65,78.24 90.39,78.24 88.86,79.77 88.86,80.16 88.61,80.4 88.23,80.4 87.82,80.82 87.82,82.35 88.33,82.86 88.33,84.5 82.52,90.31 77.13,90.31 65.57,101.87 63.59,101.87 62.2,103.26 54.7,103.26 54.06,102.63 52.3,102.63 48.85,99.17 47.31,99.17 46.48,100 46.48,100.26 v1(46.29,100.44)
  BOTTOM w0.102: R515.1 45.99,102.59 45.99,101.51 46.48,101.01 46.48,100.64 v1(46.29,100.44) ; U30.AC10 96.1,57.17 v2(96.45,57.52)
