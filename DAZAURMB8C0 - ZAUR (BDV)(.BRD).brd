# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Nets (continued)
+5V_ODD: C490.2 C491.2 C492.2 C493.2 C494.1 C495.1 C496.1 CN17.9 CN17.10 CN17.11 CN17.12 CN17.13 CN17.14 CN17.15 Q21.3 R382.2
+5V_PVDD: C675.2 C677.1 C678.2 C679.1 L10.2 L14.2 U35.41 U35.46
+5V_S5: C420.1 C421.1 C422.1 C447.1 C450.1 C614.1 C656.1 C657.1 C658.1 C681.2 C682.1 C693.1 L5.1 L10.1 PR1.2 PR43.1 PR51.2 PR160.1 PR161.1 PR166.1 PR167.2 PR341.1 R335.2 R392.1 U19.19 U31.5 U36.5 U38.5
+5VA: C366.2 C367.1 C641.1 C642.2 L4.2 L5.2 U35.26
+5VPCU: C325.1 C488.2 C517.2 PC97.1 PC116.1 PC191.1 PJ8.1 PJ17.1 PR90.1 PR245.1 PR252.2 PR293.1 PR301.2 PR330.1 PU5.1 PU5.6 PU9.4(VPP) Q21.1(S) Q23.1(S) R190.1 R193.1 R393.1 R420.1 R631.2 U10.1
+A3VPCU: C448.1 L7.2 U15.74
+V3A_LX: PC263.2 PL14.1 PR331.1 PU13.2 PU13.3
+V3A_LX_R: PC274.1 PR331.2
+V3A_OUT: PC85.1 PC88.1 PC94.1 PC257.1 PC258.1 PC260.1 PC266.1 PJ6.2 PL14.2 PR309.2
+V5P5A_LX: PC299.2 PL16.1 PR345.1 PU15.2 PU15.3
+V5P5A_LX_R: PC293.1 PR345.2
+V5P5A_OUT: PC286.1 PC292.1 PC300.1 PC301.1 PC302.1 PC303.1 PC308.1 PJ17.2 PL16.2 PR348.1
+VCC_CORE: C247.1 C251.1 C252.1 C254.1 C263.1 C264.1 C269.1 C270.1 C275.1 C276.1 C290.1 C294.1 C295.1 C302.1 C303.1 C304.1 C309.1 PC52.1 PC54.1 PC57.1 PC58.1 PC59.1 PC62.1 PC63.1 PC64.1 PC66.1 PC70.1 PC72.1 PC204.1 PC213.1 PC235.1 PL11.2 PL12.2 PR263.1 PR290.2 PR295.2 U30.AA7 U30.AA10 U30.AA14 U30.AA16 U30.AA18 U30.AB13 U30.AB15 U30.AB17 U30.AB19 U30.AC14 U30.AC16 U30.AC18 U30.AD7 U30.AD10 U30.AD13 U30.AD15 U30.AD17 U30.AD19 U30.AE8 U30.AE14 U30.AE16 U30.AE18 U30.AF7 U30.AF10 U30.AF13 U30.AF15 U30.AF17 U30.AF19 U30.AG14 U30.AG16 U30.AG18 U30.AH13 U30.AH15 U30.AH17 U30.AH19 U30.AJ7 U30.AJ10 U30.AJ14 U30.AJ16 U30.AJ18 U30.AK13 U30.AK15 U30.AK17 U30.AK19 U30.G7 U30.G10 U30.G12 U30.G14 U30.H8 U30.H11 U30.H15 U30.K6 U30.K12 U30.K14 U30.L8 U30.M7 U30.M10 U30.N14 U30.P7 U30.P10 U30.P13 U30.P15 U30.R8 U30.R14 U30.R16 U30.T7 U30.T10 U30.T13 U30.T15 U30.T17 U30.U14 U30.U16 U30.V13 U30.V15 U30.V17 U30.W7 U30.W10 U30.W14 U30.W16 U30.Y8 U30.Y13 U30.Y15 U30.Y17
+VCC_V3A: PC264.1 PU13.9
+VCC_V5P5A: PC304.1 PU15.11
+VDD_08: C31.1 C32.1 C33.1 C34.1 C39.1 C40.1 C41.1 PC25.1 PC26.1 PC31.1 PC32.1 PL3.2 PR9.1 PR10.2 R494.1 U25.AC32 U25.AG32 U25.AG35 U25.AJ32 U25.AJ34 U25.AL34 U25.W32
+VDD_18: C307.1 C316.1 C649.1 R665.2 R666.2 U30.AL20 U30.AM19
+VDD_18_S5: C327.1 C391.1 C398.1 R297.2 U30.AL19 U30.AM18
+VDDCI: C62.1 C78.1 C93.1 C105.1 C112.2 C113.2 PC12.1 PC134.1 PL6.2 PR15.1 PR142.2 R89.1 R494.2 U25.AA11 U25.AE11 U25.L13 U25.L17 U25.L21 U25.L25 U25.L29 U25.N11 U25.U11
+VDDCR_SOC: C217.1 C222.1 C227.1 C245.1 C246.1 C249.1 C250.1 C253.1 C256.1 PC38.1 PC39.1 PC40.1 PC41.1 PC42.1 PC50.1 PC51.1 PC193.1 PC194.1 PC195.1 PC196.1 PC200.1 PL9.2 PR32.2 PR232.1 U30.N16 U30.N18 U30.N20 U30.P17 U30.P19 U30.R18 U30.R20 U30.T19 U30.U18 U30.U20 U30.V19 U30.W18 U30.W20 U30.Y19
+VDDQ: PR8.2 R181.1 R738.1
+VDDQ_BOOT1: PC16.1 PR4.1
+VDDQ_SR: PC139.1 PR126.2
+VDDQ_VTT: C141.1 C142.1 C143.1 C144.1 C145.1 C146.1 C147.1 C155.1 C162.1 C167.1 C173.1 C185.1 C370.2 C371.2 C386.2 C387.1 CN5.258(VTT) PR132.2 R104.1 R105.1 R106.1 R107.1 R108.1 R109.1 R110.1 R111.1 R112.1 R113.1 R114.1 R117.1 R118.1 R119.1 R123.1 R124.1 R126.1 R130.1 R132.1 R134.1 R139.1 R140.1 R144.1 R147.1 R161.1
+VIN: C43.1 PC6.1 PC7.1 PC8.1 PC11.2 PC13.2 PC14.1 PC15.1 PC17.1 PC18.1 PC48.1 PC49.1 PC53.1 PC55.1 PC69.1 PC74.1 PC78.1 PC79.1 PC80.1 PC90.1 PC96.1 PC146.1 PC158.1 PC160.1 PC164.1 PC174.1 PC176.1 PC177.1 PC178.1 PC179.1 PC180.1 PC182.1 PC183.1 PC206.1 PC207.1 PC209.1 PC210.1 PC211.1 PC214.1 PC216.1 PC217.1 PC220.1 PC229.1 PC236.1 PC238.1 PC239.1 PC247.1 PC249.1 PC250.1 PC268.1 PC269.1 PC272.1 PC273.2 PC275.2 PC276.1 PC294.1 PC295.1 PC296.1 PC297.2 PC305.2 PQ9.5 PQ14.2 PQ16.3 PQ16.4 PQ16.9 PQ17.3 PQ17.4 PQ17.9 PQ31.5 PQ32.3 PQ32.4 PQ32.9 PQ33.3 PQ33.4 PQ33.9 PQ35.5 PR2.1 PR16.2 PR22.1 PR28.1 PR170.1 PR211.1 PR212.1 PR214.1 PR227.1 PR244.2 PR257.1 PR308.2 PU1.7 PU10.8 PU10.9 PU10.22 PU10.24 PU11.8 PU11.9 PU11.22 PU11.24 PU13.5 PU15.5 R72.1
+VIN_BLIGHT: C73.1 C83.1 CN2.39 CN2.40 R72.2
AVDD2: C674.1 L13.2 U35.40
AVDD2_R: L13.1 R353.1 R370.2 R699.2
DVDD_IO: C401.1 C650.2 Q38.2 R278.1 R292.1 U35.9
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.1 C11.2 C12.1 C13.1 C14.1 C15.2 C18.2 C21.1 C22.2 C23.2 C24.1 C25.2 C26.1 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.1 C36.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C45.2 C46.1 C47.2 C48.1 C49.2 C50.1 C51.2 C52.2 C53.2 C54.2 C55.2 C56.1 C57.2 C58.2 C59.1 C60.2 C61.1 C62.2 C63.2 C64.2 C65.1 C66.2 C67.1 C68.2 C69.2 C70.1 C71.2 C72.1 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.1 C81.1 C82.2 C83.2 C84.2 C85.1 C86.2 C87.2 C88.2 C89.2 C91.1 C92.1 C93.2 C95.1 C96.1 C97.2 C98.2 C99.2 C100.2 C101.2 C102.1 C103.1 C104.2 C105.2 C106.2 C107.1 C108.1 C109.1 C110.2 C111.2 C112.1 C113.1 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.1 C126.2 C127.1 C128.2 C129.1 C130.2 C131.2 C132.2 C133.2 C134.1 C135.1 C136.2 C137.2 C138.1 C139.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C151.1 C152.1 C153.1 C154.2 C155.2 C156.2 C157.1 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.1 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C183.1 C184.1 C185.2 C186.2 C188.2 C189.1 C190.1 C191.1 C192.1 C194.1 C195.1 C197.2 C198.1 C199.1 C200.2 C201.1 C204.1 C207.1 C208.1 C209.1 C210.1 C211.1 C212.1 C213.1 C214.1 C215.2 C216.2 C217.2 C218.2 C219.2 C220.1 C221.2 C222.2 C223.1 C224.1 C225.1 C226.2 C227.2 C228.1 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.1 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.1 C258.2 C259.1 C260.1 C261.2 C263.2 C264.2 C265.2 C267.2 C268.2 C269.2 C270.2 C271.1 C272.2 C273.1 C274.2 C275.2 C276.2 C277.2 C278.1 C279.1 C280.2 C281.2 C282.2 C283.1 C284.2 C286.2 C287.2 C288.1 C290.2 C291.2 C292.1 C293.1 C294.2 C295.2 C296.2 C297.2 C298.2 C299.1 C300.2 C301.1 C302.2 C303.2 C304.2 C305.2 C306.1 C307.2 C308.1 C309.2 C310.2 C311.2 C312.2 C313.2 C314.2 C315.2 C316.2 C317.2 C318.2 C319.1 C320.1 C321.1 C322.2 C323.2 C324.2 C325.2 C326.2 C327.2 C328.1 C329.1 C330.2 C331.2 C332.2 C333.1 C334.2 C335.1 C336.1 C337.2 C338.2 C339.2 C340.1 C341.2 C342.2 C343.1 C345.2 C347.2 C349.2 C350.2 C351.2 C352.1 C353.2 C354.2 C355.1 C356.2 C358.2 C359.2 C361.2 C362.2 C363.2 C364.2 C365.2 C368.2 C369.2 C370.1 C371.1 C372.2 C373.1 C374.2 C375.2 C376.2 C377.1 C378.2 C379.2 C380.1 C381.1 C382.2 C383.2 C384.1 C385.2 C386.1 C387.2 C388.2 C389.2 C390.1 C391.2 C392.2 C393.1 C394.1 C395.1 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.1 C403.2 C404.2 C405.1 C406.2 C407.2 C408.2 C409.2 C410.1 C411.1 C412.2 C413.2 C414.1 C415.1 C416.1 C417.1 C418.2 C419.2 C420.2 C421.2 C422.2 C423.1 C424.2 C425.1 C427.2 C428.2 C429.2 C430.2 C431.2 C432.2 C433.2 C434.2 C435.2 C440.2 C441.1 C442.2 C443.2 C444.1 C445.1 C446.2 C447.2 C449.2 C450.2 C451.2 C452.2 C454.2 C459.2 C461.2 C462.2 C463.2 C464.2 C465.2 C466.2 C467.2 C468.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C477.2 C478.2 C479.1 C480.2 C482.2 C485.2 C486.2 C487.2 C489.2 C490.1 C491.1 C492.1 C493.1 C494.2 C495.2 C496.2 C497.2 C498.2 C499.2 C500.2 C501.1 C502.1 C503.2 C504.2 C509.1 C510.2 C515.2 C516.2 C518.2 C519.1 C528.1 C529.2 C530.2 C531.2 C532.2 C533.2 C534.2 C535.2 C536.2 C537.2 C538.2 C539.2 C540.2 C541.2 C542.2 C543.2 C544.1 C545.1 C546.2 C547.2 C556.1 C557.1 C558.1 C559.1 C562.1 C563.2 C564.1 C565.1 C566.1 C567.2 C568.2 C569.2 C570.2 C571.1 C573.2 C574.2 C575.1 C576.1 C577.1 C578.2 C579.2 C580.1 C581.1 C582.1 C583.2 C584.2 C585.2 C586.2 C588.2 C595.2 C609.1 C610.1 C611.1 C612.1 C613.1 C614.2 C615.2 C616.1 C617.1 C618.1 C619.2 C622.2 C623.2 C624.1 C625.1 C627.1 C628.2 C630.2 C632.2 C633.2 C634.2 C635.2 C636.1 C638.2 C644.1 C645.2 C647.1 C648.2 C649.2 C650.1 C652.2 C653.1 C654.2 C655.2 C656.2 C657.2 C658.2 C659.1 C660.1 C661.2 C662.2 C663.1 C664.1 C665.2 C667.2 C668.1 C669.2 C671.1 C672.1 C673.1 C675.1 C676.1 C677.2 C678.1 C679.2 C680.1 C681.1 C682.2 C683.2 C684.2 C685.2 C686.2 C687.2 C688.2 C689.2 C690.2 C691.2 C692.1 C693.2 C698.1 C699.1 C700.2 C701.2 C704.1 C707.1 C708.2 C709.1 C710.1 C711.1 C712.1 C713.2 C714.1 CN1.1 CN1.5 CN1.6 CN2.3 CN2.6 CN2.9 CN2.12 CN2.15 CN2.18 CN2.21 CN2.41 CN2.42 CN3.9 CN3.10 CN3.11 CN3.12(GND#4) CN4.2 CN4.5 CN4.8 CN4.11 CN4.17 CN4.20 CN4.21 CN4.22 CN4.23 CN5.1 CN5.2 CN5.5 CN5.6 CN5.9 CN5.10 CN5.14 CN5.15 CN5.18 CN5.19 CN5.22 CN5.23 CN5.26 CN5.27 CN5.30 CN5.31 CN5.35 CN5.36 CN5.39 CN5.40 CN5.43 CN5.44 CN5.47 CN5.48 CN5.51 CN5.52 CN5.56 CN5.57 CN5.60 CN5.61 CN5.64 CN5.65 CN5.68 CN5.69 CN5.72 CN5.73 CN5.77 CN5.78 CN5.81 CN5.82 CN5.85 CN5.86 CN5.89 CN5.90 CN5.93 CN5.94 CN5.98 CN5.99 CN5.102 CN5.103 CN5.106 CN5.107 CN5.167 CN5.168 CN5.171 CN5.172 CN5.175 CN5.176 CN5.180 CN5.181 CN5.184 CN5.185 CN5.188 CN5.189 CN5.192 CN5.193 CN5.196 CN5.197 CN5.201 CN5.202 CN5.205 CN5.206 CN5.209 CN5.210 CN5.213 CN5.214 CN5.217 CN5.218 CN5.222 CN5.223 CN5.226 CN5.227 CN5.230 CN5.231 CN5.234 CN5.235 CN5.238 CN5.239 CN5.243 CN5.244 CN5.247 CN5.248 CN5.251 CN5.252 CN5.256 CN5.260 CN5.261 CN5.262 CN6.4 CN6.7 CN6.10 CN6.11 CN6.12 CN6.13 CN7.3 CN7.5 CN7.7 CN7.17 CN8.14 CN8.17 CN8.22 CN8.24 CN8.31 CN8.32 CN9.4 CN9.7 CN9.10 CN9.11 CN9.12 CN9.13 CN10.2 CN10.29 CN10.30 CN11.1 CN11.7 CN11.13 CN11.18 CN11.19 CN11.33 CN11.39 CN11.45 CN11.51 CN11.57 CN11.63 CN11.69 CN11.75 CN11.76 CN11.77 CN12.4 CN12.9 CN12.10 CN13.5 CN13.9 CN13.10 CN14.5 CN14.6 CN15.5 CN15.6 CN15.7 CN15.8 CN15.9 CN15.10 CN15.A1 CN15.A12 CN15.B1 CN15.B12 CN16.2 CN16.29 CN16.30 CN17.1 CN17.4 CN17.7 CN17.17 CN17.18 CN17.19 CN17.20 CN18.1 CN18.5 CN18.6 CN19.1 CN19.3 CN19.9 CN19.15 CN19.21 CN19.27 CN19.33 CN19.39 CN19.45 CN19.51 CN19.57 CN19.71 CN19.73 CN19.75 CN19.76 CN19.77 CN20.2 D6.2 D9.1 D24.1 D26.2 D27.2 D34.1 D35.1 D36.1 D37.2 D38.1 EC1.1 EC2.2 EC3.2 FAN1.4 FAN1.5 FAN1.6 HD1.6 HD1.9 HD1.12 HD1.13 HD1.14 HE1.3 HE2.3 HOLE1.1 HOLE2.1 HOLE2.2 HOLE2.3 HOLE2.4 HOLE2.5 HOLE2.6 HOLE2.7 HOLE2.8 HOLE2.9 HOLE3.1 HOLE5.1 HOLE8.1 HOLE9.1 HOLE10.1 HOLE11.1 HOLE12.1 HOLE13.1 HOLE14.1 HOLE14.2 HOLE14.3 HOLE14.4 HOLE14.5 HOLE14.6 HOLE14.7 HOLE14.8 HOLE14.9 HOLE15.1 HOLE17.1 HOLE18.1 HOLE18.2 HOLE18.3 HOLE18.4 HOLE18.5 HOLE18.6 HOLE18.7 HOLE18.8 HOLE18.9 HOLE19.1 HOLE19.2 HOLE19.3 HOLE19.4 HOLE19.5 HOLE19.6 HOLE19.7 HOLE19.8 HOLE19.9 HOLE21.1 HOLE22.1 HOLE23.1 HOLE23.2 HOLE23.3 HOLE23.4 HOLE23.5 HOLE23.6 HOLE23.7 HOLE23.8 HOLE23.9 J1.2 L6.2 PC1.2 PC2.1 PC3.2 PC4.2 PC5.2 PC6.2 PC7.2 PC8.2 PC9.2 PC11.1 PC12.2 PC13.1 PC14.2 PC15.2 PC17.2 PC18.2 PC19.1 PC20.2 PC21.2 PC23.2 PC24.2 PC25.2 PC26.2 PC28.2 PC29.2 PC30.2 PC31.2 PC32.2 PC33.2 PC34.2 PC35.2 PC36.2 PC37.2 PC38.2 PC39.2 PC40.2 PC41.2 PC42.2 PC43.2 PC44.2 PC45.2 PC46.2 PC47.2 PC48.2 PC49.2 PC50.2 PC51.2 PC52.2 PC53.2 PC54.2 PC55.2 PC56.2 PC57.2 PC58.2 PC59.2 PC62.2 PC63.2 PC64.2 PC66.2 PC67.1 PC68.1 PC69.2 PC70.2 PC72.2 PC74.2 PC78.2 PC79.2 PC80.2 PC82.2 PC83.1 PC84.1 PC85.2 PC86.1 PC87.1 PC88.2 PC89.1 PC90.2 PC91.2 PC92.2 PC93.2 PC94.2 PC95.2 PC96.2 PC97.2 PC98.2 PC99.2 PC100.2 PC101.2 PC102.2 PC103.1 PC104.2 PC105.2 PC106.2 PC107.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.1 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC125.1 PC126.2 PC127.2 PC128.2 PC129.2 PC130.2 PC131.2 PC132.1 PC133.1 PC134.2 PC135.2 PC136.2 PC137.2 PC138.2 PC139.2 PC140.2 PC141.1 PC142.2 PC143.2 PC144.2 PC145.1 PC146.2 PC147.2 PC148.2 PC149.2 PC150.1 PC152.2 PC153.2 PC156.2 PC157.1 PC158.2 PC160.2 PC161.2 PC162.1 PC163.2 PC164.2 PC165.2 PC173.1 PC174.2 PC175.2 PC176.2 PC177.2 PC178.2 PC179.2 PC180.2 PC181.2 PC182.2 PC183.2 PC184.2 PC185.2 PC186.1 PC187.2 PC188.2 PC189.2 PC190.2 PC191.2 PC192.2 PC193.2 PC194.2 PC195.2 PC196.2 PC197.2 PC198.1 PC200.2 PC201.2 PC202.2 PC203.2 PC204.2 PC206.2 PC207.2 PC208.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC216.2 PC217.2 PC220.2 PC222.2 PC223.2 PC224.2 PC225.2 PC226.1 PC227.1 PC228.1 PC229.2 PC230.2 PC231.2 PC232.2 PC234.1 PC235.2 PC236.2 PC237.2 PC238.2 PC239.2 PC241.2 PC242.2 PC243.2 PC247.2 PC249.2 PC250.2 PC251.2 PC252.2 PC253.2 PC254.2 PC255.2 PC256.2 PC257.2 PC258.2 PC259.2 PC260.2 PC261.1 PC262.2 PC264.2 PC266.2 PC267.2 PC268.2 PC269.2 PC270.2 PC272.2 PC273.1 PC274.2 PC275.1 PC276.2 PC277.2 PC278.1 PC279.2 PC280.2 PC281.2 PC283.2 PC284.2 PC285.1 PC286.2 PC287.2 PC288.1 PC289.2 PC290.2 PC291.2 PC292.2 PC293.2 PC294.2 PC295.2 PC296.2 PC297.1 PC298.1 PC300.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.1 PC306.1 PC308.2 PD1.2 PD3.2 PD4.2 PJ11.2 PJ11.4 PJ11.5(SPRING & SHELL(-) #3) PJ18.1 PJ18.2 PJ18.9 PJ18.10 PQ2.1(S) PQ4.1(S) PQ5.1(S) PQ6.1(S) PQ7.1(S) PQ10.1(S) PQ11.1(S) PQ12.1(S) PQ13.1(S) PQ14.5 PQ14.6 PQ14.7(S2#3) PQ15.1(S) PQ16.10(S2) PQ17.10(S2) PQ18.1(S) PQ19.1(S) PQ20.1(S) PQ21.1(EMITTER) PQ22.1(S) PQ23.1(S) PQ24.1(S) PQ25.1(S) PQ28.1(S) PQ29.1(S) PQ30.1 PQ30.2 PQ30.3(S_3) PQ32.10(S2) PQ33.10(S2) PQ36.1 PQ36.2 PQ36.3(S_3) PR3.2 PR13.2 PR27.2 PR48.2 PR50.1 PR61.1 PR64.1 PR67.2 PR69.2 PR70.1 PR77.2 PR78.2 PR80.2 PR86.1 PR89.2 PR101.1 PR105.2 PR115.1 PR127.1 PR139.2 PR145.1 PR156.1 PR164.2 PR172.1 PR205.2 PR207.2 PR210.2 PR215.2 PR220.2 PR228.2 PR240.2 PR251.2 PR269.2 PR270.1 PR302.2 PR311.2 PR338.1 PR346.1 PU1.3 PU1.9 PU1.16 PU2.4 PU2.8 PU2.9 PU3.41 PU4.11 PU4.15 PU5.11 PU5.15 PU6.2 PU7.4 PU7.8 PU7.9 PU8.41 PU9.8 PU9.9 PU10.12 PU10.13 PU10.14 PU10.15 PU10.19 PU11.12 PU11.13 PU11.14 PU11.15 PU11.19 PU12.2 PU12.4 PU13.4 PU13.8 PU14.22 PU14.29 PU14.30 PU14.31 PU14.32 PU14.33 PU14.34 PU14.35 PU14.36 PU14.37 PU14.38 PU15.4 PU15.8 Q2.1(EMITTER) Q3.1(S) Q3.4 Q8.1(EMITTER) Q9.1(S) Q10.1(S) Q11.1(EMITTER) Q12.1(EMITTER) Q13.1(S) Q15.1(S) Q16.1(S) Q18.1(S) Q19.1(S) Q19.4 Q22.1(S) Q25.1(S) Q26.1(S) Q35.1(S) Q40.1(EMITTER) R3.2 R4.1 R8.1 R13.1 R22.2 R24.1 R29.2 R35.1 R36.2 R37.1 R38.1 R42.1 R44.2 R45.2 R46.1 R50.1 R59.2 R65.1 R67.2 R77.1 R79.2 R88.2 R91.1 R94.1 R95.1 R101.2 R103.2 R115.1 R120.2 R145.2 R152.2 R157.1 R158.1 R159.2 R162.1 R165.2 R166.1 R172.1 R174.2 R176.2 R177.1 R186.2 R191.1 R192.1 R196.1 R198.2 R199.1 R200.1 R209.1 R212.2 R216.1 R217.2 R218.1 R225.1 R231.1 R243.2 R244.2 R249.2 R257.1 R258.2 R262.2 R266.1 R268.2 R271.2 R272.2 R273.2 R274.1 R275.2 R289.2 R299.2 R304.2 R326.1 R327.2 R328.2 R338.1 R339.1 R351.2 R355.2 R357.1 R363.2 R365.1 R366.2 R369.2 R372.1 R374.1 R381.1 R383.2 R384.2 R390.1 R391.2 R396.2 R399.1 R402.2 R405.1 R407.1 R411.1 R414.2 R437.1 R443.1 R444.1 R445.1 R449.2 R457.1 R458.2 R459.1 R460.1 R461.1 R462.1 R463.1 R465.1 R474.2 R475.2 R479.2 R481.2 R482.1 R483.1 R484.1 R485.1 R486.1 R487.1 R488.1 R490.1 R491.1 R492.1 R496.2 R497.1 R500.2 R501.2 R511.2 R517.2 R518.1 R520.2 R524.1 R527.2 R528.1 R530.1 R533.1 R535.2 R548.1 R553.1 R555.1 R559.1 R560.2 R561.2 R566.2 R567.2 R568.2 R586.2 R592.2 R603.1 R604.1 R633.1 R640.2 R646.2 R648.1 R663.1 R664.1 R679.2 R691.1 R705.2 R709.1 R713.1 R717.2 R733.2 R737.2 RV1.2 RV2.2 RV3.3 RV3.8 RV5.2 RV6.2 RV7.3 RV7.8 RV8.1 RV9.1 SW1.1 SW1.2 SW1.5 SW1.6 SW3.3 SW3.4 U1.4 U2.33 U3.3 U4.2 U5.A2 U5.A8 U5.B2 U5.C9 U5.D2 U5.D8 U5.E1 U5.E3 U5.E8 U5.F1 U5.G8 U5.H1 U5.H9 U5.K1 U5.K9 U5.N1 U5.N9 U5.T1 U5.T7 U6.A2 U6.A8 U6.B2 U6.C9 U6.D2 U6.D8 U6.E1 U6.E3 U6.E8 U6.F1 U6.G8 U6.H1 U6.H9 U6.K1 U6.K9 U6.N1 U6.N9 U6.T1 U6.T7 U7.3 U7.8 U7.9 U7.11 U8.2 U8.5 U9.A2 U9.A8 U9.B2 U9.C9 U9.D2 U9.D8 U9.E1 U9.E3 U9.E8 U9.F1 U9.G8 U9.H1 U9.H9 U9.K1 U9.K9 U9.N1 U9.N9 U9.T1 U9.T7 U10.14 U10.17 U11.2 U12.A2 U12.A8 U12.B2 U12.C9 U12.D2 U12.D8 U12.E1 U12.E3 U12.E8 U12.F1 U12.G8 U12.H1 U12.H9 U12.K1 U12.K9 U12.N1 U12.N9 U12.T1 U12.T7 U13.3 U13.8 U13.9 U13.11 U14.3 U15.1 U15.27 U15.49 U15.91 U15.104 U16.16 U16.23 U16.33 U17.5 U17.10 U17.12 U17.13 U17.15 U17.16 U18.3 U18.13 U18.18 U18.21 U18.22 U18.23 U18.24 U18.25 U18.26 U19.25 U20.2 U21.5(VCC) U22.6 U23.3 U24.25 U25.A2 U25.A5 U25.A9 U25.A13 U25.A17 U25.A21 U25.A25 U25.A29 U25.A33 U25.A37 U25.A40 U25.AA1 U25.AA3 U25.AA5 U25.AA10 U25.AA17 U25.AA19 U25.AA25 U25.AA27 U25.AA32 U25.AA39 U25.AC3 U25.AC7 U25.AC11 U25.AC17 U25.AC19 U25.AC25 U25.AC27 U25.AC39 U25.AE1 U25.AE3 U25.AE5 U25.AE10 U25.AE17 U25.AE19 U25.AE25 U25.AE27 U25.AE32 U25.AE35 U25.AE39 U25.AG3 U25.AG7 U25.AG11 U25.AG17 U25.AG19 U25.AG25 U25.AG27 U25.AG39 U25.AG40 U25.AG41 U25.AJ1 U25.AJ3 U25.AJ5 U25.AJ10 U25.AJ11 U25.AJ35 U25.AJ39 U25.AL3 U25.AL7 U25.AL10 U25.AL11 U25.AL32 U25.AL35 U25.AL39 U25.AM17 U25.AM23 U25.AN1 U25.AN3 U25.AN7 U25.AN35 U25.AN39 U25.AN40 U25.AN41 U25.AP13 U25.AP17 U25.AR3 U25.AR7 U25.AR11 U25.AR19 U25.AR21 U25.AR25 U25.AR27 U25.AR31 U25.AR35 U25.AR39 U25.AU1 U25.AU3 U25.AU9 U25.AU23 U25.AU29 U25.AW3 U25.AW5 U25.AW7 U25.AW9 U25.AW11 U25.AW13 U25.AW15 U25.AW17 U25.AW19 U25.AW21 U25.AW23 U25.AW25 U25.AW27 U25.AW29 U25.AW31 U25.AW33 U25.AW35 U25.AW37 U25.AW39 U25.AY1 U25.AY2 U25.AY9 U25.AY12 U25.AY17 U25.AY23 U25.AY29 U25.AY37 U25.AY40 U25.AY41 U25.B1 U25.B40 U25.B41 U25.BA2 U25.BA5 U25.BA9 U25.BA17 U25.BA23 U25.BA29 U25.BA37 U25.BA40 U25.C5 U25.C7 U25.C9 U25.C11 U25.C13 U25.C15 U25.C17 U25.C19 U25.C21 U25.C23 U25.C25 U25.C27 U25.C29 U25.C31 U25.C33 U25.C35 U25.C37 U25.C39 U25.E1 U25.E3 U25.E4 U25.E9 U25.E13 U25.E17 U25.E21 U25.E25 U25.E29 U25.E39 U25.E41 U25.G3 U25.G7 U25.G11 U25.G15 U25.G19 U25.G23 U25.G27 U25.G31 U25.G35 U25.G39 U25.J1 U25.J3 U25.J5 U25.J34 U25.J37 U25.J39 U25.J40 U25.J41 U25.K21 U25.K25 U25.K29 U25.K40 U25.L3 U25.L7 U25.L11 U25.L15 U25.L19 U25.L23 U25.L27 U25.L31 U25.L35 U25.L39 U25.N1 U25.N3 U25.N5 U25.N17 U25.N19 U25.N25 U25.N27 U25.N32 U25.N37 U25.N39 U25.R3 U25.R7 U25.R11 U25.R17 U25.R19 U25.R25 U25.R27 U25.R32 U25.R35 U25.R39 U25.U1 U25.U3 U25.U5 U25.U17 U25.U19 U25.U25 U25.U27 U25.U32 U25.U37 U25.U39 U25.W3 U25.W7 U25.W11 U25.W17 U25.W19 U25.W25 U25.W27 U25.W39 U26.2 U27.3 U28.49 U29.3 U30.A3 U30.A5 U30.A7 U30.A10 U30.A12 U30.A14 U30.A16 U30.A19 U30.A21 U30.A23 U30.A26 U30.A30 U30.AA5 U30.AA13 U30.AA15 U30.AA17 U30.AA19 U30.AA23 U30.AA26 U30.AA28 U30.AA32 U30.AB2 U30.AB4 U30.AB14 U30.AB16 U30.AB18 U30.AB20 U30.AC5 U30.AC8 U30.AC11 U30.AC13 U30.AC15 U30.AC17 U30.AC19 U30.AC22 U30.AC25 U30.AD1 U30.AD5 U30.AD14 U30.AD16 U30.AD18 U30.AD20 U30.AE5 U30.AE11 U30.AE13 U30.AE15 U30.AE17 U30.AE19 U30.AF1 U30.AF3 U30.AF5 U30.AF14 U30.AF16 U30.AF18 U30.AF20 U30.AG5 U30.AG8 U30.AG11 U30.AG13 U30.AG15 U30.AG17 U30.AG19 U30.AH14 U30.AH16 U30.AH18 U30.AH20 U30.AJ1 U30.AJ3 U30.AJ5 U30.AJ13 U30.AJ15 U30.AJ17 U30.AJ19 U30.AK5 U30.AK8 U30.AK11 U30.AK14 U30.AK16 U30.AK18 U30.AK20 U30.AL1 U30.AL5 U30.AL7 U30.AL10 U30.AL16 U30.AM5 U30.AM8 U30.AM11 U30.AM15 U30.AM20 U30.AN1 U30.AN5 U30.AN7 U30.AN10 U30.AN22 U30.AN23 U30.AN26 U30.AP5 U30.AP8 U30.AP13 U30.AP15 U30.AP18 U30.AP20 U30.AP25 U30.AR1 U30.AR5 U30.AR7 U30.AR12 U30.AR14 U30.AR16 U30.AR19 U30.AR21 U30.AR26 U30.AR28 U30.AT23 U30.AU5 U30.AU8 U30.AU11 U30.AU13 U30.AU15 U30.AU18 U30.AU20 U30.AU22 U30.AU25 U30.AU28 U30.AV1 U30.AV5 U30.AV7 U30.AV10 U30.AV12 U30.AV14 U30.AV16 U30.AV19 U30.AV21 U30.AV23 U30.AV26 U30.AV28 U30.AV32 U30.AW5 U30.AW28 U30.AY6 U30.AY7 U30.AY8 U30.AY10 U30.AY11 U30.AY12 U30.AY13 U30.AY14 U30.AY15 U30.AY16 U30.AY18 U30.AY19 U30.AY20 U30.AY21 U30.AY22 U30.AY23 U30.AY25 U30.AY26 U30.AY27 U30.BB1 U30.BB32 U30.BD3 U30.BD7 U30.BD10 U30.BD12 U30.BD14 U30.BD16 U30.BD19 U30.BD21 U30.BD23 U30.BD26 U30.BD30 U30.C3 U30.C10 U30.C32 U30.E7 U30.E8 U30.E10 U30.E11 U30.E12 U30.E13 U30.E14 U30.E15 U30.E16 U30.E18 U30.E19 U30.E20 U30.E21 U30.E22 U30.E23 U30.E25 U30.E26 U30.E27 U30.F5 U30.F19 U30.F21 U30.F23 U30.F28 U30.G1 U30.G3 U30.G5 U30.G16 U30.G26 U30.G28 U30.G32 U30.H5 U30.H13 U30.H18 U30.H20 U30.H22 U30.H25 U30.H28 U30.J19 U30.K1 U30.K3 U30.K5 U30.K16 U30.K21 U30.K26 U30.K28 U30.K32 U30.L5 U30.L13 U30.L15 U30.L18 U30.L20 U30.L25 U30.L28 U30.M1 U30.M3 U30.M5 U30.M21 U30.M23 U30.M26 U30.M28 U30.M32 U30.N5 U30.N8 U30.N11 U30.N13 U30.N15 U30.N17 U30.N22 U30.N25 U30.N28 U30.P1 U30.P5 U30.P14 U30.P16 U30.P18 U30.P20 U30.P23 U30.P26 U30.P28 U30.P32 U30.R5 U30.R11 U30.R13 U30.R15 U30.R17 U30.R19 U30.R22 U30.R25 U30.R28 U30.T1 U30.T3 U30.T5 U30.T14 U30.T16 U30.T18 U30.T20 U30.T23 U30.T26 U30.T28 U30.T32 U30.U13 U30.U15 U30.U17 U30.U19 U30.V2 U30.V4 U30.V5 U30.V8 U30.V11 U30.V14 U30.V16 U30.V18 U30.V20 U30.V22 U30.V25 U30.V28 U30.W5 U30.W13 U30.W15 U30.W17 U30.W19 U30.W23 U30.W26 U30.W28 U30.W32 U30.Y1 U30.Y3 U30.Y5 U30.Y11 U30.Y14 U30.Y16 U30.Y18 U30.Y20 U30.Y22 U30.Y25 U30.Y28 U31.2 U32.5 U33.3 U34.4 U35.49 U36.2 U37.4 U38.2 U39.9 VRAM1.A1 VRAM1.A3 VRAM1.A12 VRAM1.A14 VRAM1.B5 VRAM1.B10 VRAM1.C1 VRAM1.C3 VRAM1.C4 VRAM1.C11 VRAM1.C12 VRAM1.C14 VRAM1.D10 VRAM1.E1 VRAM1.E3 VRAM1.E12 VRAM1.E14 VRAM1.F5 VRAM1.F10 VRAM1.G5 VRAM1.G10 VRAM1.H1 VRAM1.H2 VRAM1.H13 VRAM1.H14 VRAM1.K1 VRAM1.K2 VRAM1.K13 VRAM1.K14 VRAM1.L5 VRAM1.L10 VRAM1.M5 VRAM1.M10 VRAM1.N1 VRAM1.N3 VRAM1.N12 VRAM1.N14 VRAM1.P10 VRAM1.R1 VRAM1.R3 VRAM1.R4 VRAM1.R11 VRAM1.R12 VRAM1.R14 VRAM1.T5 VRAM1.T10 VRAM1.U1 VRAM1.U3 VRAM1.U12 VRAM1.U14 VRAM2.A1 VRAM2.A3 VRAM2.A12 VRAM2.A14 VRAM2.B5 VRAM2.B10 VRAM2.C1 VRAM2.C3 VRAM2.C4 VRAM2.C11 VRAM2.C12 VRAM2.C14 VRAM2.D10 VRAM2.E1 VRAM2.E3 VRAM2.E12 VRAM2.E14 VRAM2.F5 VRAM2.F10 VRAM2.G5 VRAM2.G10 VRAM2.H1 VRAM2.H2 VRAM2.H13 VRAM2.H14 VRAM2.K1 VRAM2.K2 VRAM2.K13 VRAM2.K14 VRAM2.L5 VRAM2.L10 VRAM2.M5 VRAM2.M10 VRAM2.N1 VRAM2.N3 VRAM2.N12 VRAM2.N14 VRAM2.P10 VRAM2.R1 VRAM2.R3 VRAM2.R4 VRAM2.R11 VRAM2.R12 VRAM2.R14 VRAM2.T5 VRAM2.T10 VRAM2.U1 VRAM2.U3 VRAM2.U12 VRAM2.U14 Y1.2 Y1.4 Y2.2 Y2.4 Y4.2 Y4.4
V3A_BOOT: PR312.2 PU13.1
V3A_BOOT_R: PC263.1 PR312.1
V3A_EN: PC87.2 PR71.2 PR73.2 PU13.6
V3A_PWRGD: PR318.2 PU13.7
V3A_VBYP: PC262.1 PR63.2 PR66.2 PU13.11
V3A_VOUT: PC261.2 PR59.2 PR62.2 PR309.1 PU13.10(VOUT)
V5P5A_BOOT: PR347.2 PU15.1
V5P5A_BOOT_R: PC299.1 PR347.1
V5P5A_EN: PC298.2 PR111.2 PR113.2 PU15.6
V5P5A_PWRGD: PR351.2 PU15.7
V5P5A_VOUT: PC306.2 PR348.2 PR349.2 PR350.2 PU15.10(VOUT)
VBUS_EN: R314.1 R405.2 U19.15
VBUS_EN_EC_R: Q18.3 R314.2 U36.4
VDD08_PG: PR19.2 PR20.1 PR128.1
VDDBT_RTC: C311.1 C347.1 J1.1 Q16.3 R261.1 U30.AJ11
VDDCI_CORE_SENSE: PR18.2 U25.AV13
VDDP: PQ34.1 PQ34.2 PQ34.3(S3) PR58.1 PR314.2 R544.1 R545.1 R570.2
VDDP_S5: PJ15.1 PQ34.5 R280.1 R288.1
VDDQ_BOOT: PR4.2 PU1.18
VDDQ_PG: PR134.2 PU1.8
VDDQ_SLP_S4: PC133.2 PR120.2 PR121.2 PU1.11
VDDQ_SW: PC16.2 PL2.1 PR126.1 PU1.17
VDDQ_SW_VPP: PL1.1 PU1.15
VDDQ_VCC: PC1.1 PC2.2 PC3.1 PR1.1 PU1.13 PU1.14
VDDQ_VDDQSNS: PR6.2 PR12.1 PU1.5
VDDQ_VLDOIN: PC142.1 PR7.2 PU1.1
VDDQ_VTT: PC21.1 PC143.1 PR5.2 PR132.1 PU1.2
VDDQ_VTT_CNTL: PC132.2 PR122.2 PU1.10(VTT_CNTL)
VDDQ_VTTREF: PC19.2 PR8.1 PU1.6
VDDQ_VTTSNS: PR5.1 PU1.4
VSS_GPU_SENSE: PR209.2 U25.AU13
VSS_SENSEA: R543.1 R546.1 U30.J22
2D_ACCEL_INT#: R591.1 U30.AM1
2ND_MBCLK: Q7.3 Q29.6 R260.1 U15.115
2ND_MBDATA: Q7.6 Q29.3 R259.1 U15.116
2ND_S5ON: PR329.1 R733.1 U15.48
6D_ACCEL_GYRO_INT#: R594.1 U30.AU2
32K_X1: C619.1 R600.1 U30.AY1 Y3.1
32K_X2: C622.1 R600.2 U30.AY4 Y3.2
48M_X1: C625.2 R610.2 U30.BB3 Y4.1
48M_X2: C624.2 R610.1 U30.BA5 Y4.3
256_I2C_SCL: R654.2 TP80.1
256_I2C_SDA: R655.2 TP79.1
3622AC_PVCC: PC68.2 PR51.1 PU3.34
3622AM_PVCC_GPU: PC162.2 PR167.1 PU8.34
3662AC_BOOT1: PR46.1 PU3.38
3662AC_BOOT2: PR54.1 PU3.2
3662AC_CPU_HG1: PQ32.1 PR254.2
3662AC_CPU_HG2: PQ33.1 PR266.2
3662AC_CPU_LG1: PQ32.8 PU3.35
3662AC_CPU_LG2: PQ33.8 PU3.39
3662AC_CPU_LX1: PC71.1 PL11.1 PQ32.5 PQ32.6 PQ32.7 PR33.1 PR288.2 PU3.36
3662AC_CPU_LX2: PC73.1 PL12.1 PQ33.5 PQ33.6 PQ33.7 PR285.1 PR297.2 PU3.40
3662AC_CPUISEN1N: PC75.1 PR275.2 PR279.1 PR292.2 PR295.1
3662AC_CPUISEN1P: PR280.2 PR288.1
3662AC_CPUISEN2N: PC77.1 PR278.1 PR286.1 PR287.2 PR290.1
3662AC_CPUISEN2P: PR291.2 PR297.1
3662AC_EN: PC222.1 PR36.2 PU3.29
3662AC_HG1: PR254.1 PU3.37
3662AC_HG2: PR266.1 PU3.1
3662AC_IMON_CPU: PC232.1 PR268.2 PU3.14
3662AC_IMON_NB: PC230.1 PR259.2 PU3.16
3662AC_ISEN1N_CPU: PC234.2 PR275.1 PR286.2 PU3.10
3662AC_ISEN1P_CPU: PC75.2 PR279.2 PR280.1 PR287.1 PU3.9
3662AC_ISEN2P_CPU: PC77.2 PR278.2 PR291.1 PR292.1 PU3.7
3662AC_ISENP_NB: PC61.1 PR31.2 PR35.1 PU3.25
3662AC_NB_HG1: PQ31.4 PR39.2
3662AC_NB_LG1: PQ30.4 PU3.33
3662AC_NB_LX1: PC65.1 PL9.1 PQ30.5 PQ31.1 PQ31.2 PQ31.3(S3) PR30.2 PR241.1 PU3.32
3662AC_PGOOD: PR52.2 PU3.3
3662AC_PWROK: PR42.2 PU3.18
3662AC_RGND: PC233.2 PR230.1 PR269.1 PR271.1 PU3.4
3662AC_SVC: PR40.2 PU3.19
3662AC_SVD: PR38.2 PU3.20
3662AC_SVT: PR37.2 PU3.21
3662AC_TSEN: PR281.2 PR282.2 PU3.12
3662AC_TSEN_NB: PR231.2 PR235.2 PU3.23
3662AC_VCC: PC67.2 PR43.2 PU3.17
3662AC_VDDIO: PC225.1 PR256.2 PU3.22
3662AC_VRHOT: PR53.2 PU3.11
3662ACCOMP_CPU: PC76.1 PR276.1 PU3.5
3662ACCOMP_NB: PC60.1 PR34.1 PU3.27
3662ACFB_CPU: PC76.2 PC240.2 PR276.2 PR289.2 PU3.6
3662ACFB_NB: PC60.2 PC221.2 PR34.2 PR255.2 PU3.26
3662ACNBISENN: PC61.2 PC224.1 PR32.1 PR35.2 PU3.24
3662ACNBISENP: PR30.1 PR31.1
3662ACSET1: PR49.2 PR55.2 PU3.13
3662AM_BOOT1_GPU: PR174.1 PU8.38
3662AM_BOOT2_GPU: PR186.1 PU8.2
3662AM_BOOT_VDDCI: PR158.1 PU8.30
3662AM_COMP_GPU: PC171.1 PR183.1 PU8.5
3662AM_COMP_VDDCI: PC155.1 PR154.1 PU8.27
3662AM_EN_GPU: PC149.1 PR119.1 PR128.2 PR135.2 PU8.29
3662AM_FB_GPU: PC171.2 PC172.2 PR183.2 PR191.2 PU8.6
3662AM_FB_VDDCI: PC151.2 PC155.2 PR139.1 PR146.2 PR154.2 PU8.26
3662AM_GPU_ISEN1N: PC168.1 PR181.1 PR187.2 PR188.1 PR189.2
3662AM_GPU_ISEN1P: PR180.2 PR184.1
3662AM_GPU_ISEN2N: PC169.2 PR182.2 PR190.2 PR194.1 PR196.1
3662AM_GPU_ISEN2P: PR195.1 PR197.1
3662AM_HG1_GPU: PQ16.1 PR185.2
3662AM_HG1_VDDCI: PQ14.1 PR130.2
3662AM_HG2_GPU: PQ17.1 PR198.2
3662AM_IMON_GPU: PC165.1 PR171.2 PU8.14
3662AM_IMON_VDDCI: PC161.1 PR138.2 PU8.16
3662AM_ISEN1N_GPU: PC173.2 PR189.1 PR194.2 PU8.10
3662AM_ISEN1P_GPU: PC168.2 PR180.1 PR181.2 PR182.1 PU8.9
3662AM_ISEN2P_GPU: PC169.1 PR187.1 PR190.1 PR195.2 PU8.7
3662AM_ISENP_VDDCI: PC154.1 PR147.2 PR151.1 PR161.2 PU8.25
3662AM_LG1_GPU: PQ16.8 PU8.35
3662AM_LG1_VDDCI: PQ14.8 PU8.33
3662AM_LG2_GPU: PQ17.8 PU8.39
3662AM_LX1_GPU: PC166.1 PL7.1 PQ16.5 PQ16.6 PQ16.7 PR23.1 PR184.2 PU8.36
3662AM_LX1_VDDCI: PC159.1 PL6.1 PQ14.9 PR11.1 PR140.2 PU8.32
3662AM_LX2_GPU: PC167.1 PL8.1 PQ17.5 PQ17.6 PQ17.7 PR197.2 PR199.1 PU8.40
3662AM_PGOOD_GPU: PR179.2 PU8.3
3662AM_PWROK_GPU: PR168.2 PU8.18
3662AM_RGND_GPU: PC170.2 PR207.1 PR209.1 PU8.4
3662AM_SET1_GPU: PR173.2 PR176.2 PU8.13
3662AM_SVC_GPU: PR163.2 PU8.19
3662AM_SVD_GPU: PR155.2 PU8.20
3662AM_SVT_GPU: PR159.2 PU8.21
3662AM_TSEN_GPU: PR201.2 PR203.2 PU8.12
3662AM_TSEN_VDDCI: PR118.2 PR123.2 PU8.23
3662AM_UGATE1_GPU: PR185.1 PU8.37
3662AM_UGATE2_GPU: PR198.1 PU8.1
3662AM_UGATE_VDDCI: PR130.1 PU8.31
3662AM_VCC_GPU: PC157.2 PR166.2 PU8.17
3662AM_VDDCI_ISENN: PC148.1 PC154.2 PR142.1 PR151.2 PR162.2
3662AM_VDDCI_ISENP: PR140.1 PR147.1
3662AM_VDDIO_GPU: PC152.1 PR131.2 PU8.22
3662AM_VRHOT_GPU: PR24.2 PU8.11
3662AM_VSEN_GPU: PR192.1 PU8.8(VSEN)
3662NBBOOTNB: PR41.1 PU3.30
3662NBUGATENB: PR39.1 PU3.31
5213EN_1.8V: PC120.1 PR103.1 PU7.7
5213EN_VDD08: PC23.1 PR17.1 PU2.7
5213FB_1.8V: PC124.2 PR100.2 PR101.2 PU7.1
5213FB_1.8V_S: PC124.1 PR99.1 PR100.1
5213FB_VDD08: PC22.2 PR13.1 PR14.2 PU2.1
5213LX_1.8V: PL4.1 PR98.1 PU7.6
5213LX_VDD08: PL3.1 PU2.6
5213PG_1.8V: PR94.2 PU7.2
5213PG_VDD08: PR20.2 PU2.2
5447_CC1_CON: C515.1 C692.2 CN15.A5 D35.2 U19.12
5447_CC2_CON: C499.1 C704.2 CN15.B5 D38.2 U19.14
8801EN: PC185.1 PR218.2 PR221.1 PR222.2 PU9.2
24780_ACDET: PQ7.3 PR70.2 PR321.2 PU14.6
24780_ACDRV: PR320.2 PU14.4
24780_ACN: PC82.1 PC265.2 PR22.2 PU14.1
24780_ACP: PC83.2 PC265.1 PR21.2 PU14.2
24780_BATDRV: PR85.2 PU14.18
24780_BATSRC: PR92.2 PU14.17
24780_BM#: PR334.1 PU14.16
24780_BST: PR328.1 PU14.25
24780_CMPIN: PR80.1 PU14.13
24780_CMPOUT: PR332.1 PU14.14
24780_CMSRC: PR319.2 PU14.3
24780_DH: PQ35.4 PU14.26
24780_DL: PQ36.4 PU14.23
24780_ILIM: PC103.2 PR89.1 PR91.1 PU14.21
24780_LX: PC271.1 PL15.1 PQ35.1 PQ35.2 PQ35.3(S_3) PQ36.5 PR340.1 PU14.27
24780_PROCHOT: PR81.1 PR84.1 PU14.10
24780_SRN: PC282.1 PC285.2 PR339.1 PR343.1
24780_SRP: PC278.2 PC282.2 PR336.1 PR342.1
24780_VCC: PC267.1 PR74.1 PU14.28(VCC)
25810_POL#_EC: R336.2 R337.1 TP37.1
+601_VCC: C451.1 C452.1 C459.1 C498.1 C504.1 C516.1 R364.2 R371.2 R380.2 R389.2 R398.2 R406.2 R410.2 R417.2 U18.10 U18.20(VCC#2)
+APU_VDD_33: C388.1 C392.1 C399.1 R295.2 U30.AL18 U30.AM17
+APU_VDD_33_S5: C382.1 C389.1 C396.1 R291.2 U30.AL17 U30.AM16
+APU_VDDIO_AZ: C350.1 C351.1 R240.2 U30.AP9
+AZA_CPVDD: C665.1 R320.1 R329.2 R354.2 U35.36
+AZA_DVDD: C664.2 C669.1 R334.2 R344.2 R647.2 R678.2 U35.1
+ECSPI: R283.2 R284.1 R293.1 R683.2 U37.8
+G_SEN_PW: C449.1 C485.1 R340.2 R378.2 R386.2 U17.1(VDD_IO) U17.8 U17.14
+TYPEC_VBUS: C435.1 C500.1 C660.2 CN15.A4 CN15.A9 CN15.B4 CN15.B9(VBUS_4) R373.2 U36.1(OUT)
+USBPWR0: C277.1 C301.2 C306.2 C609.2 CN6.1 R573.1 R574.1 U7.2(VDD) U10.12(VOUT)
+USBPWR1: C613.2 C617.2 C618.2 C633.1 CN9.1 R573.2 R574.2 U13.2(VDD) U31.1(OUT)
+VGA_CORE: C53.1 C54.1 C55.1 C58.1 C59.2 C76.1 C77.1 C80.2 C81.2 C89.1 C91.2 C92.2 C98.1 C99.1 C109.2 C110.1 PC33.1 PC34.1 PC35.1 PC36.1 PC37.1 PC156.1 PC181.1 PL7.2 PL8.2 PR141.1 PR188.2 PR196.2 PR206.1 R89.2 U25.AA13 U25.AA15 U25.AA21 U25.AA23 U25.AA29 U25.AA31 U25.AC13 U25.AC15 U25.AC21 U25.AC23 U25.AC29 U25.AC31 U25.AE13 U25.AE15 U25.AE21 U25.AE23 U25.AE29 U25.AE31 U25.AG13 U25.AG15 U25.AG21 U25.AG23 U25.AG29 U25.AG31 U25.AJ13 U25.AJ15 U25.AJ17 U25.AJ19 U25.AJ21 U25.AJ23 U25.AJ25 U25.AJ27 U25.AJ29 U25.AJ31 U25.AL13 U25.AL15 U25.AL17 U25.AL19 U25.AL21 U25.AL23 U25.AL25 U25.AL27 U25.AL29 U25.AL31 U25.N13 U25.N15 U25.N21 U25.N23 U25.N29 U25.N31 U25.R13 U25.R15 U25.R21 U25.R23 U25.R29 U25.R31 U25.U13 U25.U15 U25.U21 U25.U23 U25.U29 U25.U31 U25.W13 U25.W15 U25.W21 U25.W23 U25.W29 U25.W31
+VREF_CA0: C286.1 C288.2 C298.1 CN5.164 R181.2 R183.2 R186.1
+VREF_CA1: C149.1 C153.2 C197.1 C199.2 C273.2 C274.1 C336.2 C338.1 R736.2 R737.1 R738.2 U5.M1 U6.M1 U9.M1 U12.M1
AC_PRESENT_EC: R28.2 U15.84 U30.BA8
ACCEL_INT2: D11.1(CATHODE) R707.2
ACCEL_INT2_R: D11.2 U17.9
ACCEL_INTA: C423.2 D10.1(CATHODE) R230.1 U30.AU10
ACCEL_INTA_R: D10.2 U17.11
ACIN: PR65.2 PR69.1 PR317.1 U15.72
ACP_WOV_CLK: U8.4 U30.AG6
ACP_WOV_DAT: R195.1 R196.2 U30.AG7
ACZ_BCLK_R: R588.2 U30.AN6
ACZ_RST#_R: R587.2 U30.AM6
ACZ_SDOUT_R: R585.2 U30.AK6
ACZ_SPKR: D32.2 U30.AR11
ACZ_SYNC_R: R590.2 U30.AN8
ADBIA0: U25.H21 VRAM1.J4
ADBIA1: U25.H19 VRAM2.J4
ADOGND: C337.1 C366.1 C367.2 C620.1 C621.1 C628.1 C629.1 C637.1 C640.2 C641.2 C642.1 C646.2 C651.1 C670.1 C674.2 CN8.1 CN8.3 CN8.5 CN8.12 R244.1 R268.1 R271.1 R275.1 R299.1 R328.1 R606.2 R613.2 R657.1 U35.25 U35.38
ADP_ID: PJ11.3 PQ7.2 PR60.2 PR67.1
AGPIO30: TP69.1 U30.BC9
AGPIO31: TP68.1 U30.BB10
AGPIO68: TP24.1 U30.AU12
AGPIO76: TP67.1 U30.BB11
AMP_MUTE#: D15.1(CATHODE) U15.108
ANALOGIO: R492.2 U25.AY38
APU_ALERT#: R541.1 U30.C22
APU_BT_OFF: D8.1(CATHODE) U30.AM2
APU_DBREQ#: C339.1 R219.2 R220.1 U30.AT2
APU_DIGITAL_CLK: CN1.3 L8.2 R189.1
APU_DIGITAL_D1: CN1.2 L9.2 R195.2
APU_DISP_ON: R557.1 R560.1 U30.D23
APU_DPST_PWM: R552.1 R566.1 U30.C23
APU_LVDS_BLON: R558.1 R561.1 U30.A22
APU_OC1#: R571.1 U30.AE10
APU_PWRGD_D: R596.1 U11.3
APU_PWRGD_SVID_REG: C612.2 PR42.1 PR258.2 R595.2 R596.2 U30.AW4
APU_PWROK_BUF: CN7.10 R206.1 U11.4(Y2)
APU_RST#: C616.2 R597.2 U11.1 U30.AW3
APU_RST_L_BUF: CN7.12 R203.1 U11.6
APU_SIC: Q7.4 R131.1 U30.B22 U32.8
APU_SID: Q7.1(S) R135.1 U30.D22 U32.7
APU_SPI_CLK_M: Q31.1(S) R622.1 R646.1 R649.1 R652.1
APU_SPI_CLK_R1: C627.2 Q31.3 R311.1 R638.1 R652.2
APU_SPI_CLK_R2: R622.2 U30.BC10
APU_SPI_CS0#_R1: R621.2 R676.1
APU_SPI_CS0#_R2: R621.1 U30.BD11
APU_SPI_HOLD#_R1: R636.2 R637.1 TP75.1 U34.7
APU_SPI_HOLD#_R2: R636.1 U30.BC8
APU_SPI_SI_R1: R325.1 R626.2 R639.1
APU_SPI_SI_R2: R626.1 U30.BB8
APU_SPI_SO_R1: Q33.3 R611.2 R629.1 R669.1
APU_SPI_SO_R2: R611.1 R623.1 U30.BA10
APU_SPI_SO_TPM: Q33.1(S) R350.1 R358.1 R629.2
APU_SPI_WP_R1: R624.2 R668.1
APU_SPI_WP_R2: R624.1 U30.BA9
APU_SUSB#: C403.1 R296.2 U14.1 U30.AT11
APU_SUSCLK: R435.2 R696.2 U33.4(Y)
APU_SVC: C580.2 PC228.2 PR40.1 R549.2 R563.2
APU_SVD: C577.2 PC226.2 PR38.1 R551.2 R565.2
APU_SVT: C576.2 PC227.2 PR37.1 R550.2 R564.2
APU_TCK: CN7.2 R194.1 U30.AR2
APU_TDI: C615.1 R598.1 R599.2 U30.AP3
APU_TDO: CN7.8 U30.AU1
APU_TEST4: TP73.1 U30.BB6
APU_TEST5: TP70.1 U30.BD5
APU_TEST14: R531.1 U30.G25
APU_TEST15: R537.1 U30.K25
APU_TEST16: R538.1 U30.F25
APU_TEST17: R532.1 U30.F26
APU_TEST41: TP21.1 U30.AK9
APU_THERMTRIP#: R221.1 R731.1 R732.1 U30.AN9
APU_TMS: CN7.4 R197.1 U30.AU3
APU_TRST#: C332.1 R214.1 R215.2 U30.AR4
APU_TS_INT#: Q4.3 R228.1 U30.AV6
APU_USBC_SCL_Q: TP23.1 U30.AL9
APU_USBC_SDA_Q: TP22.1 U30.AL8
APU_VDD_RUN_FB_H: PR265.2 TP56.1 U30.K22
APU_VDD_RUN_FB_L: PR271.2 R546.2
APU_VDDIO_MEM_FB_H: PR12.2 U30.J21
APU_VDDP_ALW_FB_H: PR306.2 U30.AK7
APU_VDDP_RUN_FB_H: PR315.2 U30.AK12
APU_VDDP_RUN_FB_L: PR316.2 U30.AJ12
APU_VDDSOC_RUN_FB_H: PR229.2 TP55.1 U30.J23
APU_VDDSOC_RUN_FB_L: PR230.2 R543.2
AUX_ZVSS: R520.1 U25.BA12
BAT-V: PC287.1 PC288.2 PC289.1 PC290.1 PC291.1 PD2.1 PJ18.7 PJ18.8 PR343.2 PR344.2
BATLED0#: CN8.21 U15.29
BATLED1#: CN8.20 U15.25
BI: PJ18.6 PR105.1 R233.1 SW2.1 SW2.2
BL#: Q3.2 Q3.3 R83.1
BL_ON: CN2.26 D4.2 Q2.3 Q3.6 R76.1
BOARD_ID2: R257.2 R281.1 U30.AW11
BOARD_ID3: R663.2 R673.1 U30.BC17
BOARD_ID4: C556.2 R91.2 R92.1 R504.1 U30.AR13
BOARD_ID5: R231.2 R232.1 U30.AP10
BOARD_ID6: C558.2 R93.1 R94.2 R506.1 U30.AW15
BP_0: R7.2 TP2.1 U25.AA38
BP_1: R30.2 TP7.1 U25.AA37
BRIGHT: R68.2 R69.2 R70.1
BT_EN: R303.2 R306.2
BT_EN_R: CN11.54(W_DISABLE2#) R306.1 R309.1
C1: R709.2 R710.1 U39.12
C2: R713.2 R714.1 U39.6
C_IN_CLK: C203.2 U28.47
C_IN_CLK#: C205.2 U28.48
C_IN_D0: C196.2 U28.44
C_IN_D0#: C202.2 U28.45
C_IN_D1: C187.2 U28.41
C_IN_D1#: C193.2 U28.42
C_IN_D2: C181.2 U28.38
C_IN_D2#: C182.2 U28.39
C_TX0_HDMI+: R154.1 U28.17
C_TX0_HDMI-: R148.1 U28.16
C_TX1_HDMI+: R149.1 U28.20
C_TX1_HDMI-: R155.1 U28.19
C_TX2_HDMI+: R143.1 U28.23
C_TX2_HDMI-: R146.1 U28.22
C_TXC_HDMI+: R169.2 U28.14
C_TXC_HDMI-: R171.2 U28.13
CASA0B: U25.D23 VRAM1.L3
CASA1B: U25.D17 VRAM2.G3
CCDPWRON#: Q43.2 R734.1 U15.31
CKEA0: U25.G21 VRAM1.J3
CKEA1: U25.E19 VRAM2.J3
CLK_LPC_DEBUG: C635.1 C701.1 R620.1 R706.1 R716.1
CLK_LPC_DEBUG_C: CN11.71 R716.2
CLK_PCI_EC: C638.1 R322.2 R614.1 U15.13
CLK_PCIE_LANN: R581.1 U2.16
CLK_PCIE_LANN_R: R581.2 U30.AH4
CLK_PCIE_LANP: R582.1 U2.15
CLK_PCIE_LANP_R: R582.2 U30.AH2
CLK_PCIE_SSDN: R580.1 R728.1
CLK_PCIE_SSDN_C: CN19.53 R728.2
CLK_PCIE_SSDN_R: R580.2 U30.AF4
CLK_PCIE_SSDP: R579.1 R727.1
CLK_PCIE_SSDP_C: CN19.55 R727.2
CLK_PCIE_SSDP_R: R579.2 U30.AF2
CLK_PCIE_VGA_N: R577.1 U25.AU33
CLK_PCIE_VGA_N_R: R577.2 U30.AF9
CLK_PCIE_VGA_P: R575.1 U25.AV33
CLK_PCIE_VGA_P_R: R575.2 U30.AF8
CLK_PCIE_WLANN: CN11.49 R584.1
CLK_PCIE_WLANN_R: R584.2 U30.AJ4
CLK_PCIE_WLANP: CN11.47 R583.1
CLK_PCIE_WLANP_R: R583.2 U30.AJ2
CLKA0: R49.2 U25.E31 VRAM1.J12
CLKA0B: R51.2 U25.D31 VRAM1.J11
CLKA1: R127.2 U25.D7 VRAM2.J12
CLKA1B: R125.2 U25.D9 VRAM2.J11
CLKRUN#: R618.1 U15.93 U30.BD13
CLR_CMOS: Q16.2 R262.1 U15.19
CODEC_VREF: C651.2 U35.28(VREF)
CORE_PWM_PROCHOT#: PR53.1 PR81.2 Q35.3 R562.1 U30.B25
CSA0B_0: U25.H31 VRAM1.G12
CSA1B_0: U25.E7 VRAM2.L12
CSCL: R540.2 U28.29
CSDA: R539.2 U28.28
CTL2: R193.2 U10.7
CTL3: R190.2 U10.8
DBGDATA_0: R476.2 R490.2 U25.L40
DBGDATA_1: R477.2 R491.2 U25.L41
DBGDATA_2: R454.2 R463.2 U25.M40
DBGDATA_3: R473.2 R487.2 U25.M41
DBGDATA_4: R472.2 R486.2 U25.N40
DBGDATA_5: R453.2 R462.2 U25.N41
DBGDATA_6: R452.2 R461.2 U25.P40
DBGDATA_7: R471.2 R485.2 U25.P41
DBRDY1: CN7.15 R603.2
DBRDY2: CN7.13 R216.2
DBRDY3: CN7.11 R209.2
DC-DET: R304.1 R315.1 U35.4
DCIN_ENB: R165.1 U28.3
DDBIA0_0: U25.J38 VRAM1.D2
DDBIA0_1: U25.F40 VRAM1.D13
DDBIA0_2: U25.A38 VRAM1.P13
DDBIA0_3: U25.B30 VRAM1.P2
DDBIA1_0: U25.B25 VRAM2.D2
DDBIA1_1: U25.B18 VRAM2.D13
DDBIA1_2: U25.A12 VRAM2.P2
DDBIA1_3: U25.B5 VRAM2.P13
DDR4_SUSON_2V5: PR120.1 U15.122
DE1: R389.1 R390.2 U18.9
DE2: R380.1 R381.2 U18.8
DEBUG_CLK: CN11.60 R706.2
DEBUG_IRQ: CN11.62 R712.2
DEVSLP0: R693.1 U30.AK10
DEVSLP1: D25.1(CATHODE) R430.1 U30.BC6
DEVSLP_HDD: HD1.5 Q39.1(S) R715.2 R717.1 R718.2
DEW1: R410.1 R411.2 U18.16
DEW2: R364.1 R365.2 U18.6
DGPU_DP_HPD: TP49.1 U25.AV25
DGPU_OPP#: D1.1(CATHODE) R33.1 R34.2 R43.2 U15.71
DGPU_PW_CTRL#: R643.1 R648.2 U30.AW14
DGPU_PWREN: PR238.2 PR239.2 PR240.1 R302.1 U30.AV15
DGPU_PWREN_R: PC198.2 PQ28.2 PR222.1 PR236.1 PR239.1
DGPU_PWROK: PR246.2 PR247.1 U30.AT10
DGPUT_CLK: Q29.1(S) R447.1 R456.1
DGPUT_CLK_R: R456.2 U25.AW40
DGPUT_DATA: Q29.4 R446.1 R455.1
DGPUT_DATA_R: R455.2 U25.AW41
DIECRACKMON: R530.2 TP52.1 U25.B2
DISP_ON: R527.1 R529.2 U26.4
DMIC-DATA34: R317.1 TP33.1
DMIC_CLK: R680.1 U35.3
DMIC_CLK_3V3: R189.2 R191.2 U8.3
DMIC_CLK_L: C659.2 L1.2 R680.2
DMIC_CLK_L_C: C28.1 CN2.1 L8.1 R52.2
DMIC_DAT: R685.2 U35.2
DMIC_DAT_L: L2.2 R685.1
DMIC_DAT_L_C: C29.1 CN2.2 L9.1 R53.2
DNBSWON#: R294.1 U15.123 U30.AT12
DP_STEREOSYNC: R556.2 R559.2 U30.B23
DPB_DDCCLK: Q6.4 R129.2 U30.J20
DPB_DDCDATA: Q6.1(S) R116.2 U30.K20
DQA0_0: U25.L34 VRAM1.E2
DQA0_1: U25.L37 VRAM1.F4
DQA0_2: U25.L38 VRAM1.E4
DQA0_3: U25.J35 VRAM1.F2
DQA0_4: U25.G37 VRAM1.B2
DQA0_5: U25.E38 VRAM1.B4
DQA0_6: U25.E35 VRAM1.A4
DQA0_7: U25.D35 VRAM1.A2
DQA0_8: U25.H41 VRAM1.B13
DQA0_9: U25.H40 VRAM1.A13
DQA0_10: U25.G41 VRAM1.A11
DQA0_11: U25.G40 VRAM1.B11
DQA0_12: U25.E40 VRAM1.E13
DQA0_13: U25.D41 VRAM1.F13
DQA0_14: U25.D40 VRAM1.F11
DQA0_15: U25.C41 VRAM1.E11
DQA0_16: U25.C40 VRAM1.M11
DQA0_17: U25.B39 VRAM1.M13
DQA0_18: U25.A39 VRAM1.N13
DQA0_19: U25.B38 VRAM1.N11
DQA0_20: U25.B36 VRAM1.T13
DQA0_21: U25.A36 VRAM1.U13
DQA0_22: U25.B35 VRAM1.T11
DQA0_23: U25.A35 VRAM1.U11
DQA0_24: U25.B33 VRAM1.U4
DQA0_25: U25.B32 VRAM1.T4
DQA0_26: U25.A32 VRAM1.U2
DQA0_27: U25.B31 VRAM1.T2
DQA0_28: U25.A30 VRAM1.N4
DQA0_29: U25.B29 VRAM1.N2
DQA0_30: U25.B28 VRAM1.M2
DQA0_31: U25.A28 VRAM1.M4
DQA1_0: U25.B27 VRAM2.F4
DQA1_1: U25.A27 VRAM2.F2
DQA1_2: U25.B26 VRAM2.E2
DQA1_3: U25.A26 VRAM2.E4
DQA1_4: U25.A24 VRAM2.B2
DQA1_5: U25.B23 VRAM2.A2
DQA1_6: U25.A23 VRAM2.B4
DQA1_7: U25.B22 VRAM2.A4
DQA1_8: U25.B20 VRAM2.A11
DQA1_9: U25.A20 VRAM2.B11
DQA1_10: U25.B19 VRAM2.A13
DQA1_11: U25.A19 VRAM2.B13
DQA1_12: U25.B17 VRAM2.E11
DQA1_13: U25.A16 VRAM2.E13
DQA1_14: U25.B16 VRAM2.F13
DQA1_15: U25.A15 VRAM2.F11
DQA1_16: U25.B15 VRAM2.U4
DQA1_17: U25.A14 VRAM2.U2
DQA1_18: U25.B14 VRAM2.T2
DQA1_19: U25.B13 VRAM2.T4
DQA1_20: U25.A11 VRAM2.M4
DQA1_21: U25.B11 VRAM2.N4
DQA1_22: U25.A10 VRAM2.N2
DQA1_23: U25.B10 VRAM2.M2
DQA1_24: U25.B8 VRAM2.M11
DQA1_25: U25.A7 VRAM2.N11
DQA1_26: U25.B7 VRAM2.N13
DQA1_27: U25.A6 VRAM2.M13
DQA1_28: U25.A4 VRAM2.T11
DQA1_29: U25.B4 VRAM2.T13
DQA1_30: U25.A3 VRAM2.U13
DQA1_31: U25.B3 VRAM2.U11
DRAM_RST_A: R21.2 VRAM1.J2 VRAM2.J2
DRAM_RST_A_R: R40.1 R42.2 U25.L32
EC_FPBACK#: Q2.2 U15.86
EC_ODD_EJ#: CN17.16 R282.1 R367.1
EC_ODD_EJ_R#: C400.1 R282.2 U15.94
EC_PWROK: D13.1(CATHODE) U15.33
EC_SPI1_CLK: C667.1 R251.1 U15.105 U37.6
EC_SPI1_SI: R253.1 U15.102 U37.5
EC_SPI1_SO: R252.1 U15.103 U37.2
EC_SPI_CS0#: R254.1 R283.1 U15.101 U37.1
EC_SPI_HOLD#: R683.1 U37.7
EC_SPI_WP#: R284.2 U37.3(W\P\)
EC_THMTRIP#: R732.2 U15.125
EC_TYPEC_CHG_HI: R700.1 U15.3
EC_TYPEC_EN: R324.1 U15.80
EC_TYPEC_EN_R: R324.2 R345.1
EC_WLAN_RST#: D17.1(CATHODE) U15.87
ECAGND: C448.2 C484.1 L6.1 U15.75
EDCA0_0: U25.G38 VRAM1.C2
EDCA0_1: U25.F41 VRAM1.C13
EDCA0_2: U25.B37 VRAM1.R13
EDCA0_3: U25.A31 VRAM1.R2
EDCA1_0: U25.B24 VRAM2.C2
EDCA1_1: U25.A18 VRAM2.C13
EDCA1_2: U25.B12 VRAM2.R2
EDCA1_3: U25.B6 VRAM2.R13
EDP_HPD: C557.2 R505.1 R567.1 U30.C12
EDP_HPD_R: CN2.25 R505.2
EN: R371.1 R372.2 U18.7
EQ1: R406.1 R407.2 U18.17
EQ2: R398.1 R399.2 U18.19
EQ_SEL_A0: R568.1 R569.2 U28.5
FAN1_RPM: FAN1.2 R690.2 U15.47
FAN_PWM: Q36.1(EMITTER) U15.32
FAN_PWM_C: FAN1.3 Q36.3 R684.2
FB_VMEMIO: TP51.1 U25.C3
G781THERM#: R605.2 U32.4
G5335-AGND: PC215.2 PC219.2 PR248.1 PR250.2 PR251.1 PU10.4
G5335-AGND-1: PC245.2 PC246.2 PR300.1 PR302.1 PR303.1 PR304.2 PR316.1 PU11.4
G5335-BST: PR243.2 PU10.20
G5335-BST-1: PR294.2 PU11.20
G5335-EN: PC219.1 PR29.1 PR253.2 PU10.2
G5335-EN-1: PC246.1 PR299.2 PU11.2
G5335-FB: PC218.1 PR249.2 PR250.1 PU10.5
G5335-FB-1: PC248.1 PR304.1 PR305.2 PU11.5
G5335-LX: PC205.1 PL10.1 PR242.1 PU10.10 PU10.11 PU10.16 PU10.17 PU10.18 PU10.25
G5335-LX-1: PC244.1 PL13.1 PR307.1 PU11.10 PU11.11 PU11.16 PU11.17 PU11.18 PU11.25
G5335-PFM: PR248.2 PR252.1 PU10.3
G5335-PFM-1: PR300.2 PR301.1 PU11.3
G5335-PWRGD: PR247.2 PU10.1
G5335-PWRGD-1: PR298.2 PU11.1
G5335-SS: PC215.1 PU10.23
G5335-SS-1: PC245.1 PU11.23
G5335-TON: PR244.1 PU10.6
G5335-TON-1: PR308.1 PU11.6
G5335-VCC: PC212.1 PR245.2 PU10.21(VCC)
G5335-VCC-1: PC243.1 PR293.2 PU11.21(VCC)
G_MBCLK_R: C486.1 R386.1 R387.2 U17.4
G_MBDATA_R: C478.1 R378.1 R379.2 U17.6
G_WAKEB: R465.2 U25.AU40
GENERICA: TP48.1 U25.BA38
GENINT2: R307.1 U30.AU14
GFX_TX0N_C: C594.2 U30.F2
GFX_TX0P_C: C596.2 U30.F4
GFX_TX1N_C: C592.2 U30.E4
GFX_TX1P_C: C593.2 U30.F3
GFX_TX2N_C: C590.2 U30.C1
GFX_TX2P_C: C591.2 U30.E1
GFX_TX3N_C: C589.2 U30.E6
GFX_TX3P_C: C587.2 U30.D5
GPF6: TP27.1 U15.117
GPIO_0: R451.2 R460.2 U25.W40
GPIO_1: R441.2 R443.2 U25.AA40
GPIO_2: R26.2 R38.2 U25.AA35
GPIO_8_ROMSO: R16.2 R17.1 R24.2 TP5.1 U25.AP25
GPIO_9_ROMSI: R32.1 R440.2 R445.2 TP6.1 U25.AM25
GPIO_10_ROMSCK: R25.1 TP4.1 U25.AM27
GPIO_11: R470.2 R484.2 U25.W41
GPIO_12: R469.2 R483.2 U25.Y40
GPIO_13: R450.2 R459.2 U25.Y41
GPIO_15: R437.2 R438.2 U25.AA41
GPIO_20: R468.2 R482.2 U25.AB40
GPIO_21_PCC: TP45.1 U25.AB41
GPIO_22_ROMCSB: R5.2 R6.1 R8.2 TP1.1 U25.AP27
GPIO_28_FDO: R22.1 R23.2 U25.U38
GPIO_29: R4.2 R11.2 U25.W37
GPIO_30: R3.1 R10.2 U25.W38
GPIO_5441: R337.2 R338.2 U19.23
GPIO_SVC: R98.2 U25.AU17
GPIO_SVD: R97.2 U25.AV17
GPIO_SVT: R96.2 U25.AR17
GPU_CLR_REQ6#: Q17.3 R300.1 R301.2 U30.AN15
GPU_EDP_HPD: TP13.1 U25.AV21
GPU_GPIO6: D1.2 D2.2 R15.1 R19.2 R29.1 R34.1 U25.U35
GPU_PCIE_CLKREQ#: Q17.1(S) R37.2 R301.1 R464.2 U25.AV40
GPU_PWM_PROCHOT#: D2.1(CATHODE) PR24.1 R14.1 R15.2
HDDPWRON: Q25.2 R402.1 R404.2 U15.83
HDMI_HPD: C574.1 CN4.19 RV5.1 U28.21
HDMI_HPD_CON: R141.1 R533.2 U30.L21
HDMI_HPD_DC: R138.1 R141.2 U28.40
HDMI_HPD_PCH: TP50.1 U25.AU25
HDMI_RST#: C573.1 R534.2 U28.35
HDMI_SCLK: CN4.15 Q6.3 R121.1 RV1.1 U28.7
HDMI_SDATA: CN4.16 Q6.6 R122.1 RV2.1 U28.8
HDMI_SEL#_A1: R536.2 U28.32
HDT_APU_TDI: CN7.6 R599.1
HDT_DBREQ#: CN7.16 R219.1
HDT_TRST#: CN7.9 R214.2
HEPWR: C537.1 D27.1 HE1.2(VCC) HE2.2(VCC) R448.2
HP-L2: C631.2 R608.2 R612.2 R613.1 U35.32
HP-L3: C621.2 CN8.4 R608.1
HP-R2: C626.2 R606.1 R607.2 R609.2 U35.33
HP-R3: C620.2 CN8.2 R607.1
HP_JD#: CN8.13 R651.2
HSYNC: R35.2 R41.2 U25.W34
HWPG: D18.2 D19.2 D20.2 D21.2 D22.2 D23.2 Q19.5 R385.2 U15.21
HWPG_1.5V: D22.1(CATHODE) PR75.2 PR79.1
HWPG_1.8VS5: D19.1(CATHODE) PR94.1 PR96.2
HWPG_VDDPS5: D20.1(CATHODE) PR296.2 PR298.1
HWPG_VDDR: D23.1(CATHODE) PR133.2 PR134.1
I2C_C0_CLK: R377.1 R658.2 U30.AP14
I2C_C0_DATA: R376.1 R659.2 U30.AN14
I2C_C1_CLK: R210.1 R514.1 U30.AP2
I2C_C1_DATA: R211.1 R513.1 U30.AN3
I2C_SEL_PIN: R136.2 U28.31
ICMNT: C484.2 PC84.2 PR322.1 U15.67
IDCHG_R: PC86.2 PR323.1 U15.68
IFDET: R235.1 U30.BA6
ILIM_HI: R199.2 U10.16
ILIM_LO: R192.2 U10.15
IN_CLK: C203.1 U30.F20
IN_CLK#: C205.1 U30.G20
IN_D0: C196.1 U30.G21
IN_D0#: C202.1 U30.H21
IN_D1: C187.1 U30.F22
IN_D1#: C193.1 U30.G22
IN_D2: C181.1 U30.G23
IN_D2#: C182.1 U30.H23
INT_AMIC-VREFO: C646.1 R657.2 U35.27
INT_EDP_AUXN: C560.1 U30.B12
INT_EDP_AUXN_C: C560.2 CN2.22 R510.1
INT_EDP_AUXP: C561.1 U30.D12
INT_EDP_AUXP_C: C561.2 CN2.23 R511.1
INT_EDP_TXN0: C554.1 U30.B11
INT_EDP_TXN0_C: C554.2 CN2.19
INT_EDP_TXN1: C552.1 U30.A11
INT_EDP_TXN1_C: C552.2 CN2.16
INT_EDP_TXN2: C550.1 U30.B10
INT_EDP_TXN2_C: C550.2 CN2.13
INT_EDP_TXN3: C548.1 U30.B9
INT_EDP_TXN3_C: C548.2 CN2.10
INT_EDP_TXP0: C555.1 U30.D11
INT_EDP_TXP0_C: C555.2 CN2.20
INT_EDP_TXP1: C553.1 U30.C11
INT_EDP_TXP1_C: C553.2 CN2.17
INT_EDP_TXP2: C551.1 U30.D10
INT_EDP_TXP2_C: C551.2 CN2.14
INT_EDP_TXP3: C549.1 U30.D9
INT_EDP_TXP3_C: C549.2 CN2.11
ISOLATEB: R77.2 R78.1 U2.20
JTAG_TCK: TP42.1 U25.AE41
JTAG_TDI: TP41.1 U25.AD40
JTAG_TDO: TP9.1 U25.AF41
JTAG_TESTEN: R467.2 R475.1 TP47.1 U25.AE40
JTAG_TMS: TP43.1 U25.AD41
JTAG_TRSTB: R466.1 R474.1 TP46.1 U25.AF40
JW5222LX1.5V: PL5.1 PU6.3
KB_BL_LED: Q40.2 U15.113
KL_NO_EC: PR88.1 PR114.1 U15.70
L_SPK+: R359.1 U35.42
L_SPK+_1: C428.1 CN14.4 R359.2
L_SPK-: R360.1 U35.43
L_SPK-_1: C429.1 CN14.3 R360.2
LAD0: R635.1 U30.BA16
LAD1: R616.1 U30.BA15
LAD2: R644.1 U30.BC13
LAD3: R617.1 U30.BB14
LAN_AMBLED#: TP12.1 U2.27
LAN_LED1: TP11.1 U2.26
LAN_LED2: TP10.1 U2.25
LAN_MCTG0: R61.2 U24.24
LAN_MCTG1: R60.2 U24.21
LAN_MCTG2: R57.2 U24.18
LAN_MCTG3: R58.2 U24.15
LAN_XTAL1: C26.2 R64.1 Y1.1
LANPWR#: R55.2 R56.1 U15.16
LCD_BL_PWM: R45.1 U25.AC38
LCD_BLEN: R44.1 U25.AC37
LCD_VDD: R458.1 U25.AC40
LDO_3V3: C680.2 R341.2 R342.2 R401.2 R408.2 R415.2 R416.2 U19.20
LID#: C538.1 D4.1(CATHODE) D26.1 HE1.1 HE2.1 R62.2 R239.2
LID#_C: C353.1 D6.1 R239.1 U15.118
LINE1-L: C631.1 U35.22
LINE1-R: C626.1 U35.21
LINE1-VREFO-L: R612.1 U35.31
LINE1-VREFO-R: R609.1 U35.30
LPC_LAD0: CN11.64 R635.2 R702.2 U15.10
LPC_LAD1: CN11.66 R616.2 U15.9
LPC_LAD2: CN11.68 R644.2 U15.8
LPC_LAD3: CN11.70 R617.2 U15.7
LPC_LFRAME#: R712.1 R719.1 U15.6 U30.BA13
LPC_LFRAME#_C: CN11.73 R719.2
LPC_PD#: R640.1 U30.BB13
LPC_RST#: R619.2 U30.BC12
LPC_RST#_EC: C443.1 R352.2 U15.22
LPCCLK0: R614.2 U30.BB15
LPCCLK1: R620.2 U30.BA12
M0_5441: R341.1 R700.2 U19.22
M1_5441: R342.1 U19.21
M2_SSD_CLKREQ#: CN19.52 Q28.3 R432.1 R433.2
M2_SSD_RST#: CN19.50 R428.1 R429.1 U21.4
M2SSD_PWREN#: R263.1 R421.1 U15.126
M_A_A0: CN5.144 U30.AK26
M_A_A1: CN5.133 U30.AG24
M_A_A2: CN5.132 U30.AG23
M_A_A3: CN5.131 U30.AG26
M_A_A4: CN5.128 U30.AG27
M_A_A5: CN5.126 U30.AF21
M_A_A6: CN5.127 U30.AF22
M_A_A7: CN5.122 U30.AF25
M_A_A8: CN5.125 U30.AF24
M_A_A9: CN5.121 U30.AE21
M_A_A10: CN5.146 U30.AL21
M_A_A11: CN5.120 U30.AF27
M_A_A12: CN5.119 U30.AE23
M_A_A13: CN5.158 U30.AM23
M_A_ACT#: CN5.114 U30.AD22
M_A_ALERT#: CN5.116 R173.2 TP19.1 U30.AE24
M_A_BG#0: CN5.115 U30.AE27
M_A_BG#1: CN5.113 U30.AE26
M_A_BS#0: CN5.150 U30.AL22
M_A_BS#1: CN5.145 U30.AK27
M_A_CAS#: CN5.156 U30.AL27
M_A_CKE0: CN5.109 U30.AD24
M_A_CKE1: CN5.110 U30.AD25
M_A_CLKN0: CN5.139 U30.AJ24
M_A_CLKN1: CN5.140 U30.AJ21
M_A_CLKP0: CN5.137 U30.AJ25
M_A_CLKP1: CN5.138 U30.AJ22
M_A_CS#0: CN5.149 U30.AL25
M_A_CS#1: CN5.157 U30.AM26
M_A_DM0: CN5.12 U30.L27
M_A_DM1: CN5.33 U30.N23
M_A_DM2: CN5.54 U30.R27
M_A_DM3: CN5.75 U30.Y24
M_A_DM4: CN5.178 U30.AP27
M_A_DM5: CN5.199 U30.AW23
M_A_DM6: CN5.220 U30.AT21
M_A_DM7: CN5.241 U30.AV18
M_A_DQ0: CN5.3 U30.K27
M_A_DQ1: CN5.8 U30.L26
M_A_DQ2: CN5.17 U30.N26
M_A_DQ3: CN5.21 U30.N27
M_A_DQ4: CN5.4 U30.G27
M_A_DQ5: CN5.7 U30.H27
M_A_DQ6: CN5.16 U30.M27
M_A_DQ7: CN5.20 U30.N24
M_A_DQ8: CN5.28 U30.L23
M_A_DQ9: CN5.29 U30.N21
M_A_DQ10: CN5.42 U30.T21
M_A_DQ11: CN5.41 U30.T22
M_A_DQ12: CN5.25 U30.M22
M_A_DQ13: CN5.24 U30.L24
M_A_DQ14: CN5.38 U30.R21
M_A_DQ15: CN5.37 U30.R23
M_A_DQ16: CN5.49 U30.P24
M_A_DQ17: CN5.50 U30.R26
M_A_DQ18: CN5.59 U30.T27
M_A_DQ19: CN5.58 U30.V27
M_A_DQ20: CN5.46 U30.P25
M_A_DQ21: CN5.45 U30.P27
M_A_DQ22: CN5.63 U30.V23
M_A_DQ23: CN5.62 U30.T25
M_A_DQ24: CN5.67 U30.W22
M_A_DQ25: CN5.71 U30.Y23
M_A_DQ26: CN5.79 U30.AC24
M_A_DQ27: CN5.84 U30.AC23
M_A_DQ28: CN5.66 U30.V21
M_A_DQ29: CN5.70 U30.W21
M_A_DQ30: CN5.83 U30.AA24
M_A_DQ31: CN5.80 U30.AA22
M_A_DQ32: CN5.173 U30.AP26
M_A_DQ33: CN5.174 U30.AN24
M_A_DQ34: CN5.183 U30.AR25
M_A_DQ35: CN5.186 U30.AU26
M_A_DQ36: CN5.169 U30.AN25
M_A_DQ37: CN5.170 U30.AN27
M_A_DQ38: CN5.187 U30.AR27
M_A_DQ39: CN5.182 U30.AU27
M_A_DQ40: CN5.190 U30.AV25
M_A_DQ41: CN5.191 U30.AW25
M_A_DQ42: CN5.207 U30.AV20
M_A_DQ43: CN5.203 U30.AW20
M_A_DQ44: CN5.194 U30.AV27
M_A_DQ45: CN5.195 U30.AW26
M_A_DQ46: CN5.208 U30.AU21
M_A_DQ47: CN5.204 U30.AW21
M_A_DQ48: CN5.215 U30.AT22
M_A_DQ49: CN5.212 U30.AP21
M_A_DQ50: CN5.229 U30.AN19
M_A_DQ51: CN5.224 U30.AN18
M_A_DQ52: CN5.211 U30.AU23
M_A_DQ53: CN5.216 U30.AR22
M_A_DQ54: CN5.228 U30.AN20
M_A_DQ55: CN5.225 U30.AP19
M_A_DQ56: CN5.236 U30.AT19
M_A_DQ57: CN5.237 U30.AW18
M_A_DQ58: CN5.246 U30.AU16
M_A_DQ59: CN5.250 U30.AW16
M_A_DQ60: CN5.232 U30.AW19
M_A_DQ61: CN5.233 U30.AU19
M_A_DQ62: CN5.245 U30.AP16
M_A_DQ63: CN5.249 U30.AT16
M_A_DQSN0: CN5.11 U30.M24
M_A_DQSN1: CN5.32 U30.P21
M_A_DQSN2: CN5.53 U30.R24
M_A_DQSN3: CN5.74 U30.Y21
M_A_DQSN4: CN5.177 U30.AP24
M_A_DQSN5: CN5.198 U30.AV22
M_A_DQSN6: CN5.219 U30.AR20
M_A_DQSN7: CN5.240 U30.AT18
M_A_DQSP0: CN5.13 U30.M25
M_A_DQSP1: CN5.34 U30.P22
M_A_DQSP2: CN5.55 U30.T24
M_A_DQSP3: CN5.76 U30.AA21
M_A_DQSP4: CN5.179 U30.AP23
M_A_DQSP5: CN5.200 U30.AW22
M_A_DQSP6: CN5.221 U30.AT20
M_A_DQSP7: CN5.242 U30.AR18
M_A_EVENT#: CN5.134 R178.1 U30.AK23
M_A_ODT0: CN5.155 U30.AM24
M_A_ODT1: CN5.161 U30.AM27
M_A_PARITY: CN5.143 U30.AK24
M_A_RAS#: CN5.152 U30.AL24
M_A_RST#: CN5.108 U30.AD27
M_A_WE#: CN5.151 U30.AM21
M_B1_UZQ0: R157.2 U5.E9
M_B1_UZQ1: R177.2 U6.E9
M_B1_UZQ2: R218.2 U9.E9
M_B1_UZQ3: R274.2 U12.E9
M_B1_ZQ0: R152.1 U5.F9(ZQ)
M_B1_ZQ1: R176.1 U6.F9(ZQ)
M_B1_ZQ2: R217.1 U9.F9(ZQ)
M_B1_ZQ3: R273.1 U12.F9(ZQ)
M_B_A0: R118.2 U5.P3 U6.P3 U9.P3 U12.P3 U30.AM29
M_B_A1: R124.2 U5.P7 U6.P7 U9.P7 U12.P7 U30.AH31
M_B_A2: R117.2 U5.R3 U6.R3 U9.R3 U12.R3 U30.AJ30
M_B_A3: R123.2 U5.N7 U6.N7 U9.N7 U12.N7 U30.AH29
M_B_A4: R119.2 U5.N3 U6.N3 U9.N3 U12.N3 U30.AG32
M_B_A5: R130.2 U5.P8 U6.P8 U9.P8 U12.P8 U30.AG30
M_B_A6: R105.2 U5.P2 U6.P2 U9.P2 U12.P2 U30.AG31
M_B_A7: R140.2 U5.R8 U6.R8 U9.R8 U12.R8 U30.AF30
M_B_A8: R106.2 U5.R2 U6.R2 U9.R2 U12.R2 U30.AG29
M_B_A9: R126.2 U5.R7 U6.R7 U9.R7 U12.R7 U30.AF29
M_B_A10: R109.2 U5.M3 U6.M3 U9.M3 U12.M3 U30.AM30
M_B_A11: R104.2 U5.T2 U6.T2 U9.T2 U12.T2 U30.AF31
M_B_A12: R108.2 U5.M7 U6.M7 U9.M7 U12.M7 U30.AE32
M_B_A13: R139.2 U5.T8 U6.T8 U9.T8 U12.T8 U30.AP30
M_B_ACT#: R112.2 U5.L3 U6.L3 U9.L3 U12.L3 U30.AD30
M_B_ALERT#: R160.1 TP17.1 U5.P9 U6.P9 U9.P9 U12.P9 U30.AE30
M_B_BG#0: R110.2 U5.M2 U6.M2 U9.M2 U12.M2 U30.AD29
M_B_BG#1: R153.1 R161.2 R175.1 R213.1 R248.1 U30.AD31
M_B_BG#1_R: R153.2 R159.1 U5.M9
M_B_BG#2_R: R174.1 R175.2 U6.M9
M_B_BG#3_R: R212.1 R213.2 U9.M9
M_B_BG#4_R: R248.2 R249.1 U12.M9
M_B_BS#0: R107.2 U5.N2 U6.N2 U9.N2 U12.N2 U30.AN31
M_B_BS#1: R147.2 U5.N8 U6.N8 U9.N8 U12.N8 U30.AM32
M_B_CAS#: R144.2 U5.M8 U6.M8 U9.M8 U12.M8 U30.AP29
M_B_CKE0: R114.2 U5.K2 U6.K2 U9.K2 U12.K2 U30.AC31
M_B_CLKN0: R150.2 U5.K8 U6.K8 U9.K8 U12.K8 U30.AK30
M_B_CLKP0: R156.2 U5.K7 U6.K7 U9.K7 U12.K7 U30.AJ31
M_B_CS#0: R134.2 U5.L7 U6.L7 U9.L7 U12.L7 U30.AN30
M_B_DM0: U5.E7 U30.C30
M_B_DM1: U5.E2 U30.H32
M_B_DM2: U6.E7 U30.M29
M_B_DM3: U6.E2 U30.T29
M_B_DM4: U9.E2 U30.AU30
M_B_DM5: U9.E7 U30.BD28
M_B_DM6: U12.E7 U30.BB23
M_B_DM7: U12.E2 U30.BD20
M_B_DQ0: U5.J3 U30.C27
M_B_DQ1: U5.G2 U30.A28
M_B_DQ2: U5.H8 U30.F29
M_B_DQ3: U5.H7 U30.F31
M_B_DQ4: U5.H2 U30.B27
M_B_DQ5: U5.H3 U30.D27
M_B_DQ6: U5.J7 U30.E32
M_B_DQ7: U5.F7 U30.F30
M_B_DQ8: U5.C3 U30.H31
M_B_DQ9: U5.D3 U30.H30
