# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_BS#0: length 151.7
  TOP w0.102: v1(36.3,42.33) 36.3,42.32 35.96,41.91 35.91,41.78 35.91,40.99 35.96,40.84 U12.N2 ; v1(36.14,86.49) 36.14,87.25 34.1,89.29 R107.2
  TOP w0.165: v1(36.93,51.53) 36.93,51.53 U9.N2 ; v1(36.14,86.49) 36.52,86.11 U5.N2 ; U6.N2 36.87,75.07 v1(36.88,75.13)
  IN1 w0.089: v1(36.14,86.49) 36.14,86.09 36.02,85.97 35.49,85.97 35.37,85.84 35.37,85.58 35.49,85.46 36.13,85.46 36.26,85.33 36.26,76.95 35.62,76.31 35.62,75.42 35.92,75.13 v1(36.88,75.13) 36.87,75.11 36.26,74.49 36.26,73.14 35.23,72.11 35.23,70.99 36,70.22 36,68.69 37.02,67.68 37.02,59.51 37.11,59.42 38.07,59.42 38.16,59.33 38.16,59 38.07,58.91 37.11,58.91 37.02,58.83 37.02,58.49 37.11,58.41 38.33,58.41 38.42,58.32 38.42,53.2 37.65,52.44 37.65,51.8 37.38,51.53 v1(36.93,51.53) 36.51,51.53 35.88,50.9 35.88,49.47 36,49.35 36,48.92 35.86,48.77 35.53,48.77 35.37,48.62 35.37,47.48 36,46.85 36,44.82 36.13,44.69 36.89,44.69 37.02,44.56 37.02,44.31 36.89,44.18 36.13,44.18 36,44.06 36,43.8 36.13,43.67 36.93,43.67 37.02,43.59 37.02,42.37 36.93,42.28 36.36,42.28 v1(36.3,42.33)
  IN3 w0.133: v1(36.3,42.33) 36.3,42.48 35.25,43.53 34.86,43.53 34.72,43.67 34.72,44.33 34.49,44.56 34.49,44.7 34.99,45.2 34.99,45.37 34.84,45.52 34.68,45.52 34.18,45.02 34.02,45.02 33.32,45.72 33.32,47.53 33.41,47.61 33.41,49.21 33.61,49.41 33.61,52.34 35.71,54.44 35.71,54.85 36.8,55.94 36.8,56.79 37.08,57.07 38.37,57.6 50.59,57.6 51.6,58.61 54.16,58.61 54.19,58.64 57.3,58.64 58.42,57.52 61.53,57.52 62.55,56.5 v1(62.8,56.5)
  BOTTOM w0.089: U30.AN31 78.93,48.49 78.9,48.52 78.8,48.52
  BOTTOM w0.102: 78.8,48.52 78.66,48.52 78.27,48.91 77.13,48.91 76.64,49.39 74.31,49.39 73.98,49.06
  BOTTOM w0.165: v1(62.8,56.5) 62.8,54.97 62.65,54.83 61.55,54.83 61.4,54.68 61.4,54.48 61.55,54.33 62.88,54.33 63.03,54.19 63.03,53.98 62.88,53.84 61.55,53.84 61.4,53.69 61.4,53.49 61.55,53.34 63.92,53.34 64.07,53.2 64.07,52.99 63.92,52.85 61.55,52.85 61.4,52.7 61.4,52.5 61.55,52.35 63.92,52.35 64.07,52.21 64.07,52 63.92,51.86 61.55,51.86 61.4,51.71 61.4,51.42 61.53,51.29 64.07,51.29 64.69,50.67 70.13,50.67 71.74,49.06 73.98,49.06
M_B_BS#1: length 154.9
  TOP w0.102: v1(31.3,79.62) R147.2
  TOP w0.165: U5.N8 36.12,80.9 36.12,80.16 v1(36.92,79.36) ; U6.N8 v1(36.92,69.54) ; U9.N8 v1(36.92,45.93) ; v1(36.16,35.36) 36.16,35.32 U12.N8
  IN1 w0.089: v1(36.92,79.36) 36.76,79.2 36.76,78.43 36.85,78.35 37.15,78.35 37.65,77.84 37.65,77.46 37.53,77.33 36.89,77.33 36.76,77.2 36.76,76.95 36.89,76.82 37.53,76.82 37.65,76.69 37.65,76.44 37.53,76.31 36.89,76.31 36.76,76.19 36.76,75.93 36.89,75.81 37.53,75.81 37.65,75.68 37.65,73.52 36.51,72.38 36.51,69.94 v1(36.92,69.54) 37.53,68.93 37.53,62.05 37.62,61.96 38.84,61.96 38.92,61.87 38.92,61.54 38.84,61.45 37.62,61.45 37.53,61.37 37.53,61.03 37.62,60.95 38.84,60.95 38.92,60.86 38.92,52.95 38.16,52.18 38.16,51.4 37.08,50.31 36.72,50.31 36.38,49.98 36.38,49.67 36.51,49.55 36.51,46.34 v1(36.92,45.93) 37.15,45.93 37.65,45.43 37.65,44.31 37.53,44.18 37.53,40.88 37.02,40.37 37.02,36.94 35.75,35.67 35.75,34.49 35.84,34.4 36.07,34.4 36.16,34.49 v1(36.16,35.36)
  IN3 w0.089: v1(36.92,79.36) 36.16,80.12 33.46,80.12 32.96,79.62 v1(31.3,79.62)
  IN3 w0.133: v1(36.16,35.36) 36.16,36.05 36.76,36.66 36.76,38.09 36.26,38.59 36.26,40.51 35.88,40.89 35.88,41.39 34.23,43.04 33.92,43.04 33.34,43.63 33.34,44.68 32.6,45.42 32.6,48.5 32.22,48.88 32.22,51.97 34.99,54.74 34.99,55.15 35.34,55.49 35.34,56.6 36.24,57.5 38.23,58.33 50.29,58.33 51.3,59.34 57.62,59.34 58.72,58.24 61.85,58.24 62.7,57.39 63.56,57.39 v1(64.07,57.9)
  BOTTOM w0.089: U30.AM32 78.8,48.99
  BOTTOM w0.102: 78.8,48.99 78.8,48.99 78.48,49.31 77.56,49.31 76.72,50.15 76.01,50.15 75.88,50.02 74.13,50.02 73.98,49.87
  BOTTOM w0.165: v1(64.07,57.9) 64.07,57.77 65.09,56.76 65.09,51.73 65.23,51.59 65.48,51.59 65.63,51.73 65.63,56.23 65.77,56.37 65.98,56.37 66.12,56.23 66.12,51.73 66.27,51.59 70.33,51.59 72.05,49.87 73.98,49.87
M_B_CAS#: length 149.9
  TOP w0.102: R144.2 v1(31.3,80.38)
  TOP w0.165: v1(36.92,80.9) U5.M8 ; U12.M8 v1(37.73,34.55) ; U6.M8 v1(37.74,69.52) ; U9.M8 v1(37.74,45.92)
  IN1 w0.089: v1(36.92,80.9) 36.92,81.58 37.01,81.67 37.27,81.67 37.4,81.55 37.4,78.47 37.91,77.96 37.91,73.42 37.15,72.66 37.15,71.74 37.32,71.57 37.32,70.43 37.74,70.01 v1(37.74,69.52) 38.2,69.52 38.29,69.43 38.29,68.19 37.78,67.68 37.78,63.36 37.91,63.23 38.84,63.23 38.92,63.14 38.92,62.81 38.84,62.72 37.87,62.72 37.78,62.64 37.78,62.3 37.87,62.22 39.09,62.22 39.18,62.13 39.18,52.82 38.42,52.06 38.42,51.31 37.33,50.22 37.33,49.79 36.76,49.22 36.76,48.25 37.32,47.69 37.32,46.33 v1(37.74,45.92) 37.91,45.74 37.91,44.18 37.78,44.06 37.78,40.75 37.27,40.25 37.27,35.93 38.67,34.53 38.67,34.28 38.54,34.15 37.72,34.15 37.6,34.26 37.6,34.43 v1(37.73,34.55)
  IN3 w0.089: v1(31.3,80.38) 31.81,79.87 32.86,79.87 33.37,80.38 36.4,80.38 v1(36.92,80.9)
  IN3 w0.133: v1(37.73,34.55) 38.16,34.12 38.16,33.29 38.07,33.2 37.69,33.2 37.58,33.08 37.58,32.85 37.7,32.73 39.39,32.73 39.51,32.85 39.51,33.16 39.28,33.39 38.66,33.39 38.54,33.5 38.54,33.67 38.66,33.79 39.18,33.79 39.3,33.9 39.3,34.21 39.15,34.36 38.58,34.36 37.63,35.31 37.63,36.01 37.15,36.49 37.15,38.09 36.76,38.47 36.76,42.53 35.36,43.94 35.36,46.46 35.11,46.7 34.45,46.7 33.77,47.38 33.77,49.06 33.97,49.26 33.97,52.19 36.07,54.29 36.07,54.7 37.17,55.79 37.17,56.47 37.57,56.88 38.31,57.19 50.69,57.19 51.19,57.68 54.71,57.68 54.85,57.83 57.6,57.83 58.27,57.16 61.36,57.16 62.51,56 65.92,56 68.51,53.41 72.61,53.41 73.39,52.64 75.42,52.64 75.62,52.44 75.62,51.65 76.02,51.25 76.02,50.97 77.91,49.08 77.91,48.78 v2(77.45,48.31)
  BOTTOM w0.089: 78.8,47.69 79.37,47.69 79.48,47.8 79.75,47.8 80.06,47.49 U30.AP29
  BOTTOM w0.102: 78.8,47.69 78.07,47.69 v2(77.45,48.31)
M_B_CKE0: length 153.9
  TOP w0.102: R114.2 v1(39.43,89.52)
  TOP w0.165: v1(39.33,51.53) U9.K2 ; v1(38.56,75.13) 38.56,75.09 U6.K2 ; v1(38.53,40.15) U12.K2 ; U5.K2 v1(39.33,85.71)
  IN2 w0.089: v1(38.53,40.15) 38.42,40.26 38.42,42.53 39.18,43.29 39.18,46.3 38.42,47.06 38.42,47.87 38.54,47.99 39.3,47.99 40.19,48.88 40.19,51.4 40.07,51.53 v1(39.33,51.53) 39.33,51.95 40.07,52.69 40.07,63.27 39.98,63.36 38.03,63.36 37.91,63.49 37.91,63.74 38.03,63.87 39.09,63.87 39.18,63.96 39.18,64.28 39.09,64.38 38.03,64.38 37.91,64.5 37.91,67.33 38.92,68.34 38.92,71.74 39.3,72.12 39.3,74.37 38.56,75.12 v1(38.56,75.13) 38.56,75.14 40.07,76.64 40.07,84.06 40.19,84.19 40.32,84.19 40.45,84.31 40.45,84.57 40.32,84.7 39.66,84.7 39.53,84.82 39.53,85.08 39.66,85.2 40.32,85.2 40.45,85.33 40.45,85.58 40.33,85.71 v1(39.33,85.71)
  IN3 w0.089: v1(39.33,85.71) 38.91,86.13 38.91,89 v1(39.43,89.52)
  IN3 w0.133: v1(38.53,40.15) 38.53,43.02 38.92,43.42 38.92,46.47 38.67,46.72 38.67,51.68 39.44,52.44 39.44,53.75 40.7,55.02 50.64,55.02 50.86,54.8 53.1,54.8 53.19,54.89 57.83,54.89 58.18,54.54 59.07,54.54 59.77,53.83 65.02,53.83 68.32,50.53 69.85,50.53 72.87,47.51 78.52,47.51 78.83,47.81 78.83,49.19 76.74,51.27 76.74,51.55 76.39,51.9 76.39,52.32 76.9,52.82 78.67,52.82 80.03,54.18 80.03,56.97 80.45,57.39 80.45,62.06 80.28,62.24 79.33,62.24 79.16,62.07 79.16,57.87 78.67,57.39 78.04,57.39 77.4,58.03 76.9,58.03 76.38,58.55 v2(75.8,58.55)
  BOTTOM w0.102: v2(75.8,58.55) 76.71,58.55 78.01,57.25 78.49,57.25 79.12,56.62 79.48,56.62 U30.AC31
M_B_CLKN0: length 152.6
  TOP w0.102: v1(39.28,78.92) 39.52,78.68 39.79,78.68 R150.2
  TOP w0.165: U6.K8 v1(39.33,70.33) ; U9.K8 v1(39.33,46.73) ; v1(39.33,81.68) 38.95,81.31 U5.K8 ; v1(39.33,35.33) 38.95,34.95 U12.K8
  IN1 w0.089: v1(39.33,35.33) 39.33,35.58 39.24,35.67 38.94,35.67 38.75,35.86 38.75,36.51 39.18,36.94 39.98,36.94 40.14,37.11 40.14,37.36 39.51,38 39.51,46.16 39.81,46.47 39.81,46.91 39.72,47 39.6,47 v1(39.33,46.73) 39.01,47.04 38.74,47.04 38.54,47.23 38.54,47.74 39.86,49.06 39.86,51.34 40.57,52.05 40.57,66.61 40.76,66.79 42.01,66.79 42.1,66.88 42.1,67.28 42.01,67.37 40.5,67.37 39.89,67.98 39.89,70.51 39.76,70.64 39.64,70.64 v1(39.33,70.33) 38.99,70.66 38.86,70.66 38.58,70.95 38.58,71.27 39.23,71.92 39.76,71.92 40.27,72.42 40.27,81.83 40.08,82.01 39.45,82.01 39.33,81.89 v1(39.33,81.68)
  IN3 w0.089: v1(39.28,78.92) 39.28,78.76 39.37,78.67 39.63,78.67 39.94,78.98 39.94,81.91 39.76,82.09 39.27,82.09 39.18,82 39.18,81.83 v1(39.33,81.68)
  IN3 w0.14: v1(39.33,35.33) 38.94,35.49 38.73,35.49 38.45,35.77 38.45,36.34 39.42,37.31 39.42,42.64 39.7,42.92 39.7,43.79 39.42,44.07 39.42,46.2 39.77,46.55 39.77,47.73 39.43,48.07 39.43,49.26 39.8,49.63 39.8,51.48 40.68,52.36 40.68,52.59 40.23,53.04 40.23,53.49 40.77,54.02 54.5,54.02 54.79,53.73 54.79,53.24 54.93,53.1 55.21,53.1 55.35,53.24 55.35,53.73 55.65,54.02 56.15,54.02 56.44,53.73 56.44,53.19 56.58,53.05 56.86,53.05 57,53.19 57,53.53 57.3,53.82 57.94,53.82 58.24,53.53 58.24,53.22 58.38,53.08 64.71,53.08 68.02,49.78 69.54,49.78 72.58,46.75 79.03,46.75 79.45,46.33 81.31,46.33 81.41,46.43 81.41,46.65 81.1,46.96 80.34,46.96 79.59,47.71 79.59,48.35 79.87,48.63 80.33,48.63 80.9,48.06 81.16,48.06 81.43,48.33 81.43,48.57 80.89,49.11 80.58,49.84 80.45,49.97 80.25,49.97 79.88,49.6 79.47,49.6 79.04,50.04 79.04,50.49 80.41,51.86 80.41,52.09 80.11,52.4 79.85,52.4 78.5,51.05 78.04,51.05 77.49,51.59 77.49,51.84 v2(77.4,52.07)
  BOTTOM w0.127: 78.93,51.33 79.32,51.33 79.65,50.99 U30.AK30
  BOTTOM w0.165: 78.93,51.33 78.09,51.33 77.4,52.02 v2(77.4,52.07)
M_B_CLKP0: length 152.4
  TOP w0.102: R156.2 39.84,78.47 39.47,78.47 v1(39.28,78.28)
  TOP w0.165: U5.K7 v1(39.33,82.51) ; U12.K7 v1(39.33,36.15) ; U9.K7 v1(39.33,47.53) ; U6.K7 v1(39.33,71.13)
  IN1 w0.089: v1(39.33,36.15) 39.33,35.99 39.19,35.85 39.01,35.85 38.92,35.94 38.92,36.44 39.25,36.77 40.05,36.77 40.32,37.03 40.32,37.44 39.69,38.07 39.69,46.09 39.99,46.39 39.99,46.98 39.8,47.18 39.68,47.18 v1(39.33,47.53) 39.01,47.21 38.81,47.21 38.72,47.31 38.72,47.66 40.04,48.98 40.04,51.27 40.75,51.98 40.75,66.53 40.83,66.61 42.08,66.61 42.28,66.8 42.28,67.36 42.08,67.55 40.57,67.55 40.07,68.06 40.07,70.59 39.84,70.82 39.64,70.82 v1(39.33,71.13) 39.04,70.84 38.94,70.84 38.76,71.02 38.76,71.2 39.3,71.74 39.84,71.74 40.45,72.35 40.45,81.9 40.16,82.19 39.42,82.19 39.33,82.28 v1(39.33,82.51)
  IN3 w0.089: v1(39.28,78.28) 39.49,78.49 39.71,78.49 40.12,78.9 40.12,81.99 39.84,82.27 39.56,82.27 v1(39.33,82.51)
  IN3 w0.14: v1(39.33,36.15) 39.45,36.03 39.45,35.89 39.31,35.75 38.84,35.75 38.72,35.88 38.72,36.23 39.69,37.2 39.69,42.53 39.97,42.81 39.97,43.9 39.69,44.18 39.69,46.09 40.04,46.44 40.04,47.84 39.7,48.18 39.7,49.15 40.07,49.52 40.07,51.37 40.94,52.25 40.94,52.71 40.5,53.15 40.5,53.38 40.88,53.76 54.39,53.76 54.53,53.62 54.53,53.13 54.82,52.83 55.32,52.83 55.62,53.13 55.62,53.62 55.76,53.76 56.04,53.76 56.18,53.62 56.18,53.08 56.47,52.78 56.97,52.78 57.27,53.08 57.27,53.41 57.41,53.55 57.83,53.55 57.97,53.41 57.97,53.11 58.27,52.82 64.6,52.82 67.91,49.52 69.43,49.52 72.47,46.48 78.92,46.48 79.34,46.06 81.42,46.06 81.68,46.32 81.68,46.77 81.21,47.23 80.45,47.23 79.86,47.82 79.86,48.24 79.98,48.36 80.22,48.36 80.79,47.79 81.27,47.79 81.7,48.22 81.7,48.68 81.11,49.26 80.81,50 80.56,50.24 80.14,50.24 79.77,49.87 79.59,49.87 79.31,50.15 79.31,50.38 80.68,51.75 80.68,52.2 80.22,52.67 79.74,52.67 78.39,51.31 78.15,51.31 77.76,51.7 77.76,51.9 77.93,52.07 v2(77.98,52.07)
  BOTTOM w0.127: U30.AJ31 79.79,51.49 79.87,51.56 79.87,51.68 79.72,51.83 79.49,51.83 79.22,51.55 79.04,51.55 78.95,51.64
  BOTTOM w0.165: 78.95,51.64 78.22,51.64 77.98,51.88 v2(77.98,52.07)
M_B_CS#0: length 159.6
  TOP w0.102: R134.2 v1(31.3,82.66)
  TOP w0.165: v1(37.91,82.66) 38.13,82.45 U5.L7 ; U6.L7 38.13,72.06 v1(37.93,72.25) ; v1(37.73,49.02) 38.13,48.62 U9.L7 ; U12.L7 38.12,35.76 38.12,36.48 v1(37.93,36.66)
  IN2 w0.089: v1(37.91,82.66) 37.65,82.41 37.65,81.99 37.74,81.9 38.29,81.9 38.42,81.77 38.42,81.52 38.29,81.39 37.91,81.39 37.76,81.25 37.76,81.01 37.89,80.89 38.29,80.89 38.42,80.76 38.42,80.5 38.29,80.38 37.85,80.38 37.76,80.29 37.76,79.13 38.03,78.86 38.03,77.07 37.91,76.95 37.65,76.95 37.53,76.82 37.53,74.41 38.03,73.9 38.03,73.39 38.54,72.88 38.54,72.5 38.29,72.25 v1(37.93,72.25) 37.93,71.84 38.16,71.61 38.16,68.69 37.15,67.68 37.15,60.69 37.27,60.57 39.18,60.57 39.3,60.44 39.3,60.18 39.18,60.06 38.03,60.06 37.91,59.93 37.91,59.68 38.03,59.55 39.18,59.55 39.3,59.42 39.3,53.07 38.29,52.06 38.29,50.25 38.42,50.12 38.42,49.55 37.89,49.02 v1(37.73,49.02) 37.65,48.95 37.65,46.72 38.29,46.09 38.29,44.69 37.64,44.04 37.64,38.07 37.73,37.98 38.3,37.98 38.44,37.83 38.44,36.75 38.35,36.66 v1(37.93,36.66)
  IN3 w0.089: v1(37.91,82.66) 37.76,82.51 35.25,82.51 34.85,82.91 34.36,82.91 34.11,82.66 v1(31.3,82.66)
  IN3 w0.133: v2(74.61,49.01) 74.6,49.01 73.89,49.01 73.78,49.13 73.78,49.39 74.27,49.88 74.27,50.01 74.13,50.15 73.98,50.15 72.96,49.14 72.78,49.14 72.65,49.27 72.65,49.43 73.72,50.5 73.72,50.67 73.58,50.8 73.41,50.8 72.34,49.74 72.18,49.74 72.06,49.86 72.06,50.02 73.13,51.09 73.13,51.25 73.01,51.37 72.85,51.37 71.78,50.3 71.61,50.3 71.5,50.42 71.5,50.59 72.38,51.48 72.38,51.64 72.27,51.76 72.1,51.76 71.21,50.87 71.05,50.87 70.93,50.99 70.93,51.15 71.05,51.27 71.05,52.19 70.93,52.31 70.77,52.31 70.65,52.19 70.65,51.73 70.53,51.61 70.37,51.61 70.25,51.73 70.25,52.19 70.13,52.31 69.97,52.31 69.85,52.19 69.85,51.73 69.73,51.61 69.57,51.61 69.45,51.73 69.45,52.19 69.33,52.31 69.17,52.31 69.05,52.19 69.05,51.73 68.93,51.61 68.78,51.61 68.64,51.75 68.64,52.18 68.51,52.31 68.08,52.31 65.47,54.92 61.73,54.92 61.02,55.62 58.63,55.62 58.19,56.07 57.81,56.07 57.53,56.36 54.94,56.36 54.83,56.47 51.51,56.47 51.15,56.1 40.25,56.1 39.94,55.79 39.77,55.79 39.47,56.09 39.3,56.09 39.18,55.97 39.18,55.81 39.49,55.5 39.49,55.34 39.37,55.22 39.21,55.22 38.77,55.65 38.61,55.65 38.49,55.54 38.49,55.37 38.92,54.94 38.92,54.77 38.81,54.66 38.61,54.66 38.2,55.07 38.03,55.07 37.91,54.96 37.91,54.82 38.36,54.37 38.36,54.21 38.24,54.09 38.07,54.09 37.64,54.52 37.48,54.52 37.36,54.4 37.36,54.24 37.79,53.81 37.79,53.64 37.55,53.4 37.55,52.84 36.38,51.68 36.38,50.1 36.22,49.94 36.22,49.39 36.34,49.28 36.77,49.28 36.89,49.16 36.89,48.99 36.77,48.88 36.34,48.88 36.22,48.76 36.22,48.59 36.34,48.48 36.77,48.48 36.89,48.36 36.89,48.19 36.77,48.08 36.34,48.08 36.22,47.96 36.22,47.57 36.13,47.48 36.13,47.26 36.46,46.93 36.46,44.37 37.49,43.34 37.49,38.97 38.38,38.08 38.96,38.08 39.1,37.93 39.1,37.45 38.31,36.66 v1(37.93,36.66)
  BOTTOM w0.089: U30.AN30 79.84,48.15 79.49,48.15 79.35,48.29 78.8,48.29
  BOTTOM w0.102: 78.8,48.29 78.6,48.29 78.18,48.7 77.04,48.7 76.74,49.01 v2(74.61,49.01)
M_B_DM0: length 61.3
  TOP w0.102: U5.E7 41.71,83.32 v1(41.71,83.65)
  IN3 w0.089: v2(80.14,74.37) 80.22,74.37 80.54,74.7 80.54,77.23 80.92,77.61 80.92,78.58 80.62,78.88 76.91,78.88 69.93,85.86 67.37,85.86 66.48,86.75 66.18,86.75 62.06,90.87 51.35,90.87 50.83,90.36 47.89,90.36 47.05,89.52 43.65,89.52 41.99,87.87 41.59,87.87 41.31,87.59 41.31,84.54 41.08,84.31 40.32,84.31 40.19,84.19 40.19,83.93 40.32,83.81 41.56,83.81 v1(41.71,83.65)
  BOTTOM w0.102: v2(80.14,74.37) 79.94,74.37 79.69,74.11 79.69,73.26 80.1,72.84 U30.C30
M_B_DM1: length 61.2
  TOP w0.102: v1(43.88,84.19) U5.E2
  IN3 w0.089: v1(76.87,71.85) 80.3,71.85 80.43,71.72 80.43,70.73 80.55,70.6 80.71,70.6 80.81,70.7 80.81,72.8 80.9,72.88 81.08,72.88 81.17,72.8 81.17,71.58 81.26,71.49 81.51,71.49 81.6,71.58 81.6,73.14 81.47,73.27 80.71,73.27 79.87,72.43 76.08,72.43 74.64,73.87 74.64,74.9 70.1,79.44 67.98,79.44 65.98,81.43 64.86,81.43 62.13,84.17 49.46,84.17 48.97,83.68 47.33,83.68 47.13,83.48 44.59,83.48 v1(43.88,84.19)
  BOTTOM w0.102: v1(76.87,71.85) 77.84,70.88 77.84,70.01 78.79,69.07 79.13,69.07 U30.H32
M_B_DM2: length 61.5
  TOP w0.102: v1(41.72,72.25) 41.73,71.93 42.51,71.14 U6.E7
  IN3 w0.089: v1(41.72,72.25) 41.33,72.64 41.33,76.33 41.43,76.44 41.68,76.44 41.78,76.54 41.78,77.28 42.08,77.57 42.08,78.42 42.3,78.64 42.78,78.64 42.88,78.54 42.88,78.08 42.98,77.98 43.13,77.98 43.24,78.08 43.24,78.54 43.34,78.64 43.49,78.64 43.59,78.54 43.59,78.08 43.7,77.98 43.84,77.98 43.95,78.08 43.95,78.54 44.05,78.64 44.2,78.64 44.3,78.54 44.3,78.08 44.41,77.98 44.55,77.98 44.66,78.08 44.66,78.54 44.76,78.64 44.91,78.64 45.01,78.54 45.01,78.08 45.12,77.98 45.27,77.98 45.37,78.08 45.37,78.54 45.47,78.64 46.08,78.64 46.18,78.54 46.18,78.08 46.29,77.98 46.43,77.98 46.54,78.08 46.54,78.54 46.64,78.64 46.79,78.64 46.89,78.54 46.89,78.08 47,77.98 50.91,77.98 51.18,77.7 64,77.7 72.05,69.66 74.18,69.66 75.51,68.33 75.51,67.44 74.99,66.92 74.41,66.92 v2(74.28,66.79)
  BOTTOM w0.089: U30.M29 80.06,65.49 79.73,65.82 79.49,65.82 79.36,65.69 78.87,65.69 78.8,65.61 78.45,65.61 78.29,65.77
  BOTTOM w0.102: v2(74.28,66.79) 77.04,66.79 77.93,65.9 78.17,65.9 78.29,65.77
M_B_DM3: length 63.7
  TOP w0.102: v1(43.88,72.81) U6.E2
  IN3 w0.089: v1(43.88,72.81) 43.97,72.71 43.97,72.06 44.44,71.59 44.66,71.59 44.87,71.38 44.87,70.9 44.97,70.79 52.6,70.79 53.17,70.22 53.66,70.22 53.91,70.47 56.74,70.47 57,70.22 59.81,70.22 60.66,69.37 64.29,69.37 69.89,63.77 72.17,63.77 v2(72.71,63.23)
  BOTTOM w0.089: 77.79,62.78 78.98,62.78 79.08,62.69 79.35,62.69 79.53,62.87 79.69,62.87 80.06,62.49 U30.T29
  BOTTOM w0.102: v2(72.71,63.23) 72.58,63.11 67.88,63.11 67.63,62.85 67.63,61.45 67.5,61.33 67.14,61.33 67.04,61.43 67.04,62.75 66.94,62.85 66.78,62.85 66.67,62.75 66.67,61.43 66.57,61.33 66.36,61.33 66.23,61.45 66.23,63.49 66.39,63.65 73.56,63.65 74.36,62.85 76.77,62.85 76.84,62.78 77.79,62.78
M_B_DM4: length 62.1
  TOP w0.102: U9.E2 v2(43.33,51.53)
  IN3 w0.089: v2(43.33,51.53) 43.64,51.53 43.73,51.44 43.73,50.4 44.17,49.96 44.3,49.96 44.38,50.05 44.38,50.15 44.51,50.28 44.72,50.28 44.81,50.19 44.81,49.6 44.9,49.52 45.08,49.52 45.17,49.6 45.17,50.19 45.25,50.28 45.53,50.28 45.65,50.15 45.91,50.15 46.04,50.28 46.67,50.28 46.8,50.4 47.09,50.4 47.18,50.49 47.18,50.79 47.31,50.91 48.83,50.91 48.96,50.79 49.21,50.79 49.34,50.91 50.48,50.91 50.73,50.66 50.73,50.07 51.38,49.42 59.24,49.42 59.53,49.14 59.72,49.14 60.01,49.42 60.89,49.42 61.18,49.14 61.5,49.14 61.78,49.42 62.04,49.42 62.07,49.39 62.51,49.39 62.55,49.42 63.15,49.42 63.82,48.75 63.82,48.59 63.9,48.5 64.07,48.5 64.7,47.87 64.7,46.43 64.79,46.34 65.12,46.34 65.21,46.43 65.21,46.76 65.3,46.85 67.32,46.85 68.17,46 68.17,45.31 68.26,45.22 69.56,45.22 69.65,45.13 69.65,44.57 69.78,44.44 69.92,44.44 70.01,44.52 70.01,45.13 70.1,45.22 70.33,45.22 70.42,45.13 70.42,44.78 70.51,44.69 71.18,44.69 71.4,44.47 71.4,44.26 71.31,44.17 70.81,44.17 v2(70.67,44.03)
  BOTTOM w0.089: U30.AU30 79.82,44.81 79.47,44.81 79.36,44.69 78.8,44.69
  BOTTOM w0.102: 78.8,44.69 78.55,44.69 78.29,44.42 77.27,44.42 77.15,44.31 75.91,44.31 75.8,44.21 75.8,43.65 75.7,43.55 75.5,43.55 75.4,43.65 75.4,44.21 75.3,44.31 71.82,44.31 71.69,44.44 70.39,44.44 70.28,44.54 70.28,44.88 70.18,44.98 69.98,44.98 69.88,44.88 69.88,44.54 69.78,44.44 69.57,44.44 69.47,44.54 69.47,44.88 69.37,44.98 69.17,44.98 69.07,44.88 69.07,44.16 68.96,44.06 68.74,44.06 68.64,44.16 68.64,44.82 68.51,44.94 67.37,44.94 67.24,44.82 67.24,44.18 67.88,43.55 70.42,43.55 70.67,43.8 v2(70.67,44.03)
M_B_DM5: length 63.3
  TOP w0.102: U9.E7 v1(43.33,46.73)
  IN3 w0.089: v2(65.47,39.1) 65.28,39.1 60.39,43.99 50.86,43.99 49.45,45.4 48.14,45.4 47.61,44.87 44.45,44.87 43.84,45.48 43.84,46.21 v1(43.33,46.73)
  BOTTOM w0.102: v2(65.47,39.1) 63.05,39.1 62.67,38.72 61.67,38.72 61.57,38.62 61.57,37.55 61.47,37.45 61.27,37.45 61.16,37.55 61.16,38.62 61.06,38.72 60.86,38.72 60.76,38.62 60.76,37.96 60.66,37.86 60.45,37.86 60.35,37.96 60.35,38.62 60.25,38.72 59.88,38.72 59.75,38.59 59.75,37.68 60.62,36.82 61.91,36.82 62.55,37.45 62.55,37.83 63.18,38.47 66.23,38.47 66.48,38.21 66.48,37.58 66.61,37.45 68.64,37.45 68.77,37.32 68.77,37.2 69.02,36.94 70.91,36.94 71.05,37.09 71.05,37.35 71.16,37.45 71.77,37.45 71.94,37.62 71.94,37.98 72.05,38.09 72.58,38.09 73.09,38.59 73.09,39.36 73.32,39.58 79.79,39.58 80.9,40.69 U30.BD28
M_B_DM6: length 60.1
  TOP w0.102: U12.E7 v1(41.84,37.39)
  IN3 w0.089: v1(82.1,37.55) 82.5,37.95 82.5,38.07 81.93,38.64 81.81,38.64 81.72,38.56 81.72,38.43 81.63,38.34 81.47,38.34 81.16,38.64 74.15,38.64 73.98,38.47 73.98,38.21 74.48,37.71 74.48,37.17 70.95,33.64 70.47,33.64 70.38,33.73 70.38,34.57 70.29,34.66 70.11,34.66 70.02,34.57 70.02,33.73 69.94,33.64 63.77,33.64 63.38,34.03 63.26,34.03 63.15,33.92 63.03,33.92 62.9,34.05 62.9,34.17 63,34.28 63,34.4 62.88,34.53 62.75,34.53 62.65,34.43 62.52,34.43 62.4,34.55 62.4,34.68 62.5,34.78 62.5,34.91 62.38,35.03 62.25,35.03 62.15,34.93 62.02,34.93 61.89,35.05 61.89,35.18 62,35.28 62,35.41 61.87,35.53 61.75,35.53 61.64,35.43 61.52,35.43 61.39,35.56 61.39,35.68 61.5,35.79 61.5,35.91 60.08,37.32 58.1,37.32 57.49,37.93 50.28,37.93 48.14,40.08 44.62,40.08 44.46,39.91 44.46,39.91 44.29,39.74 43.44,39.74 41.84,38.14 v1(41.84,37.39)
  BOTTOM w0.089: U30.BB23 84.38,41.37 84.38,41.02 84.2,40.84 84.2,40.33 84.03,40.16 84.03,40.08
  BOTTOM w0.102: v1(82.1,37.55) 82.1,37.96 82.83,38.69 82.83,38.88 84.03,40.08
M_B_DM7: length 60.3
  TOP w0.102: U12.E2 43.45,38.77 v1(44.15,37.94)
  IN3 w0.089: v2(86.68,37.71) 86.68,37.96 86.55,38.09 86.4,38.09 85.79,37.48 85.79,36.31 85.66,36.18 85.66,35.29 84.67,34.3 82.46,34.3 80.35,36.41 76.77,36.41 71.46,31.1 60.13,31.1 58.84,32.4 56.85,32.4 56.29,31.83 51.17,31.83 49.36,33.64 48.67,33.64 48.19,34.12 48.19,34.81 46.89,36.12 46.5,36.12 46.41,36.03 46.41,35.89 46.32,35.8 46.14,35.8 46.05,35.89 46.05,36.03 45.96,36.12 45.78,36.12 45.7,36.03 45.7,35.89 45.61,35.8 45.43,35.8 45.34,35.89 45.34,36.03 45.25,36.12 45.07,36.12 44.98,36.03 44.98,35.89 44.9,35.8 44.72,35.8 44.63,35.89 44.63,36.03 44.54,36.12 44.2,36.12 44,36.31 44,37.07 44.15,37.22 v1(44.15,37.94)
  BOTTOM w0.089: U30.BD20 87.51,39.64
  BOTTOM w0.102: v2(86.68,37.71) 87.06,38.09 87.06,39.19 87.51,39.64
M_B_DQ0: length 61.6
  TOP w0.102: v1(40.91,84.93) 40.1,84.93 U5.J3
  IN3 w0.089: v2(82.35,76.71) 81.95,77.11 81.95,79.01 81.01,79.95 77.3,79.95 69.89,87.36 68.64,87.36 63.94,92.06 57.85,92.06 57.34,92.57 53.91,92.57 53.78,92.44 47.56,92.44 47.28,92.16 44.74,92.16 43.5,90.92 42.73,90.92 39.79,87.97 39.79,86.29 40.07,86.01 40.07,85.78 v1(40.91,84.93)
  BOTTOM w0.102: v2(82.35,76.71) 81.45,75.81 81.45,72.54 U30.C27
M_B_DQ1: length 61.5
  TOP w0.102: v1(41.71,86.53) 41.71,86.49 U5.G2
  IN3 w0.089: v1(41.71,86.53) 42.11,86.93 42.11,87.5 43.75,89.14 47.18,89.14 48.06,90.02 50.98,90.02 51.49,90.53 55.87,90.53 55.95,90.44 55.95,90.12 56.04,90.03 56.22,90.03 56.31,90.12 56.31,90.44 56.4,90.53 56.58,90.53 56.67,90.44 56.67,90.12 56.75,90.03 56.93,90.03 57.02,90.12 57.02,90.44 57.11,90.53 57.29,90.53 57.38,90.44 57.38,90.12 57.47,90.03 57.64,90.03 57.73,90.12 57.73,90.44 57.82,90.53 61.92,90.53 62.55,89.9 62.55,89.78 62.1,89.33 62.1,89.2 62.24,89.06 62.37,89.06 62.81,89.51 62.94,89.51 66.04,86.41 66.34,86.41 67.23,85.52 69.79,85.52 76.79,78.52 80.43,78.52 80.58,78.38 80.58,77.8 80.49,77.71 v1(79.94,77.71)
  BOTTOM w0.102: U30.A28 81.21,73.5 81.21,78.5 81.11,78.6 80.91,78.6 80.81,78.5 80.81,77.28 80.74,77.21 80.52,77.21 80.43,77.3 80.43,78.5 80.33,78.6 80.07,78.6 79.94,78.47 v1(79.94,77.71)
M_B_DQ2: length 61.5
  TOP w0.102: U5.H8 v1(40.93,81.71)
  IN3 w0.089: v1(40.93,81.71) 40.93,82.03 41,82.1 41.26,82.1 41.33,82.04 41.33,80.64 41.46,80.51 42.86,80.51 42.95,80.59 42.95,81.05 42.86,81.14 42.23,81.14 42.13,81.24 42.13,82.06 42.23,82.16 42.82,82.16 42.95,82.28 42.95,82.54 43.03,82.61 44.09,82.61 44.18,82.7 44.18,82.88 44.09,82.97 43.56,82.97 43.47,83.06 43.47,84.37 44.44,85.35 44.5,85.35 44.66,85.51 45.2,85.51 45.3,85.61 45.3,85.99 45.42,86.11 45.92,86.11 46.21,85.81 46.42,85.81 47,86.4 47,86.7 47.3,87 47.58,87 47.67,86.91 47.67,86.74 47.76,86.65 47.94,86.65 48.03,86.74 48.03,86.91 48.12,87 57.7,87 58.46,86.24 62.98,86.24 64.84,84.38 65.5,84.38 66.37,83.51 68.96,83.51 76.07,76.4 76.32,76.4 76.82,75.91 76.94,75.91 77.19,76.15 77.31,76.15 77.44,76.02 77.44,75.9 77.2,75.65 77.2,75.53 77.3,75.42 v2(79.69,75.42)
  BOTTOM w0.102: U30.F29 80.4,71.06 80.06,71.4 80.06,71.98 79.78,72.26 79.78,72.85 79.01,73.63 79.01,74.76 79.16,74.92 79.56,74.92 79.69,75.04 v2(79.69,75.42)
M_B_DQ3: length 62.3
  TOP w0.102: U5.H7 v1(40.93,82.51)
  IN3 w0.089: v1(40.93,82.51) 41.33,82.91 42.07,82.91 42.73,83.57 42.73,84.63 44.21,86.11 44.29,86.11 45.89,87.71 62.88,87.71 63.15,87.44 63.15,87.05 65.13,85.06 65.79,85.06 66.65,84.2 69.24,84.2 76.34,77.1 77.38,77.1 77.79,76.69 v2(78.42,76.69)
  BOTTOM w0.102: U30.F31 79.61,71.17 79.56,71.22 79.56,71.59 78.58,72.56 78.58,74.88 77.53,75.93 77.53,76.31 76.71,77.13 76.71,77.13 76.33,77.51 74.76,77.51 74.66,77.6 74.66,78.55 74.73,78.62 74.95,78.62 75.05,78.52 75.05,78.07 75.15,77.96 75.31,77.96 75.42,78.07 75.42,78.51 75.5,78.6 75.8,78.6 77.71,76.69 v2(78.42,76.69)
M_B_DQ4: length 60.1
  TOP w0.102: U5.H2 40.91,86.49 v1(40.91,86.53)
  IN3 w0.089: v1(40.91,86.53) 40.5,86.95 40.5,87.71 41,88.21 41.85,88.21 43.67,90.03 46.88,90.03 48.07,91.22 49.58,91.22 49.67,91.13 49.67,90.88 49.76,90.79 49.94,90.79 50.03,90.88 50.03,91.13 50.11,91.22 50.29,91.22 50.38,91.13 50.38,90.88 50.47,90.79 50.65,90.79 50.74,90.88 50.74,91.13 50.83,91.22 62.2,91.22 65.84,87.58 67.12,87.58 68.5,86.21 70.07,86.21 77.04,79.23 80.75,79.23 81.27,78.72 81.27,77.47 80.88,77.09 80.88,75.3 80.97,75.21 81.76,75.21 81.85,75.12 81.85,74.94 81.76,74.86 80.97,74.86 80.88,74.77 80.88,74.48 81,74.37 v2(82.35,74.37)
  BOTTOM w0.102: U30.B27 81.88,73.02 81.88,74.05 82.17,74.35 82.32,74.35 v2(82.35,74.37)
M_B_DQ5: length 60.9
  TOP w0.102: v1(40.91,85.73) 40.91,85.69 U5.H3
  IN3 w0.089: v1(40.91,85.73) 40.44,86.21 40.44,86.42 40.13,86.73 40.13,87.83 42.71,90.41 43.74,90.41 44.89,91.56 49.81,91.56 49.9,91.65 49.9,91.97 49.99,92.06 50.17,92.06 50.26,91.97 50.26,91.65 50.34,91.56 50.52,91.56 50.61,91.65 50.61,91.97 50.7,92.06 50.88,92.06 50.97,91.97 50.97,91.65 51.06,91.56 53.65,91.56 54.3,92.21 57.19,92.21 57.68,91.72 63.69,91.72 68.39,87.02 69.74,87.02 77.17,79.59 80.88,79.59 81.61,78.86 81.61,76.28 v2(82.35,75.54)
  BOTTOM w0.102: U30.D27 82,72.43 81.66,72.77 81.66,74.85 v2(82.35,75.54)
M_B_DQ6: length 62.7
  TOP w0.102: U5.J7 40.92,83.3 v1(40.96,83.3)
  IN3 w0.089: v2(77.53,77.46) 76.47,77.46 69.38,84.54 66.79,84.54 65.93,85.41 65.27,85.41 63.49,87.19 63.49,87.58 63.02,88.05 44.29,88.05 43.62,87.38 43.62,86.09 42.23,84.7 42.23,83.6 41.88,83.25 41,83.25 v1(40.96,83.3)
  BOTTOM w0.102: U30.E32 79.21,71.63 78.34,72.49 78.34,74.74 77.28,75.81 77.28,76.06 76.19,77.15 73.77,77.15 73.47,77.46 73.47,79.11 73.72,79.36 75.63,79.36 v2(77.53,77.46)
M_B_DQ7: length 61.8
  TOP w0.102: U5.F7 v1(41.73,82.51)
  IN3 w0.089: v2(79.21,75.81) 78.19,75.81 77.25,76.74 76.21,76.74 69.1,83.86 66.51,83.86 65.65,84.72 64.99,84.72 63.13,86.58 62.89,86.58 62.8,86.67 62.8,87.27 62.72,87.36 62.54,87.36 62.45,87.27 62.45,86.67 62.36,86.58 62.18,86.58 62.09,86.67 62.09,87.27 62,87.36 61.83,87.36 61.74,87.27 61.74,86.67 61.65,86.58 61.47,86.58 61.38,86.67 61.38,87.27 61.29,87.36 61.12,87.36 61.03,87.27 61.03,86.67 60.94,86.58 60.76,86.58 60.67,86.67 60.67,87.27 60.58,87.36 60.4,87.36 60.32,87.27 60.32,86.67 60.23,86.58 60.05,86.58 59.96,86.67 59.96,87.27 59.87,87.36 59.69,87.36 59.6,87.27 59.6,86.67 59.51,86.58 59.34,86.58 59.25,86.67 59.25,87.27 59.16,87.36 58.98,87.36 58.89,87.27 58.89,86.67 58.8,86.58 58.63,86.58 58.51,86.7 58.51,87.24 58.4,87.34 47.16,87.34 46.72,86.91 45.57,86.91 44.43,85.76 44.38,85.76 43.11,84.5 43.11,83.45 42.17,82.51 v1(41.73,82.51)
  BOTTOM w0.102: U30.F30 79.81,71.18 79.81,71.93 79.56,72.19 79.56,72.79 78.78,73.56 78.78,75.13 77.79,76.13 77.79,76.31 77.89,76.41 78.12,76.41 78.73,75.81 v2(79.21,75.81)
M_B_DQ8: length 63.1
  TOP w0.102: U5.C3 44.53,85.06 v1(44.77,84.82)
  IN3 w0.089: v2(76.01,74.54) 75.97,74.54 70.39,80.12 68.26,80.12 66.27,82.12 65.15,82.12 62.41,84.85 57.87,84.85 57.38,85.35 51.3,85.35 50.83,84.88 49.2,84.88 48.68,84.36 47.05,84.36 46.85,84.16 45.42,84.16 v1(44.77,84.82)
  BOTTOM w0.089: U30.H31 78.98,69.49
  BOTTOM w0.102: v2(76.01,74.54) 75.5,75.04 75.3,75.04 74.9,74.65 74.75,74.65 74.64,74.76 74.64,75.17 74.51,75.3 74.36,75.3 74.23,75.17 74.23,74.64 74.1,74.51 73.93,74.51 73.83,74.61 73.83,75.2 73.73,75.3 73.57,75.3 73.46,75.2 73.46,74.61 73.36,74.51 73.2,74.51 73.1,74.61 73.1,75.2 72.99,75.3 72.83,75.3 72.73,75.2 72.73,74.61 72.63,74.51 72.46,74.51 72.36,74.61 72.36,75.2 72.26,75.3 72.09,75.3 71.99,75.2 71.99,74.61 71.89,74.51 71.72,74.51 71.62,74.61 71.62,75.2 71.52,75.3 71.36,75.3 71.25,75.2 71.25,74.61 71.15,74.51 70.95,74.51 70.8,74.66 70.8,75.55 70.93,75.68 75.42,75.68 76.44,74.66 76.44,73.34 78.29,71.49 78.29,70.18 78.98,69.49
M_B_DQ9: length 62
  TOP w0.102: v1(44.77,84.19) 43.73,85.23 U5.D3
  IN3 w0.089: v1(44.77,84.19) 44.77,83.92 44.87,83.82 46.99,83.82 47.19,84.02 48.83,84.02 49.32,84.51 50.95,84.51 51.45,85.01 57.23,85.01 57.73,84.51 62.27,84.51 65,81.77 66.13,81.77 68.12,79.78 70.24,79.78 74.99,75.03 74.99,74.38 75.22,74.15 75.63,74.15 v1(76.01,73.77)
  BOTTOM w0.089: 78.93,69.29 79.34,69.29 79.49,69.14 79.86,69.14 U30.H30
  BOTTOM w0.102: 78.93,69.29 78.87,69.29 78.06,70.1 78.06,71.34 76.77,72.63 74.86,72.63 74.48,73.01 73.91,73.01 73.81,73.11 73.81,73.67 73.7,73.77 73.54,73.77 73.44,73.67 73.44,73.11 73.34,73.01 73.17,73.01 73.07,73.11 73.07,73.67 72.97,73.77 72.8,73.77 72.7,73.67 72.7,73.11 72.6,73.01 72.43,73.01 72.33,73.11 72.33,73.67 72.23,73.77 72.07,73.77 71.96,73.67 71.96,73.11 71.86,73.01 71.7,73.01 71.6,73.11 71.6,73.67 71.49,73.77 71.33,73.77 71.23,73.67 71.23,73.11 71.13,73.01 70.93,73.01 70.8,73.14 70.8,73.9 71.05,74.15 74.1,74.15 74.89,73.37 75.6,73.37 v1(76.01,73.77)
M_B_DQ10: length 60.9
  TOP w0.102: U5.C8 v1(44.93,80.91)
  IN3 w0.089: v1(44.93,80.91) 44.64,80.91 44.54,81.01 44.54,81.22 44.63,81.31 45.11,81.31 45.15,81.27 45.92,81.27 46.03,81.39 47.49,81.39 48.13,82.03 49.94,82.03 50.07,81.9 50.07,80.82 50.17,80.71 50.32,80.71 50.42,80.82 50.42,81.92 50.53,82.03 50.67,82.03 50.78,81.92 50.78,80.82 50.88,80.71 51.03,80.71 51.13,80.82 51.13,81.92 51.24,82.03 53.53,82.03 53.95,81.61 53.95,81.13 53.83,81.01 51.86,81.01 51.75,80.9 51.75,80.75 51.86,80.65 57.77,80.65 57.86,80.74 57.86,81.94 57.94,82.03 58.12,82.03 58.21,81.94 58.21,80.74 58.3,80.65 60.55,80.65 61.42,79.78 65.15,79.78 74.08,70.85 74.48,70.85 76.56,68.78 76.56,67.28 76.64,67.19 76.82,67.19 76.92,67.3 76.92,68.03 77.01,68.12 77.19,68.12 77.28,68.03 77.28,67.3 77.38,67.19 77.56,67.19 77.66,67.3 77.66,68.16 77.25,68.57 v2(77.25,69.08)
  BOTTOM w0.089: 78.3,67.43 78.36,67.37 78.85,67.37 78.97,67.49 U30.K31
  BOTTOM w0.102: v2(77.25,69.08) 77.25,68.49 78.3,67.43
M_B_DQ11: length 61.1
  TOP w0.102: U5.B8 45.69,81.67 v1(45.73,81.67)
  IN3 w0.089: v1(45.73,81.67) 45.8,81.73 47.34,81.73 47.98,82.37 49.82,82.37 49.93,82.48 49.93,82.76 50.03,82.86 50.18,82.86 50.28,82.76 50.28,82.48 50.39,82.37 50.54,82.37 50.64,82.48 50.64,82.76 50.74,82.86 50.89,82.86 51,82.76 51,82.48 51.1,82.37 51.25,82.37 51.35,82.48 51.35,82.76 51.46,82.86 53.65,82.86 53.76,82.76 53.76,82.29 54.02,82.03 54.29,82.03 54.42,81.9 54.42,81.1 54.52,80.99 54.67,80.99 54.78,81.1 54.78,81.92 54.88,82.03 55.03,82.03 55.13,81.92 55.13,81.1 55.24,80.99 55.46,80.99 55.57,81.1 55.57,82.76 55.67,82.86 55.82,82.86 55.92,82.76 55.92,81.1 56.03,80.99 57.41,80.99 57.5,81.08 57.5,82.7 57.58,82.79 57.76,82.79 57.85,82.7 57.85,82.5 57.94,82.41 58.12,82.41 58.21,82.5 58.21,82.7 58.29,82.79 58.47,82.79 58.56,82.7 58.56,81.1 58.65,81.01 58.83,81.01 58.92,81.1 58.92,82.7 59.01,82.79 59.18,82.79 59.27,82.7 59.27,81.1 59.36,81.01 59.54,81.01 59.63,81.1 59.63,82.7 59.72,82.79 59.89,82.79 59.98,82.7 59.98,81.1 60.07,81.01 60.68,81.01 61.57,80.12 65.31,80.12 74.2,71.23 74.61,71.23 76.02,69.82 76.3,69.82 v2(76.43,69.96)
  BOTTOM w0.089: U30.L30 79.84,67.16 79.49,67.16 79.35,67.29 79.06,67.29 78.95,67.18 78.25,67.18 78.15,67.28
  BOTTOM w0.102: 78.15,67.28 76.26,69.17 76.26,69.79 v2(76.43,69.96)
M_B_DQ12: length 62.2
  TOP w0.102: v1(46.54,84.91) 46.53,84.91 U5.A3
  IN3 w0.089: v1(77.53,74.15) 76.01,75.68 75.8,75.68 70.2,81.28 70.07,81.28 69.6,80.81 69.48,80.81 69.35,80.94 69.35,81.06 69.82,81.53 69.82,81.66 68.67,82.82 67.75,82.82 67.67,82.73 67.67,82.07 67.58,81.98 67.4,81.98 67.31,82.07 67.31,82.73 67.22,82.82 66.08,82.82 65.21,83.68 64.55,83.68 62.69,85.54 58.16,85.54 57.66,86.04 50.85,86.04 50.76,85.95 50.76,85.8 50.67,85.71 50.49,85.71 50.4,85.8 50.4,86.21 50.32,86.3 50.14,86.3 50.05,86.21 50.05,85.67 49.96,85.58 49.78,85.58 49.69,85.67 49.69,86.21 49.6,86.3 49.43,86.3 49.34,86.21 49.34,85.67 49.25,85.58 49.07,85.58 48.98,85.67 48.98,85.95 48.89,86.04 48.28,86.04 48.18,85.93 48.18,85.47 47.75,85.05 47.65,85.05 47.56,85.14 47.56,85.6 47.47,85.69 47.29,85.69 47.2,85.6 47.2,85.14 47.11,85.05 46.68,85.05 v1(46.54,84.91)
  BOTTOM w0.102: U30.G30 79.9,70.09 79.57,70.09 79.3,70.36 79.3,70.96 78.85,71.4 78.85,71.68 78.11,72.42 78.11,73.58 78.02,73.66 78.02,74.3 75.88,76.44 72.48,76.44 72.38,76.34 72.38,76.14 72.48,76.03 75.65,76.03 v1(77.53,74.15)
M_B_DQ13: length 61.6
  TOP w0.102: U5.C2 44.93,85.71 44.93,85.24 45.26,84.91 v1(45.74,84.91)
  IN3 w0.089: v1(45.74,84.91) 46.14,84.51 46.7,84.51 46.91,84.71 47.9,84.71 48.41,85.22 50.69,85.22 51.16,85.69 57.52,85.69 58.01,85.2 62.55,85.2 65.29,82.46 66.41,82.46 67.43,81.44 67.55,81.44 68.39,82.28 68.52,82.28 68.64,82.16 68.64,82.03 67.8,81.19 67.8,81.07 67.93,80.94 68.05,80.94 68.89,81.78 69.02,81.78 69.14,81.65 69.14,81.53 68.31,80.69 68.31,80.56 68.4,80.47 70.53,80.47 75.67,75.32 75.86,75.32 76.41,74.76 76.41,72.9 76.54,72.77 78.31,72.77 78.75,73.21 79.31,73.21 79.44,73.34 79.44,74.64 79.36,74.71 79.06,74.71 78.97,74.62 78.97,73.73 78.88,73.65 78.64,73.65 78.55,73.73 78.55,74.62 78.46,74.71 78.17,74.71 78.04,74.59 78.04,73.39 77.79,73.14 77.28,73.14 v2(76.9,73.52)
  BOTTOM w0.089: U30.H29 80.04,69.49 79.71,69.82 79.47,69.82 79.33,69.69 79.3,69.69 79.08,69.69 78.93,69.84
  BOTTOM w0.102: 78.93,69.84 78.51,70.25 78.51,71.65 76.9,73.27 v2(76.9,73.52)
M_B_DQ14: length 60.5
  TOP w0.102: U5.C7 v1(44.93,81.71)
  IN3 w0.089: v1(44.93,81.71) 44.93,82.05 45.03,82.16 45.4,82.16 45.48,82.07 47.2,82.07 47.84,82.71 49.37,82.71 49.86,83.2 59.97,83.2 60.33,82.84 60.33,81.85 61.71,80.47 65.45,80.47 74.31,71.61 76.13,71.61 76.39,71.36 79.94,71.36 80.07,71.23 80.07,71.07 79.98,70.98 79.46,70.98 79.36,70.88 79.36,70.7 79.46,70.6 79.98,70.6 80.07,70.51 80.07,70.18 79.98,70.09 78,70.09 77.91,70 77.91,69.8 78,69.71 79.98,69.71 80.07,69.62 80.07,69.05 79.94,68.92 78.19,68.92 76.26,70.85 v1(75.63,70.85)
  BOTTOM w0.089: 78.55,68.44 78.67,68.44 78.82,68.29 79.36,68.29 79.6,68.05 79.95,68.05 U30.K30
  BOTTOM w0.102: v1(75.63,70.85) 76.1,70.85 78.52,68.44 78.55,68.44
M_B_DQ15: length 60.6
  TOP w0.102: U5.D7 v1(44.13,81.71)
  IN3 w0.089: v1(44.13,81.71) 43.75,81.71 43.65,81.6 43.65,80.61 43.78,80.47 46.02,80.47 46.13,80.58 46.13,80.94 46.23,81.04 46.38,81.04 46.48,80.94 46.48,80.47 46.59,80.37 46.73,80.37 46.84,80.47 46.84,80.94 46.94,81.04 47.09,81.04 47.19,80.94 47.19,80.47 47.3,80.37 47.45,80.37 47.55,80.47 47.55,80.94 47.65,81.04 47.8,81.04 47.9,80.94 47.9,80.58 48.01,80.47 49.25,80.47 49.36,80.58 49.36,81.21 49.25,81.31 48.25,81.31 48.14,81.41 48.14,81.56 48.25,81.66 49.61,81.66 49.71,81.56 49.71,80.47 49.82,80.37 51.16,80.37 51.23,80.31 60.41,80.31 61.28,79.44 64.88,79.44 73.95,70.37 74.46,70.37 76.21,68.62 76.21,67.03 76.39,66.85 77.88,66.85 78.26,67.23 79.94,67.23 80.07,67.36 80.07,67.62 79.98,67.71 79.27,67.71 79.18,67.8 79.18,67.97 79.27,68.06 79.98,68.06 80.07,68.15 80.07,68.34 79.97,68.44 78.27,68.44 v2(78.08,68.25)
  BOTTOM w0.089: 78.87,67.66 78.89,67.69 79.35,67.69 79.45,67.79 79.73,67.79 80.04,67.49 U30.K29
  BOTTOM w0.102: 78.87,67.66 78.78,67.58 78.44,67.58 78.08,67.94 v2(78.08,68.25)
M_B_DQ16: length 60.9
  TOP w0.102: U6.J7 40.93,71.93 v1(40.93,72.01)
  IN3 w0.089: v1(40.93,72.01) 39.83,72.01 39.73,71.91 39.73,67.4 39.83,67.3 39.98,67.3 40.08,67.4 40.08,71.4 40.19,71.5 41.08,71.5 41.42,71.85 42.14,71.85 42.25,71.95 42.25,73.47 43.71,74.94 43.71,75.29 43.95,75.53 44.28,75.53 44.51,75.76 44.51,76.57 44.62,76.67 48.23,76.67 48.33,76.57 48.33,75.86 48.44,75.76 57.48,75.76 58.23,75 64.74,75 71.23,68.51 v2(71.23,68.19)
  BOTTOM w0.089: 77.76,64.99 79.2,64.99 U30.N32
  BOTTOM w0.102: 77.76,64.99 77.74,64.99 76.83,65.9 72.45,65.9 71.23,67.12 v2(71.23,68.19)
M_B_DQ17: length 61.1
  TOP w0.102: v1(40.93,71.1) 40.9,71.1 U6.H7
  IN3 w0.089: v1(40.93,71.1) 41.16,71.1 41.56,71.5 41.89,71.5 42.13,71.27 42.13,70.04 42.25,69.92 42.57,69.92 42.67,69.81 42.67,69.66 42.57,69.56 42.23,69.56 42.13,69.46 42.13,69.31 42.23,69.2 42.57,69.2 42.67,69.1 42.67,68.26 42.78,68.15 42.92,68.15 43.03,68.26 43.03,71.05 42.59,71.49 42.59,73.33 43.99,74.73 44.28,74.73 45.88,76.33 47.89,76.33 47.99,76.22 47.99,75.52 48.09,75.41 53.85,75.41 53.97,75.3 53.97,74.89 54.07,74.79 54.22,74.79 54.32,74.89 54.32,75.3 54.43,75.41 57.33,75.41 58.09,74.66 64.58,74.66 70.29,68.95 v1(70.29,67.93)
  BOTTOM w0.089: U30.N29 80.06,64.49 79.69,64.86 79.55,64.86 79.37,64.69 79.08,64.69 78.98,64.79 77.63,64.79
  BOTTOM w0.102: v1(70.29,67.93) 70.27,67.91 69.07,67.91 68.97,67.8 68.97,67.22 69.12,67.07 70.7,67.07 71.59,66.18 71.66,66.18 72.2,65.65 76.77,65.65 77.63,64.79
M_B_DQ18: length 61.9
  TOP w0.102: U6.H8 40.9,70.3 v1(40.93,70.3)
  IN3 w0.089: v1(40.93,70.3) 40.44,69.81 40.44,67.05 40.78,66.71 42.96,66.71 43.71,67.46 43.71,71.33 43.27,71.77 43.27,73.04 43.93,73.7 44.27,74.04 44.56,74.04 45.25,74.73 50.8,74.73 51.35,74.18 52.55,74.18 52.75,73.98 56.62,73.98 56.82,74.18 57.09,74.18 57.3,73.98 64.12,73.98 68.26,69.84 v2(68.26,69.71)
  BOTTOM w0.089: U30.P30 79.89,64.11 79.56,64.11 79.38,64.29 78.92,64.29 78.83,64.37 77.53,64.37
  BOTTOM w0.102: 77.53,64.37 77.36,64.37 76.57,65.16 71.69,65.16 71.51,65.34 71.41,65.34 70.39,66.36 66.15,66.36 65.97,66.53 65.97,69.46 66.23,69.71 v2(68.26,69.71)
M_B_DQ19: length 61.7
  TOP w0.102: v1(41.73,75.13) 41.33,74.73 U6.G2
  IN3 w0.089: v1(41.73,75.13) 42.13,75.53 42.13,77.13 42.63,77.64 49.34,77.64 49.45,77.53 49.45,76.83 49.55,76.72 49.7,76.72 49.8,76.83 49.8,77.28 49.91,77.38 50.05,77.38 50.16,77.28 50.16,76.83 50.26,76.72 50.41,76.72 50.51,76.83 50.51,77.28 50.62,77.38 50.76,77.38 50.87,77.28 50.87,76.83 50.97,76.72 51.12,76.72 51.22,76.83 51.22,77.26 51.33,77.36 54.75,77.36 54.86,77.26 54.86,76.83 54.96,76.72 55.11,76.72 55.21,76.83 55.21,77.26 55.32,77.36 55.46,77.36 55.57,77.26 55.57,76.83 55.67,76.72 55.82,76.72 55.92,76.83 55.92,77.26 56.03,77.36 63.84,77.36 71.94,69.25 v2(73.98,69.25)
  BOTTOM w0.089: 77.99,67.12 78.12,66.99 U30.L32
  BOTTOM w0.102: 77.99,67.12 75.88,69.23 75.88,69.71 75.77,69.82 74.97,69.82 74.87,69.92 74.87,70.88 74.77,70.98 74.6,70.98 74.5,70.88 74.5,69.92 74.4,69.82 74.25,69.82 74.1,69.96 74.1,72 73.98,72.12 73.82,72.12 73.72,72.02 73.72,71.08 73.62,70.98 73.44,70.98 73.34,71.08 73.34,72.02 73.24,72.12 72.48,72.12 72.38,72.02 72.38,71.49 73.62,70.24 73.62,69.94 73.98,69.58 v2(73.98,69.25)
M_B_DQ20: length 61.2
  TOP w0.102: U6.H3 v1(40.93,73.53)
  IN3 w0.089: v1(40.93,73.53) 40.18,74.27 40.18,77.5 42.02,79.33 50.69,79.33 50.9,79.12 53.96,79.12 54.07,79.02 54.07,78.49 54.17,78.39 54.32,78.39 54.42,78.49 54.42,79.02 54.53,79.12 54.67,79.12 54.78,79.02 54.78,78.49 54.88,78.39 55.03,78.39 55.13,78.49 55.13,79.02 55.24,79.12 57.38,79.12 57.49,79.02 57.49,78.49 57.59,78.39 64.33,78.39 71.36,71.36 v1(71.94,71.36)
  BOTTOM w0.089: U30.L31 78.95,66.49 78.87,66.58 77.93,66.58
  BOTTOM w0.102: v1(71.94,71.36) 70.93,71.36 70.78,71.21 70.78,70.85 70.92,70.71 71.9,70.71 71.99,70.61 71.99,70.34 71.92,70.27 70.9,70.27 70.78,70.14 70.78,69.93 70.88,69.82 71.97,69.82 72.07,69.72 72.07,69.56 71.97,69.46 70.88,69.46 70.78,69.35 70.78,69.12 70.85,69.05 71.72,69.05 72.71,68.06 76.45,68.06 77.93,66.58
M_B_DQ21: length 61
  TOP w0.102: U6.J3 v1(40.93,72.73)
  IN3 w0.089: v2(71.05,72.25) 64.57,78.73 60.1,78.73 60.01,78.82 60.01,79.37 59.93,79.46 59.75,79.46 59.66,79.37 59.66,78.82 59.57,78.73 59.35,78.73 59.25,78.84 59.25,79.38 59.15,79.49 59,79.49 58.89,79.38 58.89,78.84 58.79,78.73 58.64,78.73 58.54,78.84 58.54,79.38 58.43,79.49 58.29,79.49 58.18,79.38 58.18,78.84 58.08,78.73 57.93,78.73 57.83,78.84 57.83,79.36 57.72,79.46 51.08,79.46 50.87,79.67 41.87,79.67 39.84,77.64 39.84,73.56 40.68,72.73 v1(40.93,72.73)
  BOTTOM w0.089: 78.79,66.38 78.87,66.29 79.37,66.29 79.52,66.14 79.85,66.14 U30.M30
  BOTTOM w0.102: 78.79,66.38 78.17,66.38 78.07,66.28 77.88,66.28 76.48,67.68 72.58,67.68 71.56,68.69 70.55,68.69 70.42,68.82 70.42,71.61 v2(71.05,72.25)
M_B_DQ22: length 62
  TOP w0.102: U6.H2 v1(40.93,74.33)
  IN3 w0.089: v1(40.93,74.33) U6.H2 40.53,76.21 40.63,76.32 40.83,76.32 40.94,76.42 40.94,76.57 40.83,76.67 40.63,76.67 40.53,76.78 40.53,76.92 40.63,77.03 40.91,77.03 40.97,77.09 40.97,77.55 41.08,77.67 41.63,77.67 41.74,77.77 41.74,78.57 42.16,78.99 48.55,78.99 48.66,78.88 48.66,78.43 48.76,78.32 48.91,78.32 49.01,78.43 49.01,78.88 49.12,78.98 49.27,78.98 49.37,78.88 49.37,78.43 49.47,78.32 49.62,78.32 49.73,78.43 49.73,78.88 49.83,78.98 49.98,78.98 50.08,78.88 50.08,78.43 50.19,78.32 50.33,78.32 50.44,78.43 50.44,78.75 50.54,78.85 50.69,78.85 50.79,78.75 50.79,78.43 50.9,78.32 51.05,78.32 51.32,78.05 52.55,78.05 52.66,78.15 52.66,78.67 52.76,78.78 52.91,78.78 53.01,78.67 53.01,78.15 53.12,78.05 53.26,78.05 53.37,78.15 53.37,78.67 53.47,78.78 53.62,78.78 53.72,78.67 53.72,78.15 53.83,78.05 64.17,78.05 71.77,70.45 v2(72.76,70.45)
  BOTTOM w0.089: 78.02,66.79 78.96,66.79 79.06,66.69 79.35,66.69 79.47,66.8 79.73,66.8 80.05,66.49 U30.L29
  BOTTOM w0.102: v2(72.76,70.45) 72.58,70.27 72.58,68.69 72.71,68.57 72.96,68.57 73.09,68.69 73.09,69.46 73.21,69.57 73.35,69.57 73.47,69.46 73.47,68.57 73.59,68.44 74.2,68.44 74.31,68.54 74.31,68.85 74.41,68.95 74.57,68.95 74.67,68.85 74.67,68.54 74.78,68.44 75.01,68.44 75.11,68.54 75.11,69.36 75.21,69.46 75.38,69.46 75.48,69.36 75.48,68.54 75.58,68.44 76.37,68.44 78.02,66.79
M_B_DQ23: length 61.9
  TOP w0.102: v1(41.73,71.1) 42.1,70.73 U6.F7
  IN3 w0.089: v2(69.28,68.82) 69.28,69.46 64.41,74.32 57.44,74.32 57.23,74.52 56.68,74.52 56.48,74.32 52.89,74.32 52.69,74.52 51.49,74.52 50.94,75.07 47.75,75.07 47.65,75.18 47.65,75.88 47.54,75.99 47.4,75.99 47.29,75.88 47.29,75.18 47.19,75.07 47.04,75.07 46.94,75.18 46.94,75.42 46.83,75.53 46.37,75.53 46.1,75.81 45.84,75.81 44.42,74.39 44.13,74.39 42.93,73.19 42.93,71.63 43.37,71.19 43.37,67.61 42.82,67.05 40.92,67.05 40.78,67.2 40.78,67.32 40.89,67.42 41.92,67.42 42.02,67.52 42.02,67.7 41.92,67.8 41.49,67.8 41.36,67.93 41.36,68.28 41.33,68.31 41.33,70.47 41.73,70.87 v1(41.73,71.1)
  BOTTOM w0.089: 77.53,64.58 78.9,64.58 79,64.49 U30.N31
  BOTTOM w0.102: v2(69.28,68.82) 68.95,68.82 68.62,68.48 68.62,66.81 68.71,66.71 70.54,66.71 71.49,65.76 71.55,65.76 71.89,65.42 76.69,65.42 77.53,64.58 77.53,64.58
M_B_DQ24: length 60.8
  TOP w0.102: U6.D3 44.91,72.74 v1(44.91,72.73)
  IN3 w0.089: v1(44.91,72.73) 44.91,72.5 44.81,72.4 44.42,72.4 44.32,72.5 44.32,73.1 44.56,73.34 44.85,73.34 45.03,73.52 45.18,73.52 45.57,73.13 45.89,73.13 46.23,72.78 47.31,72.78 47.43,72.91 47.43,73.2 47.52,73.29 47.71,73.29 47.81,73.19 47.81,72.23 47.94,72.1 48.08,72.1 48.17,72.19 48.17,73.25 48.26,73.34 48.44,73.34 48.53,73.25 48.53,72.19 48.62,72.1 48.8,72.1 48.88,72.19 48.88,73.25 48.97,73.34 49.15,73.34 49.24,73.25 49.24,72.19 49.33,72.1 49.51,72.1 49.6,72.19 49.6,73.25 49.68,73.34 49.86,73.34 49.95,73.25 49.95,72.19 50.04,72.1 50.28,72.1 50.35,72.18 50.35,72.5 50.44,72.59 57.91,72.59 57.99,72.5 57.99,72.19 58.08,72.1 58.26,72.1 58.35,72.19 58.35,72.5 58.44,72.59 58.62,72.59 58.71,72.5 58.71,72.19 58.79,72.1 58.97,72.1 59.06,72.19 59.06,72.5 59.15,72.59 59.33,72.59 59.42,72.5 59.42,72.19 59.51,72.1 59.68,72.1 59.77,72.19 59.77,72.5 59.86,72.59 60.04,72.59 60.13,72.5 60.13,72.19 60.22,72.1 60.39,72.1 60.48,72.19 60.48,72.5 60.57,72.59 60.75,72.59 60.84,72.5 60.84,72.19 60.93,72.1 61.11,72.1 61.19,72.19 61.19,72.5 61.28,72.59 61.46,72.59 61.55,72.5 61.55,72.19 61.64,72.1 61.82,72.1 61.91,72.19 61.91,72.5 61.99,72.59 62.17,72.59 62.26,72.5 62.26,72.19 62.35,72.1 62.53,72.1 62.62,72.19 62.62,72.5 62.71,72.59 63.1,72.59 69.2,66.48 69.53,66.48 69.65,66.37 69.65,66.01 69.76,65.9 69.95,65.9 70.04,65.99 70.04,66.38 70.14,66.48 70.32,66.48 70.42,66.38 70.42,65.26 70.55,65.14 70.71,65.14 70.8,65.23 70.8,66.09 70.89,66.18 71.09,66.18 71.18,66.09 71.18,65.23 71.27,65.14 72.2,65.14 v2(72.58,64.76)
  BOTTOM w0.089: 78.29,63.23 78.34,63.19 78.96,63.19 79.07,63.29 79.38,63.29 79.54,63.13 79.87,63.13 U30.R30
  BOTTOM w0.102: 78.29,63.23 78.04,63.49 74.74,63.49 73.92,64.3 73.03,64.3 v2(72.58,64.76)
M_B_DQ25: length 63.6
  TOP w0.102: U6.C3 44.53,73.92 v1(45.71,72.73)
  IN3 w0.089: v2(71.39,64.76) 70.42,64.76 63.42,71.76 57.7,71.76 57.22,72.24 51.21,72.24 50.72,71.76 47.6,71.76 46.92,72.44 45.82,72.44 45.71,72.55 v1(45.71,72.73)
  BOTTOM w0.089: 78.29,62.99 79.2,62.99 U30.R32
  BOTTOM w0.102: 78.29,62.99 77.14,62.99 76.9,63.23 74.48,63.23 73.72,63.99 72.83,63.99 72.71,64.12 65.72,64.12 65.59,64.25 65.59,65.52 65.72,65.65 66.08,65.65 66.18,65.54 66.18,64.6 66.28,64.5 66.44,64.5 66.55,64.6 66.55,65.54 66.65,65.65 66.81,65.65 66.91,65.54 66.91,64.6 67.02,64.5 67.18,64.5 67.28,64.6 67.28,65.54 67.38,65.65 67.55,65.65 67.65,65.54 67.65,64.6 67.75,64.5 67.92,64.5 68.02,64.6 68.02,65.54 68.12,65.65 68.29,65.65 68.39,65.54 68.39,64.6 68.49,64.5 68.65,64.5 68.76,64.6 68.76,65.54 68.86,65.65 69.02,65.65 69.12,65.54 69.12,64.6 69.23,64.5 69.39,64.5 69.49,64.6 69.49,65.54 69.59,65.65 69.78,65.65 69.91,65.52 69.91,64.76 70.04,64.63 71.26,64.63 v2(71.39,64.76)
M_B_DQ26: length 60.9
  TOP w0.102: U6.B8 v1(45.73,69.53)
  IN3 w0.089: v1(45.73,69.53) 45.96,69.53 46.54,70.11 47.19,70.11 47.28,70.02 47.28,68.76 47.37,68.67 47.55,68.67 47.64,68.76 47.64,70.02 47.72,70.11 47.9,70.11 47.99,70.02 47.99,68.76 48.08,68.67 48.26,68.67 48.35,68.76 48.35,70.02 48.44,70.11 48.61,70.11 48.7,70.02 48.7,68.76 48.79,68.67 48.97,68.67 49.06,68.76 49.06,70.02 49.15,70.11 49.32,70.11 49.41,70.02 49.41,68.73 49.5,68.64 49.68,68.64 49.77,68.73 49.77,70.02 49.86,70.11 50.04,70.11 50.12,70.02 50.12,68.73 50.21,68.64 50.39,68.64 50.48,68.73 50.48,70.02 50.57,70.11 50.75,70.11 50.84,70.02 50.84,69.04 50.92,68.95 51.1,68.95 51.19,69.04 51.19,70.02 51.28,70.11 52.27,70.11 53.17,69.2 54.78,69.2 54.87,69.29 54.87,69.62 54.96,69.71 55.13,69.71 55.22,69.62 55.22,69.04 55.31,68.95 55.49,68.95 55.58,69.04 55.58,69.67 55.67,69.76 55.85,69.76 55.93,69.67 55.93,69.02 56.02,68.93 56.9,68.93 56.99,69.02 56.99,69.44 57.08,69.53 57.26,69.53 57.35,69.44 57.35,69.02 57.44,68.93 57.62,68.93 57.7,69.02 57.7,69.44 57.79,69.53 57.97,69.53 58.06,69.44 58.06,69.02 58.15,68.93 58.33,68.93 58.42,69.02 58.42,69.44 58.5,69.53 58.68,69.53 58.77,69.44 58.77,69.02 58.86,68.93 60.13,68.93 60.38,68.68 63.98,68.68 69.58,63.08 71.67,63.08 72.31,62.44 73.47,62.44 73.85,62.06 v2(73.85,61.45)
  BOTTOM w0.089: U30.V30 79.87,61.13 79.54,61.13 79.38,61.29 79.08,61.29
  BOTTOM w0.102: v2(73.85,61.45) 74.26,61.86 75.47,61.86 76.54,60.79 78.58,60.79 79.08,61.29
M_B_DQ27: length 63.6
  TOP w0.102: U6.C7 v1(44.93,70.33)
  IN3 w0.089: v2(75.02,61.45) 73.67,62.8 72.44,62.8 71.82,63.42 69.72,63.42 64.12,69.02 60.52,69.02 59.67,69.87 56.86,69.87 56.62,70.12 54.06,70.12 53.67,69.72 53.16,69.72 52.43,70.45 46.4,70.45 46.15,70.21 45.05,70.21 v1(44.93,70.33)
  BOTTOM w0.102: v2(75.02,61.45) 74.61,61.05 73.09,61.05 72.3,60.26 71.77,60.26 71.44,60.59 71.3,60.59 71.2,60.49 71.2,60.16 71.09,60.06 70.89,60.06 70.79,60.16 70.79,60.49 70.69,60.59 70.48,60.59 70.38,60.49 70.38,60.16 70.28,60.06 70.08,60.06 69.98,60.16 69.98,60.49 69.87,60.59 69.67,60.59 69.57,60.49 69.57,60.16 69.47,60.06 69.27,60.06 69.16,60.16 69.16,60.49 69.06,60.59 68.86,60.59 68.76,60.49 68.76,60.16 68.66,60.06 68.45,60.06 68.35,60.16 68.35,60.49 68.25,60.59 68.05,60.59 67.94,60.49 67.94,60.16 67.84,60.06 67.64,60.06 67.54,60.16 67.54,60.51 67.44,60.62 67.23,60.62 67.13,60.51 67.13,60.16 67.03,60.06 66.83,60.06 66.73,60.16 66.73,60.51 66.62,60.62 66.43,60.62 66.33,60.51 66.33,59.8 66.46,59.68 72.32,59.68 73.32,60.67 75.78,60.67 76.01,60.44 78.65,60.44 U30.V32
M_B_DQ28: length 60.4
  TOP w0.102: v1(46.54,73.53) 46.53,73.53 U6.A3
  IN3 w0.089: v2(75.12,64.76) 75.73,64.76 76.64,63.84 76.64,63.05 76.72,62.98 76.93,62.98 77.02,63.07 77.02,63.94 77.11,64.03 77.29,64.03 77.38,63.94 77.38,63.07 77.47,62.98 77.65,62.98 77.73,63.07 77.73,63.94 77.82,64.03 78,64.03 78.09,63.94 78.09,63.06 78.17,62.98 78.38,62.98 78.47,63.07 78.47,63.53 78.56,63.62 78.74,63.62 78.83,63.53 78.83,63.07 78.92,62.98 79.21,62.98 79.31,63.08 79.31,63.94 79.39,64.02 79.61,64.02 79.69,63.94 79.69,63.08 79.79,62.98 79.97,62.98 80.07,63.08 80.07,66.28 79.82,66.53 78.55,66.53 78.17,66.15 73.59,66.15 73.34,65.9 72.35,65.9 71.08,67.17 69.68,67.17 63.57,73.28 51.26,73.28 50.5,74.03 46.67,74.03 46.54,73.9 v1(46.54,73.53)
  BOTTOM w0.089: U30.P29 80.06,63.49 79.73,63.82 79.49,63.82 79.36,63.69 78.91,63.69 78.83,63.61 78.5,63.61 78.12,63.99 77.91,63.99
  BOTTOM w0.102: 77.91,63.99 75.88,63.99 v2(75.12,64.76)
M_B_DQ29: length 61.6
  TOP w0.102: U6.C2 44.93,74.33 44.93,73.86 45.26,73.53 v1(45.74,73.53)
  IN3 w0.089: v1(45.74,73.53) 45.97,73.53 46.37,73.13 46.8,73.13 47.36,73.69 50.36,73.69 51.11,72.93 63.26,72.93 69.37,66.83 70.94,66.83 72.25,65.52 73.45,65.52 73.74,65.81 76.62,65.81 76.71,65.72 76.71,64.84 76.8,64.76 76.97,64.76 77.06,64.84 77.06,65.72 77.15,65.81 77.42,65.81 77.51,65.72 77.51,64.84 77.6,64.76 77.77,64.76 77.86,64.84 77.86,65.71 77.95,65.8 78.13,65.8 78.22,65.71 78.22,64.84 78.31,64.76 78.48,64.76 78.57,64.84 78.57,65.51 78.66,65.59 78.84,65.59 78.93,65.51 78.93,64.84 79.02,64.76 79.2,64.76 79.28,64.84 79.28,66.01 79.37,66.1 79.59,66.1 79.69,66 79.69,64.5 79.56,64.38 76.62,64.38 75.77,65.23 74.32,65.23 v2(73.85,64.76)
  BOTTOM w0.089: 78.29,63.54 78.42,63.41 78.91,63.41 78.99,63.49 U30.P31
  BOTTOM w0.102: v2(73.85,64.76) 74.86,63.74 78.09,63.74 78.29,63.54
M_B_DQ30: length 61.8
  TOP w0.102: U6.C8 v1(44.93,69.53)
  IN3 w0.089: v2(73.04,61.45) 73.37,61.45 73.49,61.58 73.49,61.91 73.32,62.09 72.18,62.09 71.53,62.74 69.29,62.74 64.4,67.63 64.4,67.77 64.06,68.11 63.92,68.11 63.82,68.01 63.82,67.6 63.73,67.51 63.51,67.51 63.41,67.61 63.41,68.21 63.28,68.34 60.23,68.34 59.99,68.59 59.39,68.59 59.32,68.52 59.32,67.84 59.23,67.75 59.09,67.75 58.94,67.91 58.94,68.49 58.84,68.59 58.59,68.59 58.5,68.5 58.5,68.11 58.41,68.02 58.23,68.02 58.15,68.11 58.15,68.5 58.06,68.59 57.88,68.59 57.79,68.5 57.79,68.11 57.7,68.02 57.52,68.02 57.43,68.11 57.43,68.5 57.35,68.59 55.33,68.59 55.23,68.48 55.23,68.13 55.14,68.04 54.91,68.04 54.82,68.13 54.82,68.64 54.72,68.74 52.59,68.74 52.51,68.82 52.51,68.95 52.41,69.05 51.98,69.05 51.88,68.95 51.88,68.82 51.78,68.72 51.45,68.72 51.04,68.31 50.65,68.31 50.57,68.22 50.57,67.91 50.48,67.82 50.3,67.82 50.21,67.91 50.21,68.22 50.12,68.31 49.94,68.31 49.85,68.22 49.85,67.91 49.76,67.82 49.59,67.82 49.5,67.91 49.5,68.22 49.41,68.31 47.69,68.31 47.51,68.13 47.16,68.13 46.93,68.36 46.93,69.02 46.82,69.13 45.56,69.13 45.16,69.53 v1(44.93,69.53)
  BOTTOM w0.089: U30.U31 78.99,61.49
  BOTTOM w0.102: 78.99,61.49 78.67,61.17 76.67,61.17 75.6,62.24 68.55,62.24 68.42,62.11 68.42,61.43 68.55,61.3 68.73,61.3 68.83,61.4 68.83,61.78 68.93,61.89 69.1,61.89 69.2,61.78 69.2,61.4 69.3,61.3 69.47,61.3 69.57,61.4 69.57,61.78 69.67,61.89 69.84,61.89 69.94,61.78 69.94,61.4 70.04,61.3 70.24,61.3 70.37,61.43 70.37,61.73 70.5,61.86 70.68,61.86 70.81,61.73 70.81,61.45 70.93,61.33 71.11,61.33 71.24,61.45 71.24,61.73 71.37,61.86 72.76,61.86 73.04,61.58 v2(73.04,61.45)
