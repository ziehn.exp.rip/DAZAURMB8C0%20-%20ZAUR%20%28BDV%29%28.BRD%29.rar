# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP8_TS+_C: length 4.3
  BOTTOM w0.102: CN2.5 45.72,106.63 46.04,106.31 46.04,104.76 46.29,104.51 46.29,103.41 46.34,103.37 R516.2
USBP8_TS-_C: length 4.4
  BOTTOM w0.102: R515.2 45.86,103.37 45.86,103.37 46.04,103.54 46.04,104.4 45.78,104.66 45.78,106.21 45.22,106.77 CN2.4
USBP10+_BT: length 152.9
  IN1 w0.089: v2(96.64,59.5) 96.64,59.49 96.79,59.35 96.79,59.12 97.03,58.87 98.19,58.87 98.54,59.22 98.54,59.78 98.68,59.93 99.25,59.93 99.78,60.46 100.91,60.46 101.19,60.18 103.44,60.18 107.02,56.6 107.02,47.64 107.71,46.96 107.71,44.58 106.77,43.64 106.77,42.37 106.39,41.99 106.39,37.04 104.74,35.39 104.74,32.53 105.25,32.02 105.86,32.02 106.14,31.74 107.43,31.74 107.66,31.51 107.66,29.04 108.16,28.54 108.16,24.47 111.95,20.69 114.67,20.69 115.09,20.27 115.09,19 117.25,16.84 118.78,16.84 121.23,14.39 161.11,14.39 161.51,13.98 179.16,13.98 181.57,16.39 182.66,16.39 183.93,15.12 184.29,15.12 v1(184.5,15.04)
  BOTTOM w0.102: v1(184.5,15.04) 184.9,15.2 184.95,15.2 186.62,16.88 186.62,17.97 186.57,18.02 186.57,22.18 187.31,22.92 187.31,24.57 186.5,25.39 186.5,28.94 184.72,30.72 184.18,30.72 184.09,30.63 CN11.3 ; U30.Y10 96.13,58.99 v2(96.64,59.5)
USBP10-_BT: length 152.9
  IN1 w0.089: v2(97.23,59.56) 97.13,59.56 97.01,59.45 97.01,59.21 97.13,59.1 98.1,59.1 98.31,59.31 98.31,59.88 98.59,60.16 99.15,60.16 99.69,60.69 101,60.69 101.28,60.41 103.53,60.41 107.25,56.7 107.25,47.74 107.94,47.05 107.94,44.49 107,43.55 107,42.28 106.61,41.9 106.61,36.94 104.96,35.29 104.96,32.63 105.34,32.24 105.95,32.24 106.23,31.96 107.53,31.96 107.88,31.61 107.88,29.14 108.39,28.63 108.39,24.57 112.04,20.92 114.77,20.92 115.31,20.37 115.31,19.1 117.35,17.07 118.87,17.07 121.32,14.62 161.2,14.62 161.61,14.21 179.06,14.21 181.48,16.62 182.76,16.62 184.03,15.35 184.24,15.35 184.52,15.63 v1(184.52,15.68)
  BOTTOM w0.102: v1(184.52,15.68) 184.52,15.56 184.62,15.45 184.84,15.45 186.37,16.98 186.37,17.86 186.32,17.91 186.32,22.29 187.06,23.02 187.06,24.47 186.24,25.28 186.24,28.84 184.61,30.47 184.29,30.47 184.21,30.39 184.21,30.21 184.14,30.13 CN11.5 ; v2(97.23,59.56) 97.35,59.45 97.35,58.89 97.24,58.79 97.11,58.79 U30.Y9
USBP_TYPC+_C: length 16.7
  TOP w0.102: v1(7.93,15.57) 7.58,15.22 RV8.2 ; v1(10.19,12.05) 10.19,11.51 10.29,11.42 10.73,11.42 R418.2
  IN1 w0.089: v1(10.19,12.05) 10.19,11.26 9.99,11.06 9.56,11.06 8.95,11.67 8.95,12.5 7.43,14.03 7.43,15.61 7.59,15.77 7.72,15.77 v1(7.93,15.57) 8.02,15.66 8.5,15.66 9.1,16.27 9.1,16.87 8.23,17.74 7.66,17.74 6.92,17 6.92,16.5 6.72,16.3 CN15.B6
  BOTTOM w0.102: CN15.A6 7.84,15.65 v1(7.93,15.57)
USBP_TYPC-_C: length 16.8
  TOP w0.102: v1(7.93,16.21) 8.26,15.87 RV9.2 ; R419.2 10.73,11.16 10.29,11.16 10.19,11.06 v1(10.19,10.53)
  IN1 w0.089: v1(10.19,10.53) 9.89,10.83 9.47,10.83 8.72,11.58 8.72,12.41 7.2,13.93 7.2,15.7 7.5,16 7.72,16 v1(7.93,16.21) 8.25,15.89 8.4,15.89 8.88,16.36 8.88,16.78 8.14,17.51 7.75,17.51 7.15,16.91 7.15,16.4 6.82,16.07 6.67,16.07 6.59,16 6.59,15.51 6.44,15.35 6.27,15.35 CN15.B7
  BOTTOM w0.102: CN15.A7 7.87,16.15 v1(7.93,16.21)
USBPWRD2:
  vias: v1(214.03,29.63) v1(214.69,29.96) v1(214.69,29.32) v1(214.69,28.69) v1(214.69,28.05)
VA: length 179.9
  TOP w0.305: v1(136.64,36.1) 136.64,36.28 136.1,36.82 v1(135.98,36.82) 134.86,36.82 134.68,36.64 133.16,36.64 133.06,36.54 132.5,36.54 131.81,37.23 PR60.1 131.25,36.8 131.25,36.05 130.62,35.42 127.82,35.42 127.44,35.04 126.93,35.04 126.57,34.68 PD2.2
  TOP w0.508: PC27.1 41.96,115.44 41.08,116.32 v1(41.08,116.7)
  IN1 w0.305: v1(136.64,36.1) 136.61,36.13 136.61,36.28 135.97,36.92 135.97,38.19 135.34,38.83 131.71,38.83 130.5,40.04 130.5,40.58 130.19,40.88 129.94,40.88 125.31,45.51 125.31,70.7 124.14,71.87 114.49,71.87 110.48,75.88 110.48,79.41 108.22,81.67 108.22,85.31 106.97,86.56 106.97,88.34 105.22,90.09 v1(105.22,90.28)
  IN2 w0.305: v1(105.22,90.28) 105.22,89.9 104.96,89.65 104.13,89.65 102.52,91.25 99.75,91.25 97.17,93.84 94.68,93.84 94.58,93.94 93.31,93.94 93.03,94.22 88.33,94.22 85.53,91.43 82.74,91.43 81.21,92.95 75.07,92.95 68.01,100.01 68.01,102.6 66.84,103.77 66.84,103.87 65.01,105.7 65.01,107.38 63.94,108.44 63.94,110.6 60.77,113.78 59.62,113.78 56.83,116.57 56.83,119.49 55.69,120.64 51.88,120.64 50.61,121.91 48.39,121.91 44.42,117.94 42.07,117.94 41.46,117.33 v1(41.08,117.33)
  BOTTOM w0.305: PR321.1 136.64,35.84 v1(136.64,36.1)
  vias: v1(19.87,116.6) v1(19.87,115.96) v1(20.51,116.6) v1(20.51,115.96) v1(21.14,116.6) v1(21.14,115.96) v1(21.78,116.6) v1(21.78,115.96) v1(41.08,119.95) v1(41.08,119.32) v1(41.08,118.68)
VA2: length 147.7
  IN3 w0.203: v1(133.44,36.08) 133.21,36.31 132.4,36.31 132.07,36.64 130.64,36.64 128.3,38.98 125.28,38.98 122.57,41.69 122.57,63.6 123.94,64.97 123.94,67.42 122.92,68.44 122.92,71.11 122.42,71.61 117.85,71.61 113.5,75.96 113.5,77.25 112.2,78.55 110.53,78.55 108.11,80.96 107.49,80.96 105.5,82.95 105.5,83.82 99.36,89.95 97.1,89.95 95.37,91.68 93.79,91.68 92.77,92.7 92.77,92.98 91.78,93.97 86.68,93.97 85.33,95.31 77.73,95.31 74.15,98.88 74.15,104.02 71.03,107.15 69.66,107.15 66.76,110.04 65.19,110.04 61.84,113.4 58.99,113.4 54.88,117.51 43.98,117.51 43.75,117.28 v1(43.29,117.28)
  BOTTOM w0.203: v1(133.44,36.08) 133.44,35.63 PR319.1
  vias: v1(43.32,120.99)
VADJ1: length 6.1
  TOP w0.102: R67.1 C52.1 59.32,107.8 59.18,107.94 R70.2 58.47,107.94 58.23,108.19 v1(58.23,108.42) 57.82,108.83 v1(57.59,108.83)
  BOTTOM w0.102: v1(58.23,108.42) 57.59,107.78 56.82,107.78 56.72,107.68 CN2.27
VGA_AC_BATT: length 23.9
  TOP w0.102: v1(127.06,121.53) 126.93,121.4 D3.2 126.39,120.55 126.17,120.76 R36.1 R31.2
  IN1 w0.089: v1(127.06,121.53) 127.06,121.02 125.79,119.75 121.98,119.75 121.22,118.99 119.06,118.99 116.34,116.27 116.09,116.27 113.09,113.27 113.09,111.52 v1(112.53,110.96)
  BOTTOM w0.102: v1(112.53,110.96) 112.44,110.96 U25.AA34
VGA_ALERT: length 14.8
  TOP w0.102: v1(115.76,111.75) 116.01,111.75 116.5,112.23 116.5,115.12 118.26,116.88 119.49,116.88 120.97,118.35 123.38,118.35 123.76,118.73 TP8.1 123.86,119.59 R39.2
  BOTTOM w0.102: U25.R37 115.68,111.75 v1(115.76,111.75)
VGA_RSTB: length 56
  TOP w0.102: v1(91.88,93.13) 92.21,93.46 92.52,93.46 92.77,93.71 U3.2
  IN1 w0.089: v1(91.88,93.13) 91.88,91.68 93.13,90.44 93.13,88.66 95.18,86.6 95.18,83.68 v1(95.44,83.43)
  IN3 w0.089: v1(95.44,83.43) 93.79,81.77 93.79,76.57 93.53,76.31 93.53,73.39 92.52,72.38 92.52,71.11 92.39,70.98 92.39,66.81 92.04,66.46 92.04,64.86 92.57,64.32 92.57,58.19 92.37,57.98 92.37,50.74 94.4,48.7 94.4,44.08 v2(93.97,43.65)
  BOTTOM w0.102: U30.AV13 93.62,43.99 v2(93.97,43.65)
VGPU_CORE_PG: length 133.5
  IN1 w0.089: v1(94.25,84.85) 94.25,85.38 92.52,87.11 92.52,88.99 85.43,96.07 80.48,96.07 76.9,99.66 76.9,103.62 76.39,104.13 76.39,105.19 v1(76.01,105.57)
  IN2 w0.089: v1(94.25,84.85) 94.33,84.94 100.76,84.94 101.41,84.29 102.12,84.29 102.76,84.92 109.05,84.92 109.32,84.66 110.84,84.66 111.95,83.55 111.95,82.41 112.58,81.77 115.28,81.77 115.79,82.28 122.74,82.28 124.83,80.2 128.85,80.2 129.89,81.24 131.92,81.24 133.46,79.7 135.11,79.7 136.53,78.28 138.69,78.28 140.88,76.1 140.88,72.98 141.27,72.59 141.27,67 144.4,63.87 146.62,63.87 147.89,62.6 148.3,62.6 149.06,61.84 v1(149.06,61.56)
  IN2 w0.152: v1(63.18,117.46) 63.64,117.92 65.9,117.92 66.86,116.95 66.86,113.68 67.65,112.89 69.37,112.89 71.12,111.14 71.12,109.93 71.94,109.1 73.82,109.1 74.48,108.44 74.48,107.1 v1(76.01,105.57)
  BOTTOM w0.102: U23.1 62.8,120.19 62.93,120.07 62.93,119.57 63.16,119.34 63.16,117.49 v1(63.18,117.46)
  BOTTOM w0.152: PR179.1 74.71,107.05 74.71,105.9 74.87,105.75 75.47,105.75 75.65,105.57 v1(76.01,105.57) 76.44,105.14 PR193.2
  BOTTOM w0.203: PR253.1 149.51,61.23 149.19,61.56 v1(149.06,61.56)
VGPU_CORE_SENSE: length 27.4
  IN2 w0.254: v1(103.89,99.84) 103.69,99.65 103.69,98.28 102.55,97.14 101.92,97.14 100.65,95.87 97.72,95.87 95.57,98.03 93.79,98.03 92.14,96.38 90.36,96.38 89.09,95.11 88.2,95.11 85.79,92.7 84.32,92.7 83.77,92.15 v1(83.74,92.15)
  BOTTOM w0.152: v1(83.74,92.15) 83.74,92.12 84.02,91.85 PR208.2
  BOTTOM w0.254: v1(103.89,99.84) 104.4,99.32 U25.AR13
VL: length 84.8
  TOP w0.102: v1(60.34,13.3) 60.16,13.47 54.82,13.47 54.54,13.19 48.98,13.19 48.47,12.69 v1(46.8,12.69) 43.88,15.61 43.88,17.18 44.21,17.51 44.71,17.51 45.69,18.48 PR109.1
  IN3 w0.089: v1(60.34,13.3) 74.33,13.3 74.94,13.91 77.2,13.91 79.03,15.73 80.28,15.73 84.39,19.85 93.1,19.85 94.04,18.91 102.04,18.91 106.17,23.04 107.57,23.04 108.37,23.84 108.37,27.27 111.42,30.31 111.92,30.31 v1(112.33,30.72)
  BOTTOM w0.102: v1(112.33,30.72) 112.2,30.85 PR326.1
VMON: length 2.6
  TOP w0.102: R373.1 23.05,16.62 22.95,16.72 R374.2 22.32,16.72 22.29,16.75 21.84,16.75 21.45,16.36 U19.17
VQQD_VPPSNS: length 3.8
  TOP w0.229: PU1.12 v1(65.79,123.44)
  BOTTOM w0.152: PR116.2 64.2,125.59 v1(65.21,124.57) 65.79,123.99 65.79,123.9 65.79,123.9 v1(65.79,123.45)
VREF_PINSET_CPU: length 15.2
  TOP w0.203: v1(149.67,53.53) 149.64,53.5 PU3.15 ; PR56.1 153.05,49.84 153.69,50.48 v2(154.11,50.48) 154.29,50.66 154.29,51.33 v1(153.88,51.74) PR45.1
  BOTTOM w0.203: PR277.1 153.36,50.3 PR274.2 153.82,50.3 154,50.48 v2(154.11,50.48) 154.31,50.68 154.31,51.05 154.16,51.42 153.73,51.89 153.73,52.44 152.98,53.19 PR262.1 152.23,53.11 151.65,53.11 151.62,53.14 151.05,53.14 150.58,52.67 ; 150.58,52.67 150.58,53.05 150.33,53.3 PR260.1 149.97,53.62 149.88,53.53 v1(149.67,53.53) 149.52,53.53 149.44,53.61 PR261.1 ; 150.58,52.67 PR264.1
VREF_PINSET_GPU: length 22.1
  IN2 w0.203: v1(65.48,116.93) 65.1,116.56 65.1,115.94 64.96,115.79 64.96,114.31 65.85,113.42 65.85,111.11 v1(65.72,110.98)
  BOTTOM w0.203: PR143.1 67.59,119.05 67.56,119.03 PR144.1 66.88,118.8 66.51,118.43 66.5,118.43 66.1,118.03 PR149.1 66.1,117.87 65.63,117.4 65.63,117.08 v1(65.48,116.93) 65.97,116.93 PR152.1 ; PR178.2 PR177.2 67.67,108.6 67.3,108.97 67.29,108.97 66.89,109.37 PR175.1 65.72,110.55 v1(65.72,110.98) 66.51,111.78 68.18,111.78 68.66,112.25 PR169.1 68.81,112.41 69.47,112.41 70.4,111.48 PU8.15
VREFC_A0:
  vias: v1(140.38,116.95) v1(141.06,116.19)
VREFC_A1:
  vias: v1(140.75,80.68)
VREFD1_A0:
  vias: v1(147.99,112.68) v1(148.07,113.32)
VREFD1_A1:
  vias: v1(131.58,88.45)
VREFD2_A0:
  vias: v1(131.41,111.9)
VREFD2_A1: length 5.9
  IN1 w0.508: v1(147.39,86.19) 147.39,84.56 147.84,84.11 147.84,81.28 v1(147.28,80.73)
VRM_PWRGD: length 89.9
  TOP w0.102: R201.1 115.1,46.44 115.64,46.98 R200.2 116.11,47.41 116.61,47.9 R202.2 116.81,47.9 117.18,47.53 117.41,47.53 117.46,47.48 118.94,47.48 119.31,47.1 120.33,47.1 120.84,46.6 v1(120.97,46.6) ; v1(144.71,28.69) 144.71,28.31 145.63,27.4 145.63,21.84 145.96,21.51 145.96,14.12 145.45,13.6 145.45,11.83 145.93,11.34 151.95,11.34 v1(152.33,11.72) 152.33,13.06 152.26,13.13 D18.1 ; v1(144.52,45.83) 144.14,46.21 139.97,46.21 137.15,49.03 PR57.2 137.15,49.46 137.15,49.46 PR52.1
  IN1 w0.089: v1(144.71,28.69) 144.71,29.07 142.87,30.91 142.87,31.78 145.48,34.39 145.48,35.5 146.75,36.77 146.75,43.8 144.71,45.83 v1(144.52,45.83)
  IN2 w0.089: v1(120.97,46.6) 120.97,46.85 122.74,48.63 128.2,48.63 129.32,47.51 135.44,47.51 136.1,46.85 141.79,46.85 142.81,45.83 v1(144.52,45.83)
VRON: length 80.3
  TOP w0.102: R369.1 182.56,17.26 182.47,17.36 U15.69 180.53,17.36 180.43,17.26 179.73,17.26 179.47,17.51 179.08,17.51 178.45,18.15 177.61,18.15 176.95,18.81 176.95,19.6 175.51,21.04 173.24,21.04 172.27,22.01 172.27,25.39 170.29,27.37 169.72,27.37 169.08,28 168.39,28 167.57,28.82 167.09,28.82 166.13,29.78 165.14,29.78 164.02,30.9 164.02,33.18 165.06,34.22 165.44,34.22 165.44,34.23 v1(165.47,34.23) ; PR36.1 144.47,59.55 v1(144.71,59.8)
  IN3 w0.089: v1(144.71,59.8) 145.02,59.8 146.67,61.45 148.27,61.45 148.65,61.07 149.49,61.07 151.06,59.5 151.06,56.83 152.72,55.18 152.72,52.95 153.45,52.21 153.45,48.93 150.18,45.66 150.18,43.47 150.66,42.99 150.66,38.16 152.03,36.79 154.12,36.79 156.66,34.25 156.89,34.25 156.92,34.23 v1(165.47,34.23)
VSEN_CPU: length 1.8
  TOP w0.203: v1(147.37,50.12) 147.35,50.14 PU3.8
  BOTTOM w0.203: PR272.1 147.48,50.23 v1(147.37,50.12)
VSTBY_FSPI: length 2.8
  TOP w0.203: U15.106 176.02,30.91 175.7,31.23 R264.2
  TOP w0.508: R264.2 R265.1
VSYNC: length 17.9
  TOP w0.102: v1(113.63,111.7) 114.29,112.36 114.29,113.88 119.09,118.68 120.33,118.68 120.71,119.06 121.12,119.06 121.83,119.77 121.83,122.64 122.13,122.94 122.39,122.94 122.49,123.05 R12.2 R13.2
  BOTTOM w0.102: v1(113.63,111.7) 113.25,111.32 U25.W35
WCKA0_0: length 33.7
  IN1 w0.089: v1(143.98,108.6) 144.2,108.6 144.29,108.51 144.29,108.27 142.78,106.76 139.35,106.76 138.82,106.23 138.82,104.89 136.85,102.92 132.02,102.92 130.81,104.13 124.72,104.13 123.12,105.72 123.12,108.44 122.26,109.31 120.69,109.31 120.6,109.4 120.6,109.53 v1(120.83,109.77)
  BOTTOM w0.102: U25.D33 120.96,110.32 120.74,110.1 120.74,109.87 v1(120.83,109.77) ; v1(143.98,108.6) 144.24,108.6 144.38,108.46 VRAM1.D4
WCKA0_1: length 17.9
  IN1 w0.089: v1(135.98,108.58) 136.29,108.89 136.29,109.38 135.54,110.13 134.9,110.13 133.67,111.37 125.25,111.37 124.9,111.01 124.9,110.89 v1(125.19,110.6)
  BOTTOM w0.102: U25.A34 122.85,110.98 122.85,111.09 122.95,111.19 123.1,111.19 123.2,111.1 123.42,111.1 123.68,111.37 124.55,111.37 124.84,111.08 124.84,110.67 124.91,110.6 v1(125.19,110.6) ; v1(135.98,108.58) 136.27,108.58 136.38,108.47 VRAM1.P4
WCKA0B_0: length 33.7
  IN1 w0.089: v1(144.78,108.6) 144.47,108.29 144.47,108.2 142.85,106.58 139.42,106.58 139,106.16 139,104.82 136.92,102.74 131.95,102.74 130.74,103.95 124.64,103.95 122.95,105.65 122.95,108.37 122.18,109.14 120.61,109.14 120.42,109.33 120.42,109.53 v1(120.18,109.76)
  BOTTOM w0.102: VRAM1.D5 144.39,108.98 v1(144.78,108.6) ; v1(120.18,109.76) 120.4,109.99 U25.E33
WCKA0B_1: length 18.3
  IN1 w0.089: v1(124.43,110.6) 124.72,110.89 124.72,111.09 125.18,111.54 133.74,111.54 134.97,110.31 135.61,110.31 136.47,109.45 136.47,108.89 v1(136.78,108.58)
  BOTTOM w0.102: v1(124.43,110.6) 124.63,110.8 124.63,110.99 124.46,111.16 123.77,111.16 123.5,110.89 123.4,110.89 123.08,110.57 122.83,110.57 122.53,110.87 U25.B34 ; v1(136.78,108.58) 136.78,108.58 VRAM1.P5
WCKA1_0: length 26.5
  IN3 w0.089: v1(136.78,90.99) 136.47,90.68 136.27,90.68 135.95,90.36 135.95,89.9 135.82,89.78 134.3,89.78 133.69,90.38 133.69,90.48 133.67,90.51 133.67,90.99 132.54,92.11 132.54,94.03 132.33,94.24 132.33,97.54 131.75,98.12 131.75,99.85 130.35,101.26 130.35,101.3 129.81,101.85 129.07,101.85 129.03,101.8 128.64,101.8 128.6,101.85 127.31,101.85 126.85,102.31 125.97,102.31 125.43,102.85 125.42,102.97 v1(125.69,103.24)
  BOTTOM w0.102: v1(125.69,103.24) 125.54,103.24 125.31,103.47 125.31,103.62 125.09,103.85 124.09,103.85 123.71,104.23 123,104.23 U25.A22 ; VRAM2.D4 136.38,91.08 136.47,90.99 v1(136.78,90.99)
WCKA1_1: length 28.1
  IN1 w0.089: v1(144.78,90.99) 144.47,90.68 144.27,90.68 144.03,90.44 144.03,90.18 143.4,89.55 139.03,89.55 138.75,89.83 138.75,90.41 138.36,90.79 137.98,90.79 136.58,92.19 134.93,92.19 133.62,93.51 128.51,93.51 128.43,93.43 v1(128.06,93.43)
  BOTTOM w0.102: U25.A8 123.47,96.57 123.76,96.29 124.61,96.29 126.24,94.65 128.5,94.65 128.64,94.52 128.64,93.65 128.42,93.43 v1(128.06,93.43) ; v1(144.78,90.99) VRAM2.P4
WCKA1B_0: length 26.6
  IN3 w0.089: v1(124.98,103.24) 125.25,102.97 125.25,102.91 125.25,102.85 125.25,102.77 125.84,102.18 125.89,102.13 126.77,102.13 127.24,101.67 128.53,101.67 128.57,101.63 129.1,101.63 129.14,101.67 129.73,101.67 130.17,101.23 130.17,101.18 131.58,99.78 131.58,98.04 132.15,97.46 132.15,94.17 132.36,93.96 132.36,92.04 133.49,90.91 133.49,90.43 133.51,90.41 133.51,90.31 134.23,89.6 135.9,89.6 136.13,89.83 136.13,90.29 136.34,90.51 136.47,90.51 v1(136.78,90.19)
  BOTTOM w0.102: v1(124.98,103.24) 125.11,103.36 125.11,103.54 125,103.64 124.01,103.64 123.62,104.03 123.15,104.03 123.07,103.95 122.83,103.95 U25.B21 ; v1(136.78,90.19) VRAM2.D5
WCKA1B_1: length 28.9
  IN1 w0.089: v1(144.78,90.19) 144.47,90.51 144.34,90.51 144.21,90.37 144.21,90.1 143.47,89.37 138.95,89.37 138.57,89.75 138.57,90.33 138.29,90.61 137.91,90.61 136.51,92.02 134.86,92.02 133.54,93.33 128.67,93.33 128.56,93.22 v1(128.56,92.92)
  BOTTOM w0.102: v1(144.78,90.19) VRAM2.P5 ; U25.B9 122.84,97.12 123.19,96.78 123.55,96.78 123.84,96.49 124.69,96.49 126.33,94.86 128.59,94.86 128.84,94.6 128.84,93.57 128.56,93.29 v1(128.56,92.92)
WEA0B: length 26.8
  TOP w0.102: 120,108.24 119.44,107.68 v1(119.26,107.68)
  TOP w0.127: v1(138.38,114.18) 137.79,113.6 136.34,113.6 136.22,113.72 136.22,114.31 136.07,114.46 135.84,114.46 135.71,114.34 135.71,113.72 135.58,113.6 133,113.6 132.87,113.72 132.87,114.53 132.75,114.65 132.49,114.65 132.36,114.53 132.36,113.72 132.24,113.6 131.61,113.6 129.07,111.06 123.51,111.06 123.02,110.58 123.02,109.51 121.75,108.24 120,108.24
  BOTTOM w0.102: U25.G29 119.6,108.02 v1(119.26,107.68)
  BOTTOM w0.127: v1(138.38,114.18) 138.78,114.58 VRAM1.L12
WEA1B: length 28
  TOP w0.102: v1(120.76,97.7) 120.76,97.38 120.99,97.15 122.5,97.15 124.93,94.73
  TOP w0.127: v1(138.43,85.39) 138.43,85.74 138.68,85.99 139.46,85.99 139.61,86.15 139.61,86.52 139.48,86.65 137.25,86.65 137.09,86.8 137.09,87.49 136.92,87.67 135.95,87.67 135.49,88.12 134.3,88.12 134.05,88.38 132.7,88.38 131.38,89.7 131.38,90.55 129.87,92.06 127.49,92.06 124.93,94.63 124.93,94.73
  BOTTOM w0.102: U25.D11 121.2,98.14 v1(120.76,97.7)
  BOTTOM w0.127: v1(138.43,85.39) 138.78,85.04 VRAM2.G12
WLAN_PLT_RST#: length 18.2
  TOP w0.102: D17.2 D16.2 198.67,16 R747.2 197.47,15.63 197.6,15.51 198.08,15.51 198.59,14.99 R397.1 198.59,14.24 v1(198.19,13.84) 198.16,13.8 198.16,13.24 198.05,13.13 C502.2 197.15,13.13 196.89,13.4 196.89,13.99 196.6,14.28 195.17,14.28 194.85,14.59 v1(194.85,14.72)
  BOTTOM w0.102: CN11.52 191.6,18.38 191.76,18.22 192.16,18.22 192.47,17.92 193.31,17.92 193.53,17.69 193.53,17.21 193.81,16.93 193.81,15.7 194.8,14.72 v1(194.85,14.72)
WLAN_WAKE#: length 21.6
  TOP w0.102: v1(191.96,14.72) 192.11,14.56 R403.2 192.11,13.55 192.21,13.45 R409.1 192.62,13.17 192.81,12.97 Q24.1
  IN2 w0.089: v1(185.05,17.26) 185.48,16.83 186.05,16.83 187.06,17.83 187.06,19.13 188.43,20.5 190.39,20.5 191.58,19.3 193.22,19.3 193.74,18.78 193.74,16.5 v1(191.96,14.72)
  BOTTOM w0.102: CN11.55 184.08,17.63 184.16,17.71 184.6,17.71 v1(185.05,17.26)
WLANPWR_EN: length 26.4
  TOP w0.102: v1(178.01,11.52) 179.74,11.52 180.4,12.18 184.21,12.18 184.28,12.24 184.28,13.13 184.9,13.75 184.9,14.51 185.05,14.67 185.58,14.67 185.81,14.9 185.81,15.4 185.58,15.64 U20.4 ; v1(166.66,13.45) 166.93,13.18 167.83,13.18 168.02,13.37 U15.35
  BOTTOM w0.102: v1(178.01,11.52) 177.25,12.28 176.55,12.28 175.84,11.57 168.54,11.57 v1(166.66,13.45)
WRST#: length 11.9
  TOP w0.102: D14.2 158.18,19.87 158.86,20.56 158.86,21.27 158.69,21.44 R331.1 159.71,20.94 161.86,20.94 162.85,21.93 C427.1 163.36,21.93 164.38,22.96 U15.14
XTAL1: length 2.3
  TOP w0.102: R64.2 44.84,108.64 U2.28
XTAL2: length 2
  TOP w0.102: U2.29 44.44,108.86 44.64,109.06 R63.1
XTALIN: length 14.9
  TOP w0.102: v1(104.63,118.48) 104.33,118.78 104.33,119.54 104.43,119.65 105.03,119.65 105.13,119.75 105.13,120.15 105.03,120.26 104.43,120.26 104.33,120.36 104.33,120.76 104.46,120.89 105.34,120.89 105.6,121.14 R27.1
  BOTTOM w0.102: R480.1 104.36,118.91 104.63,118.63 v1(104.63,118.48) 104.63,118.27 104.23,117.87 101.59,117.87 100.39,116.67 100.39,115.43 100.19,115.23 100.19,114.19 U25.BA39
XTALOUT: length 15.2
  TOP w0.102: v1(98.87,116.19) 99.38,116.19 103.72,120.53 103.72,122.19 104.58,123.05 R18.2 105.6,123.05 TP3.1
  BOTTOM w0.102: v1(98.87,116.19) 98.99,116.06 98.99,115.05 99.33,114.72 99.33,114.46 100.49,113.3 100.83,113.3 101.16,113.62 U25.AY39
ZQ_A0: length 6.4
  BOTTOM w0.102: R457.2 137.61,120.25 v1(138.18,119.68) 139.38,118.48 139.38,117.08 139.91,116.55 139.91,115.85 VRAM1.J13
ZQ_A1: length 4.5
  BOTTOM w0.102: R555.2 139.89,82.16 140.02,82.29 140.02,83.84 140.37,84.19 VRAM2.J13
N301427: length 4.2
  TOP w0.102: R40.2 124.87,120.54 124.66,120.75 C2.1 124.66,121.64 124.52,121.78 R21.1 124.65,122.32 125.26,122.92 v1(125.26,123.94)
N9111136: length 1.5
  TOP w0.102: R7.1 R1.2 v1(120.18,126.22)
N9111150: length 0.8
  TOP w0.102: R20.2 R30.1
N17002655: length 3.1
  BOTTOM w0.102: U35.39 204.54,23 205.29,22.24 205.29,21.42 205.4,21.31 C670.2
N17002661: length 7.1
  BOTTOM w0.102: C666.2 208.75,21.09 208.49,20.84 207.1,20.84 v1(206.97,20.97) 206.74,21.2 206.74,23.07 206.46,23.35 205.9,23.35 205.62,23.08 205.46,23.08 205.33,23.2 U35.37
N17002676: length 3.9
  BOTTOM w0.102: U35.34 206.82,25.26 207.35,24.73 C655.1 207.84,25.01 208.19,25.36 208.67,25.36 209.18,25.87 v1(209.26,25.87)
N17002678: length 2.1
  BOTTOM w0.102: U35.19 203.33,30.41 203.39,30.47 C640.1
N17002722: length 3.5
  TOP w0.102: v1(201.61,24.17) 201.51,24.07 R318.2 R317.2 200.95,23.1 200.62,22.77 v1(200.37,22.77)
  BOTTOM w0.102: U35.48 200.94,23.26 200.44,22.77 v1(200.37,22.77)
N17002952: length 4.7
  BOTTOM w0.102: U35.7 198.52,26.86 C652.1 197.94,26.52 197.75,26.71 196.89,26.71 196.33,26.15 v1(196.33,26)
N17002968: length 3.1
  BOTTOM w0.102: U35.11 199.56,28.46 198.94,29.07 198.56,29.07 198.31,28.82 R656.1 R655.1
N17002995: length 3.7
  BOTTOM w0.102: R654.1 198.45,30.79 198.52,30.86 C643.1 198.92,29.88 v1(199.17,29.63) 199.35,29.45 199.35,29.04 199.54,28.86 U35.12
N17003129: length 3.4
  BOTTOM w0.102: C666.1 208.08,23.86 207.55,23.86 207.25,24.17 207.25,24.5 206.89,24.86 U35.35
N17003186: length 2.8
  BOTTOM w0.203: 204.21,31.67 203.83,31.29 v1(203.83,31.04) 203.73,30.94 U35.20
  BOTTOM w0.381: 204.21,31.67 204.57,32.03 R645.1
N17004316: length 2.7
  BOTTOM w0.102: Q38.3 195.24,19.31 195.12,19.44 D33.1
N17046941: length 3.8
  TOP w0.102: v1(106.23,22.47) 106.23,22.36 105.04,21.17 PR106.1 104.22,21.17 103.54,20.48 v1(103.54,20.26)
N17047007:
  vias: v1(46.98,120.94)
N17047009: length 2.2
  BOTTOM w0.198: PR336.2 132.16,28.31 133.03,28.31 133.42,28.7 PU14.20
N17047028: length 2.8
  BOTTOM w0.198: PR339.2 132.06,27.88 133.08,27.88 133.82,28.62 PU14.19
N17047083: length 2
  TOP w0.102: PR108.1 v1(101.53,20.31)
  BOTTOM w0.305: PJ18.5 101.45,20.39 v1(101.53,20.31)
N17047104: length 14.4
  TOP w0.508: PR92.1 130.35,27.65 129.64,28.36 129.01,28.36 127.99,27.34 121.41,27.34 PC108.1
  BOTTOM w0.152: PR342.2 117.77,26.02 116.62,24.88 115.57,24.88 PR344.1
  vias: v1(118.71,27.47) v3(115.51,27.65) v3(115.52,26.91) v3(116.29,27.65) v3(116.3,26.92) v3(117.05,27.65) v3(117.06,26.92) v3(117.84,27.65) v3(117.84,26.92)
N17047112: length 164.5
  TOP w0.508: v1(45.15,120.51) 45.4,120.26 45.4,116.44 45.02,116.06 PQ3.4 44.16,116.06 v1(43.5,115.4) PC27.2 ; PR352.2 PC10.2 41.5,121.74 v1(42.02,121.22)
  IN3 w0.203: v1(134.07,36.05) 134.07,36.28 133.67,36.69 132.52,36.69 132.27,36.94 130.76,36.94 128.35,39.36 125.44,39.36 122.87,41.93 122.87,63.36 124.27,64.76 124.27,67.52 123.23,68.57 123.23,71.23 122.54,71.91 117.99,71.91 113.85,76.05 113.85,77.33 112.33,78.85 110.67,78.85 108.26,81.27 107.61,81.27 105.8,83.08 105.8,83.94 99.49,90.26 97.23,90.26 95.5,91.98 93.99,91.98 93.15,92.82 93.15,93.03 91.91,94.27 86.8,94.27 85.46,95.62 77.85,95.62 74.46,99.01 74.46,104.15 71.16,107.45 69.78,107.45 66.89,110.35 65.31,110.35 61.89,113.78 59.12,113.78 55.08,117.82 43.16,117.82 42.78,117.44 42.78,116.98 43.5,116.27 v1(43.5,115.4)
  BOTTOM w0.203: PR320.1 134.58,35.48 134.07,35.98 v1(134.07,36.05)
  BOTTOM w0.508: v1(45.15,120.51) 44,120.51 43.29,121.22 v1(42.02,121.22)
N17047116: length 3.6
  TOP w0.508: PR352.1 39.47,121.61 39.74,121.35 40.75,121.35 41.59,120.51 PQ1.4
N17047335: length 3.5
  BOTTOM w0.508: PC277.1 126.87,28.63 126.62,28.37 125.98,28.37 v1(125.75,28.14) 124.98,27.37 124.34,27.37 PR340.2
N17047399: length 2.5
  BOTTOM w0.102: PC271.2 v1(128.92,33.54)
  BOTTOM w0.559: PR328.2 128.86,31.12 128.86,32.48 PC271.2
N17047425: length 1.3
  TOP w0.102: PR107.1 103.56,21.26 103.79,21.49 103.79,21.63 v1(104.34,22.19)
  vias: v1(104.27,22.87)
N17047601: length 10.9
  TOP w0.508: PR85.1 130.1,29.6 129.04,29.6 127.42,27.98 v1(122.45,27.98) 121.85,28.57 PC108.2
N17398787: length 2.6
  BOTTOM w0.198: PR317.2 135.32,35.44 135.05,35.16 135.05,34.34 134.62,33.91 PU14.5
N17424918: length 1.7
  BOTTOM w0.198: PU14.11 136.85,31.18 137.54,31.86 PR325.2
N17424920: length 1.5
  BOTTOM w0.198: PU14.12 136.92,30.78 137.38,31.24 PR327.2
N17424921: length 4.2
  BOTTOM w0.102: PR322.2 137,35.19 137.48,35.67 v1(137.83,35.67)
  BOTTOM w0.198: PR322.2 137,34.44 136.58,34.02 135.72,34.02 135.42,33.73 PU14.7
N17424925: length 2
  BOTTOM w0.198: PU14.9 136.67,31.98 136.85,32.16 136.85,32.54 137.46,33.15 PR324.2
N17424950: length 2.4
  BOTTOM w0.198: PR338.2 PR337.2 135.84,28.14 135.42,28.55 PU14.15
N17661815: length 2.1
  BOTTOM w0.198: PR323.2 137.36,33.86 v1(136.84,33.34) 136.84,33.08 136.22,32.46 PU14.8
N19521323: length 1.6
  TOP w0.203: PR73.1 143.75,32.82 143.08,32.14 PQ10.3
N19521733: length 3.3
  TOP w0.102: PR88.2 v1(142.3,29.17)
  TOP w0.254: PR86.2 PR87.1 PR88.2 141.54,29.58 141.53,29.59 PQ10.2
N19549602: length 8
  TOP w0.102: v1(49.44,17.74) 49.62,17.56 PR112.1
  TOP w0.203: 47.66,16.16 47.15,16.16 46.68,15.68 PR115.2 ; 47.66,16.16 47.66,16.45 48.28,17.07 PQ11.2 49.1,17.07 49.29,16.88 PR112.1 ; 47.66,16.16 47.71,16.12 PR114.2
N25369936: length 5.5
  TOP w0.102: R394.2 71.31,15.35 70.7,15.96 R376.2 70.7,16.85 v1(70.12,17.44) 69.78,17.77 69.78,18.4 70.17,18.78 70.54,18.78 70.67,18.64 Q20.1
N25369945: length 3.1
  TOP w0.102: Q20.4 72.31,17.34 72.11,17.14 72.11,16.58 72.43,16.27 R377.2 72.61,15.89 72.45,15.73 R395.2
N26277307: length 37.4
  IN3 w0.127: v1(127.05,49.51) 128.46,49.51 129.88,48.09 135.6,48.09 136.17,47.52 142.62,47.52 144.52,49.42 146.27,49.42 v1(146.83,48.86)
  BOTTOM w0.102: PC240.1 146.61,47.06 v1(147.03,46.65)
  BOTTOM w0.203: v1(127.05,49.51) 127.05,49.56 126.65,49.96 123.66,49.96 121.45,52.17 121,52.17 120.71,52.46 PR263.2 120.33,52.72 120.05,52.44 PR265.1 ; PC233.1 146.7,51.07 PR272.2 146.7,50.48 146.86,50.31 146.86,48.93 146.83,48.9 v1(146.83,48.86) 147.13,48.56 147.13,47.97 146.62,47.46 PC240.1 PR289.1
N26277311: length 0.9
  TOP w0.203: PR44.1 PR45.2
N26277331: length 0.9
  TOP w0.203: PR50.2 PR49.1
N26277333: length 0.9
  TOP w0.203: PR56.2 PR55.1
N26277349: length 27.5
  IN3 w0.127: v1(129.52,49.39) 130.31,48.6 135.85,48.6 136.47,47.98 142.4,47.98 145.33,50.91 148.38,50.91 149.1,50.19 150.85,50.19 151.79,51.13 v2(151.81,51.13)
  BOTTOM w0.203: PR267.1 151.84,51.75 151.84,51.15 v2(151.81,51.13) 151.43,50.75 PR273.2 ; v1(129.52,49.39) 129.57,49.39 PR284.1
N26277351: length 1.2
  BOTTOM w0.203: PR270.2 152.43,51.56 PR267.2
N26277353: length 1.7
  BOTTOM w0.203: PR273.1 151.44,49.7 152.22,49.7 PR277.2
N26277375: length 1.7
  BOTTOM w0.102: PC231.1 149.25,52.78 v1(149.26,52.79)
  BOTTOM w0.203: PC231.1 148.58,53.29 PR261.2
N26277377: length 1.9
  BOTTOM w0.203: PR235.1 133.43,79.44 PR233.2
  BOTTOM w0.305: PR235.1 PR231.1
N26277386: length 42.7
  TOP w0.203: v1(149.19,58.74) 149.24,58.79 149.96,58.79 151.32,57.43 152.59,54.81 v1(152.59,53.62) 152.07,53.1 151.07,53.1 150.55,52.58 PR44.2 PR47.1
  IN2 w0.127: v1(133.57,78.57) 134.7,78.57 135.94,77.33 138.21,77.33 138.52,77.02 138.52,74 140.21,72.31 140.21,63.58 142.28,61.51 145.67,61.51 146.24,60.94 146.24,59.68 147.6,58.31 148.76,58.31 v1(149.19,58.74)
  BOTTOM w0.203: v1(133.57,78.57) 133.61,78.57 PR233.1
N26277388: length 1.4
  TOP w0.305: PC71.2 141.29,52.81 140.43,52.81 PR46.2
N26277392: length 43.3
  IN2 w0.127: v1(150.96,55.21) 150.53,55.64 150.53,56.15 150.85,56.47 150.85,59.64 150.48,60.01 149.9,60.01 149.69,59.8 147.51,59.8 146.95,60.36 146.95,61.24 145.98,62.22 142.64,62.22 140.89,63.97 140.89,72.6 139.21,74.28 139.21,77.3 138.46,78.05 136.23,78.05 134.81,79.47 132.12,79.47 v1(131.18,78.53)
  BOTTOM w0.203: PR260.2 151.11,54 151.36,54.26 PR259.1 151.36,54.81 v1(150.96,55.21) ; v1(131.18,78.53) 130.7,79.01 PR234.2
N26277394: length 42.8
  IN2 w0.127: v1(131.86,78.52) 132.58,79.24 134.72,79.24 136.14,77.81 138.37,77.81 138.98,77.21 138.98,74.19 140.66,72.5 140.66,63.87 142.56,61.97 145.9,61.97 146.71,61.16 146.71,60.22 147.38,59.55 149.76,59.55 149.99,59.78 150.39,59.78 150.62,59.54 150.62,56.57 150.3,56.25 150.3,55.1 150.84,54.57 v1(152,54.57)
  BOTTOM w0.203: v1(131.86,78.52) 131.86,78.82 PR234.1 ; v1(152,54.57) 152.33,54.24 PR262.2
N26277398: length 1.2
  TOP w0.305: PR41.2 139.52,55.35 PC65.2
N26277400: length 2.3
  TOP w0.102: v1(141.65,48.7) 141.63,48.73 PR54.2
  TOP w0.483: PC73.2 141.42,50.45 141.63,50.24 PR54.2
N26277406: length 0.9
  TOP w0.203: PR47.2 PR48.1
N26277420: length 3.8
  BOTTOM w0.203: PR281.1 126.63,48.78 127.1,48.31 128.65,48.31 PR282.1 129.37,48.55 PR284.2
N26277422: length 37.3
  IN2 w0.127: v1(130.91,80.81) 130.56,80.46 130.56,78.41 130.87,78.1 133.93,78.1 134.12,78.29 134.65,78.29 135.85,77.1 138.12,77.1 138.29,76.92 138.29,73.9 139.74,72.45 139.98,72.22 139.98,63.43 142.13,61.27 145.53,61.27 145.74,61.07 v1(145.74,59.84)
  BOTTOM w0.203: PC221.1 PR255.1 145.65,59.75 v1(145.74,59.84) ; PR232.2 130.34,80.25 v1(130.91,80.81) 130.72,81 PR229.1
N26277961: length 2.7
  TOP w0.102: v1(130.67,59.27) 131.25,59.85 PR33.2
  TOP w0.483: PR33.2 131.98,59.97 PC56.1
N26277963: length 1.3
  BOTTOM w0.483: PR285.2 136.53,48.68 136.76,48.45 PC237.1
N26277967: length 2.2
  BOTTOM w0.102: v1(139.89,73.29) 139.68,73.51 PC203.1
  BOTTOM w0.483: PR241.2 139.09,72.49 PC203.1
N26418322: length 1.9
  BOTTOM w0.152: PR313.2 130.26,37.68 129.98,37.97 129.98,38.47 130.49,38.99 PC251.1
  vias: v1(131.96,47.79)
N26418739: length 1.3
  BOTTOM w0.457: PC244.2 139.05,46.41 139.23,46.24 PR294.1
N26547647: length 9.1
  BOTTOM w0.102: PR237.2 PC199.1 110.04,76.41 109.15,77.3 v1(109.15,77.41) 109.15,80.11 PQ28.3 108.59,80.3 107.38,80.3 PQ27.2
N27032306: length 2.5
  TOP w0.203: v2(145.21,57.03) 145.28,56.97 145.28,56.95 145.35,56.88 PU3.28
  BOTTOM w0.254: v2(145.21,57.03) 145.21,57.11 145.19,57.12 145.19,57.19 PR257.2
  BOTTOM w0.381: v2(145.21,57.03) 145.61,56.63 PC223.1
N27032510: length 27.8
  IN3 w0.127: v1(130.57,49.99) 131.19,49.36 136.23,49.36 136.93,48.66 142.11,48.66 145.19,51.74 151.89,51.74 152.21,51.42 152.21,50.58 v2(151.8,50.18)
  BOTTOM w0.203: PR283.1 131.82,49.08 130.91,49.99 v1(130.57,49.99) ; PR274.1 151.93,50.3 v2(151.8,50.18)
N27032514: length 24.7
  IN3 w0.127: v1(130.57,49.35) 130.82,49.11 136.11,49.11 136.78,48.44 142.21,48.44 145.25,51.48 148.55,51.48 149.13,50.9 v1(149.77,50.9)
  BOTTOM w0.203: PR283.2 131.04,48.79 130.66,49.17 130.66,49.26 v1(130.57,49.35) ; v1(149.77,50.9) 150.07,51.2 150.87,51.2 151.36,51.69 PR268.1 PR264.2
N27752748: length 2.7
  BOTTOM w0.254: R630.1 R631.1 205.17,34.4 204.79,34.02 R645.2
N28087213:
  vias: v1(25.59,112.38) v1(25.59,111.75) v1(26.5,112.3)
N28100067: length 2.9
  BOTTOM w0.102: CN12.8 69.32,22.07 v1(68.69,22.69) 68.08,22.69 67.98,22.59 R687.2
N30442033:
  vias: v1(19.49,30.03) v1(20.2,30.09) v1(20.2,29.45) v1(20.76,29.78) v1(21.12,30.31)
N30442036: length 1.3
  TOP w0.102: PC119.1 17.55,25.87 v1(17.28,25.87)
  vias: v1(20.2,26.28) v1(20.2,25.64) v1(20.33,26.91) v1(20.84,26.28) v1(20.84,25.64)
N30442060: length 5.8
  TOP w0.102: v1(27.49,27.75) 26.58,27.75 26.38,27.95 PR90.2 26.38,28.53 26.22,28.69 24.79,28.69 PC107.1 24.34,28.08 24.31,28.05 PU5.4
N30442080: length 4.8
  TOP w0.102: PU5.5 23.59,28.45 PC100.1 24.84,29.7 25.54,29.7 v1(25.87,30.03) 26.38,29.52 PR83.1
N30442084: length 5
  TOP w0.102: v1(26.48,26.53) 26.38,26.63 PR93.2 26.38,27.38 25.96,27.8 24.87,27.8 PC115.1 23.95,27.65 PU5.3
N30568314: length 4.7
  TOP w0.305: PR61.2 147.51,35.79 147.51,35.44 147.11,35.05 v1(146.96,35.05) 146.96,35.21 146.46,35.7 PC81.2 PR62.1
  BOTTOM w0.229: v1(146.96,35.05) 146.96,34.78 PU13.12
N30568326: length 1.8
  TOP w0.305: PR59.1 146.7,37.56 v1(146.7,36.74) 146.44,36.48 PC81.1
N30568424: length 4.6
  BOTTOM w0.102: v1(44.36,13.24) 44.36,13.5 44.67,13.81 PR349.1
  BOTTOM w0.152: PU15.9 44.23,16.89 44.53,16.59 44.53,16.22 PR346.2
  BOTTOM w0.229: PR346.2 PC307.2 44.7,14.15 PR349.1
N30568429: length 1.9
  BOTTOM w0.102: v1(45.63,13.24) 45.61,13.26 PR350.1
  BOTTOM w0.229: PR350.1 45.48,14.25 PC307.1
N30568472: length 0.8
  BOTTOM w0.229: v1(42.92,16.66) 42.88,16.71 PU15.12
  vias: v1(43.01,17.36)
N30568498: length 3.9
  TOP w0.254: PR113.1 44.41,16.23 44.83,15.81 44.83,15.41 45.25,15 v1(45.43,15) 47.41,15 PQ11.3
N30568542: length 3.9
  TOP w0.203: PR72.2 PR68.2 142.91,34.7 v1(142.99,34.78) 143.52,35.32 PR64.2
  BOTTOM w0.203: v1(142.99,34.78) 142.99,35.55 143.21,35.77 PR318.1
N31161954:
  vias: v1(151.19,26.5)
N31161958: length 5.3
  TOP w0.203: v1(154.8,30.59) 154.91,30.48 PU4.4
  BOTTOM w0.203: PR330.2 156.91,30.72 156.68,30.95 155.15,30.95 v1(154.8,30.59) 154.92,30.47 PC281.1
N31161974: length 2.1
  TOP w0.203: v1(156.01,27.09) 155.51,27.09 155.31,27.28 PU4.12
  BOTTOM w0.254: v1(156.01,27.09) 156.01,27.29 155.87,27.44 PC284.1
N31161976: length 1.7
  TOP w0.203: PU4.10 154.51,27.33 v1(154.69,27.16)
  BOTTOM w0.254: v1(154.69,27.16) 154.05,27.8 PC283.1
N31161997:
  vias: v1(156.55,26.71)
N31162017: length 6.5
  TOP w0.203: v1(154.11,30.59) 154.51,30.19 PU4.5
  BOTTOM w0.203: PC279.1 154.03,28.84 154.23,28.84 154.44,29.05 154.44,29.25 154.53,29.35 154.53,30.17 v1(154.11,30.59) 153.35,29.83 152.46,29.83 151.93,29.29 PR335.1
N31162025: length 5.3
  TOP w0.203: PU4.3 155.31,30.32 155.43,30.44 v1(155.43,30.47)
  BOTTOM w0.203: v1(155.43,30.47) 155.43,30.44 155.87,30.01 PC280.1 155.59,28.91 155.4,28.72 155.4,27.23 155.16,26.99 PR329.2
N33761123: length 4.9
  TOP w0.102: v1(30.54,3.29) 30.8,3.03 R434.1 31.08,2.6 31.25,2.42 v1(32.24,2.42) 32.57,2.75 D25.2
  BOTTOM w0.102: v1(30.54,3.29) 30.6,3.23 CN19.38
N33919807: length 5.2
  TOP w0.102: Q9.2 99.31,81.33 99.63,81.01 R142.2 99.91,81.29 100.14,81.52 101.41,81.52 102.19,80.74 Q11.3
N33919901: length 16.1
  TOP w0.102: v1(89.6,80.89) 90.36,81.65 96.71,81.65 97.55,80.81 99.38,80.81 99.54,80.64 101.01,80.64 101.6,80.06 Q11.2
  BOTTOM w0.102: v1(89.6,80.89) 89.6,80.76 v1(88.96,80.12) 88.96,79.84 R557.2
N33922442: length 6.5
  TOP w0.102: Q10.2 105.16,80.82 104.23,81.75 v1(103.85,81.75) 103.8,81.8 103.29,81.8 103.03,82.06 R137.2 102.63,82.06 101.65,83.04 101.65,83.56 101.14,84.07 Q8.3
N33922489: length 19.6
  TOP w0.102: Q8.2 98.66,82.07 98.49,81.9 97.34,81.9 v1(97.22,81.77)
  IN2 w0.089: v1(97.22,81.77) 96.99,82 95.46,82 94.89,82.57 93.62,82.57 90.98,85.22 87.66,85.22 87.26,84.82 v1(87.06,84.82)
  BOTTOM w0.102: R552.2 86.8,80.55 87.24,80.99 87.24,82.48 86.8,82.92 86.8,83.4 87.06,83.65 v1(87.06,84.82)
N36446693: length 2.7
  TOP w0.102: R63.2 44.64,110.65 44.77,110.78 C25.1 44.77,111.48 44.07,112.19 Y1.3
N36953746: length 14.2
  BOTTOM w0.102: Q34.2 52.79,22.5 52.11,23.18 51.24,23.18 50.9,22.83 49.3,22.83 49.16,22.69 C668.2 49.49,22.3 49.74,22.04 49.74,20.76 49.87,20.64 50.48,20.64 50.76,20.36 v1(50.76,19.06) 50.76,18.5 51.45,17.82 51.45,16.19 52.1,15.54 R694.2
N36954805: length 2
  TOP w0.102: R357.2 68.27,18.15 68.23,18.2 v1(67.73,18.2) U17.7
N36977514: length 4.5
  BOTTOM w0.102: Q40.3 195.35,16.28 195.72,15.91 Q41.2 196.47,16.37 196.4,16.44 R703.2 196.57,17.12 v1(197.32,16.37)
N37139396: length 1.9
  TOP w0.102: R333.1 129.6,22.08 v1(129.75,22.24) 130.33,22.24 D9.2
N37139525: length 2.4
  TOP w0.102: R358.2 121.73,18.27 v1(122.12,18.67) 122.12,19.05 122.67,19.6 U16.24
N37139527: length 2.2
  TOP w0.102: R325.2 121.7,21.83 v1(121.88,21.65) 122.44,21.1 U16.21
N37139529: length 3.3
  TOP w0.102: U16.19 122.61,22.1 121.73,22.98 121.73,24.24 121.6,24.37 R311.2
N37139543: length 2.1
  TOP w0.102: U16.20 122.6,21.6 121.6,22.59 R321.2
N37162929: length 0.7
  TOP w0.102: R318.1 TP34.1
N37164012: length 2.2
  BOTTOM w0.102: U35.16 202.13,30.27 202.04,30.36 202.04,31.51 202.12,31.58 C639.1
N37164724: length 6.4
  BOTTOM w0.102: R634.2 200.11,34.68 200.09,34.66 198.94,34.66 198.32,34.03 D31.1 198.32,32.38 v1(197.83,31.89) 197.09,31.89 196.97,31.77 D32.1
N37738541: length 5.4
  BOTTOM w0.102: U30.AK32 79.1,51.09 77.96,51.09 77.4,51.65 75.39,51.65 TP59.1
N37738542: length 7.8
  BOTTOM w0.102: U30.AL31 79.41,50.68 79.06,50.68 78.86,50.89 77.81,50.89 77.26,51.44 75.23,51.44 74.53,52.13 74.15,52.13 73.85,52.44 72.78,52.44 TP60.1
N38048788: length 4
  TOP w0.381: C268.1 87.3,55.87 v2(87.18,55.87) 86.76,55.87 86.38,55.49 R182.1
  BOTTOM w0.254: v2(87.18,55.87) 87.06,55.99 U30.AD21 86.55,56.03 86.55,56.95 U30.AC21
N38521997: length 3.2
  BOTTOM w0.102: R697.1 174.08,19.19 174.18,19.29 D37.1 174.98,18.24 175,18.22 CN16.1
N38680880: length 1.9
  BOTTOM w0.102: R689.1 176.34,20.81 v1(176.21,20.69) 175.83,20.69 175.56,20.96 Q36.2
N38756671: length 6.1
  TOP w0.102: v1(182.69,12.61) 182.74,12.56 R412.1 183.35,13.34 183.46,13.45 C501.2 183.59,13.58 183.2,13.96 183.2,13.96 182.94,13.96 182.69,14.21 182.69,15.61 182.14,16.16 U15.66
N38756677: length 1.6
  TOP w0.102: TP36.1 182.32,20.96 U15.78
N38756738: length 4.2
  TOP w0.102: U15.82 182.13,22.56 182.26,22.68 182.26,22.77 182.75,23.26 182.9,23.26 183.57,23.93 C416.2 183.57,24.62 183.83,24.88 R303.1
N38756787: length 5.7
  TOP w0.102: U15.98 179.22,30.55 179.59,30.92 v1(180.3,30.92) 182.5,30.92 C373.2 182.81,31.71 182.97,31.88 R256.1
N38756834: length 198.6
  TOP w0.102: v1(159.47,31.38) 159.89,31.8 159.89,33.71 159.02,34.58 157.87,34.58 156.91,35.55 155.47,35.55 152.83,38.18 R233.2 151.97,38.18 Q15.3
  IN2 w0.089: v1(16.95,58.41) 17.33,58.03 19.75,58.03 20.64,58.91 22.67,58.91 26.17,55.41 26.17,34.76 27.34,33.6 27.34,32.68 28.55,31.47 28.55,30.35 27.98,29.77 27.98,28.65 28.26,28.37 33.3,28.37 37.11,24.56 40.99,24.56 43.31,26.87 48.85,26.87 50.66,25.07 61.53,25.07 62.04,25.58 65.13,25.58 65.55,26 72.65,26 73.41,26.76 84.03,26.76 84.82,27.55 92.14,27.55 93.41,28.82 93.66,28.82 96.71,25.77 100.52,25.77 101.99,24.29 111.87,24.29 112.56,24.98 113.85,24.98 114.87,26 121.37,26 121.7,25.67 121.7,25.26 121.98,24.98 122.16,24.98 123.39,26.21 130.23,26.21 130.52,26.5 137.18,26.5 140.4,29.73 146.92,29.73 147.94,28.71 151.5,28.71 152.65,29.86 155.95,29.86 156.56,30.47 158.56,30.47 v1(159.47,31.38)
  BOTTOM w0.102: v1(16.95,58.41) SW2.3 SW2.4
N38757336: length 4.6
  TOP w0.102: R269.1 165.11,31.61 165.24,31.47 C369.1 165.54,31.13 165.31,30.9 v1(165.31,30.52) 165.54,30.52 166.05,30.01 166.38,30.01 166.97,29.42 167.14,29.42 167.22,29.5 U15.128
N38757406: length 139.2
  TOP w0.102: v1(148.3,40.65) R222.1 C341.1 149.67,40.25 149.56,40.13 Q15.2
  IN2 w0.089: v1(113.09,82.54) 112.36,83.27 112.36,83.68 110.98,85.05 110.45,85.05 110.17,85.33 95.08,85.33 94,86.41 87.12,86.41 85.91,87.62 81.34,87.62 79.56,89.39 71.08,89.39 69.11,91.37 69.11,93.88 67.37,95.62 67.37,95.79 v1(66.75,96.42)
  IN3 w0.089: v1(148.3,40.65) 145.76,40.65 145.22,40.12 142.05,40.12 141.41,40.75 141.41,44.94 139.04,47.31 136,47.31 135.47,47.84 127.09,47.84 126,48.93 126,59.63 127.98,61.61 127.98,73.37 126.17,75.17 124.32,75.17 123.96,75.53 123.96,79.39 123.81,79.54 119.75,79.54 117.13,82.16 115.89,82.16 115.12,82.92 113.47,82.92 v1(113.09,82.54)
  BOTTOM w0.102: SW1.3 SW1.4 66.7,96.47 v1(66.75,96.42)
N38758998: length 1.1
  TOP w0.102: R322.1 162.11,22.72 161.86,22.97 C425.2
N38759178: length 2.4
  TOP w0.102: C418.1 163.64,23.74 163.76,23.86 v1(164.07,23.86) 164.17,23.76 U15.12
N39268705: length 3.4
  BOTTOM w0.102: R682.2 R677.1 70.85,24.14 v1(70.42,24.57) 70.42,24.95 70.58,25.11 R670.1 70.3,25.34 70.22,25.26 Q32.3
N39618724: length 8.1
  BOTTOM w0.099: 95.06,39.69 95.06,40.12 94.93,40.25 94.93,41.02 U30.BC11
  BOTTOM w0.102: 95.06,39.69 95.06,39.12 95.85,38.33 TP66.1 95.85,36 96.12,35.72 96.12,34.7 96.41,34.42 96.76,34.42 97.04,34.14 R641.1
N39785725: length 3.1
  BOTTOM w0.102: R707.1 212.91,16.67 212.94,16.7 213.35,16.7 213.72,16.32 HD1.1 ; R707.1 R705.1 ; R707.1 212.63,16.06 v1(212.48,15.91)
N40550359:
  vias: v1(111.19,124.29)
N41800206: length 8.8
  BOTTOM w0.102: R660.1 R658.1 85.76,28.34 85.41,28.69 85.41,29.07 85.2,29.27 85.2,30.52 85.8,31.11 v1(86.05,31.11) 86.59,31.11 87.44,30.26 87.44,28.43 87.34,28.34 R659.1 R661.1
N42696396: length 1.5
  BOTTOM w0.102: U28.33 21.53,81.53 22.06,82.05 TP53.1
N42696414: length 2.5
  BOTTOM w0.102: TP54.1 23.33,82.28 22.92,81.88 22.29,81.88 21.93,81.52 U28.34
N42696431: length 2.8
  TOP w0.102: v1(23.4,81.4) 23.26,81.55 22.79,81.55 v1(22.77,81.52) 22.67,81.42 22.67,81.15 R145.1
  BOTTOM w0.102: v1(23.4,81.4) 22.8,81.4 22.73,81.33 U28.36
N42868528: length 2
  BOTTOM w0.102: CN11.58 191.71,16.88 192.34,17.51 R702.1
N42946269: length 6.8
  TOP w0.102: R428.2 20.66,7.58 20.51,7.73 19.9,7.73 19.65,7.48 ; 19.65,7.48 19.65,6.74 19.8,6.59 v1(19.8,6.21) ; 19.65,7.48 19.39,7.73 U21.2 17.97,7.73 17.81,7.58 R427.2 R424.1
N42947913: length 4.4
  TOP w0.102: v1(26.2,9.46) 26.46,9.2 Q26.3 26.46,6.32 26.32,6.18 R431.2
N43515700: length 9.4
  TOP w0.102: v2(78.14,58.15) 78.55,58.56 81.95,58.56 82.43,58.08 TP18.1
  BOTTOM w0.102: v2(78.14,58.15) 78.17,58.13 78.17,58.02 78.43,57.76 78.87,57.76 79.57,57.06 79.57,56.98 80.06,56.49 U30.AC29
N43515715: length 5.1
  BOTTOM w0.102: TP62.1 74.74,46.6 79.5,46.6 U30.AR31
N43541412:
  vias: v1(147.38,18.43)
N43541437: length 2.1
  TOP w0.102: v1(151.44,21.01) C426.1 R326.2
N43551997: length 2.3
  TOP w0.102: C344.1 112.2,40.25 v1(111.76,40.69) 111.53,40.92 R225.2
N43603731: length 14.4
  TOP w0.102: Q25.3 200.47,11.25 200.87,10.85 200.95,10.85 201.03,10.77 C517.1 204.29,10.77 204.66,10.4 v1(207.7,10.4) 210.24,10.4 R420.2 211,11.16 212,11.16 212.74,11.9 Q23.2
N43605845:
  vias: v1(147.61,14.74)
N43643606: length 11.7
  TOP w0.102: Q13.2 105.61,72.77 105.73,72.88 107.86,72.88 109.03,74.05 v1(109.03,74.81) 109.03,76.24 108.73,76.54 107.44,76.54 107.36,76.47 R164.2 106.59,76.47 105.74,77.31 Q12.3
N43643623: length 20.1
  TOP w0.102: v1(89.6,80) 89.67,80 90.83,81.16 96.53,81.16 97.34,80.35 99.19,80.35 99.36,80.19 99.81,80.19 100.9,79.1 100.9,78.22 101.15,77.96 102.17,77.96 103.89,76.25 Q12.2 104.56,74.64 v1(104.56,74.36)
  BOTTOM w0.102: R558.2 89.34,79.74 v1(89.6,80)
N43702733: length 2.2
  BOTTOM w0.102: CN2.24 55.22,106.39 55.15,106.32 v1(55.15,105.93) 55.59,105.49 R504.2
N43737419: length 2
  BOTTOM w0.102: R506.2 57.62,105.52 57.59,105.55 57.59,106.64 57.72,106.77 CN2.29
N44248719: length 2
  TOP w0.102: R84.2 59.27,102.19 59.49,101.98 C103.2 60,101.98 60.36,101.61 R85.2
N44448022: length 9
  BOTTOM w0.102: R693.2 206.92,20.15 207.06,20.29 Q39.3 207.83,19.93 207.45,19.54 207.45,17.89 207.95,17.39 R708.2 207.95,16.23 v1(208.52,15.66) 209.21,14.97 R715.1
N44448095: length 2.1
  BOTTOM w0.102: R701.2 v1(209.99,17.77) 209.74,17.77 209.21,18.29 Q39.2
N44687038: length 1.6
  TOP w0.102: TP30.1 164.19,27.76 U15.2
N44719631: length 2.6
  TOP w0.102: R201.2 114.67,45.62 114.59,45.7 v1(113.85,45.7) 113.36,45.7 113.15,45.49 Q14.2
N44878476: length 2.7
  TOP w0.102: v1(23.68,3.29) 23.94,3.29 24.35,2.88 R435.1
  BOTTOM w0.102: v1(23.68,3.29) 23.56,3.29 23.1,2.83 CN19.68
N44885066: length 3.2
  TOP w0.559: PD2.3 127.6,34.31 127.9,34.61 v1(128.81,34.61) 128.81,34.25 PR74.2
N45198823: length 3.6
  BOTTOM w0.152: v1(59.95,125.58) 60.41,125.58 60.42,125.59 PR116.1
  vias: v1(59.3,125.58) v1(60.03,124.9)
N45292490: length 3
  TOP w0.102: v1(22.85,8.37) 22.67,8.55 v1(22.67,9.16) 22.87,9.36 R423.2
  BOTTOM w0.102: v1(22.85,8.37) 22.85,8.37 CN19.69
N45472894: length 2.4
  TOP w0.102: PU5.12 20.65,27.65 20.51,27.8 20.08,27.8 v1(19.8,27.52) 19.52,27.8 PC114.1
N45472895: length 2.3
  TOP w0.102: PU5.10 20.13,28.45 v1(19.8,28.79) 19.77,28.82 PC102.1
N45477665: length 10
  TOP w0.102: v1(52.18,109.84) 52.18,110.4 51.84,110.74 Q1.2 52.77,110.86 54.81,112.9 54.81,113.02 55.17,113.39 R56.2 55.6,113.83 56.22,113.83 56.45,113.6 56.45,113.39 57.86,111.99 C24.2
N45479516:
  vias: v1(198.77,30.52)
N45481673: length 30.1
  IN2 w0.102: v1(73.98,105.9) 74.48,105.4 74.48,104.28 74.41,104.21 74.41,99.18 76.91,96.68 81.01,96.68 81.6,97.27 81.81,97.27 v1(82.4,96.68)
  BOTTOM w0.152: v1(73.98,105.9) 74.23,105.9 74.66,105.47 74.93,105.47 PC172.1 ; v1(73.98,105.9) 74.15,106.08 PC170.1 ; v1(73.98,105.9) 73.8,106.08 72.81,106.08 PR191.1 73.11,104.82 PR192.2 ; PR208.1 84.47,92.09 83.93,92.63 82.58,92.63 82.4,92.81 v1(82.4,96.68)
  BOTTOM w0.203: PR208.1 84.48,91.5 PR206.2
N45613574: length 1.2
  BOTTOM w0.102: R525.2 67.51,94.48 67.43,94.41 U26.3
N45705221: length 1.9
  TOP w0.203: PR10.1 87.56,117.84 PC22.1 PR14.1
N45707852: length 2.3
  BOTTOM w0.203: PR162.1 72.05,115.33 72.2,115.48 PR160.2 72.7,115.48 72.95,115.24 PU8.24
N45737842: length 2.2
  TOP w0.102: PC24.1 v1(83.29,116.28)
  TOP w0.457: PR11.2 82.27,116.92 82.46,116.72 PC24.1
N45744946: length 3.5
  TOP w0.102: v1(125.69,122.69) 125.79,122.59 126.59,122.59 D3.1 127.48,122.25 127.82,121.91 R28.1 R33.2
N45985279: length 0.8
  TOP w0.102: R53.1 L2.1
N45985282: length 1.9
  TOP w0.102: R52.1 L1.1 41.22,113.52 v1(40.7,114.03)
N45988033: length 2.4
  TOP w0.102: U20.3 187.98,16.45 188.41,16.89 R368.2 188.41,17.96 v1(188.17,18.2)
N46048036: length 5.3
  TOP w0.102: R310.1 R309.2 187.74,25.36 186.75,26.35 186.75,26.81 v1(186.35,27.21) 186.22,27.34 D8.2
N46807066: length 16
  BOTTOM w0.203: PC218.2 142.16,62.13 142.66,61.63 143.63,61.63 PR249.1
  BOTTOM w0.254: PC218.2 141.66,62.14 140.86,62.93 140.86,73.17 141.13,73.44 141.13,75.08
  vias: v1(147.23,76.54) v3(141.67,77.96) v3(141.67,77.2) v3(143.06,76.06) v3(143.83,76.06) v3(148.4,76.82) v3(148.4,76.06)
N46807891:
  vias: v1(105.98,85.53)
N47284656:
  vias: v1(45.2,27.95)
N47284687:
  vias: v1(34.12,26.1)
N47284767:
  vias: v1(36.36,22.77)
N47360845: length 2.3
  TOP w0.102: R731.2 111.54,46.52 111.49,46.47 v1(111.06,46.47) 110.75,46.15 Q14.1
N47751595: length 1.6
  TOP w0.102: R156.1 R150.1 40.83,78.98 40.93,79.08 C188.1
N47964247: length 5.1
  TOP w0.102: Q17.2 92.2,22.15 93.1,23.05 93.1,24.15 v1(93.03,24.23) 92.43,24.83 92.14,24.83 91.99,24.98 C411.2 R302.2
N47965740: length 4.3
  TOP w0.102: R345.2 C444.2 23.4,20.21 23.12,20.49 Q18.2 23.12,23.24 v1(22.97,23.38)
N48031337: length 1.4
  TOP w0.102: R366.1 22.01,17.39 21.48,16.86 U19.18
N48031368: length 17.6
  TOP w0.203: v1(22.92,11.54) 22.7,11.77 C509.2 21.47,13.4 21.47,14.21 21.33,14.36 U19.13
  TOP w0.508: v1(21.91,20.56) 21.78,20.69 R335.1
  IN2 w0.508: v1(21.91,20.56) 22.29,20.56 23.3,19.54 23.3,19.04 25.72,16.62 25.72,13.32 24.57,12.18 23.3,12.18 22.92,11.8 v1(22.92,11.54)
N48041869: length 10.1
  IN1 w0.305: v1(75.65,115.44) 75.65,114.93 75.43,114.7 75.43,113.88 77,112.3 77.45,112.3 77.58,112.43 79.4,112.43 v1(79.62,112.65)
  BOTTOM w0.203: PC153.1 76,115.93 75.65,115.58 v1(75.65,115.44) 75.56,115.34 75.09,115.34 74.55,114.8 PU8.28
  BOTTOM w0.305: v1(79.62,112.65) 79.47,112.5 PR170.2
N48041922: length 46.9
  IN2 w0.102: v1(88.6,97.98) 88.18,97.56 87.4,97.56 85.2,95.36 76.79,95.36 73.37,98.78 73.37,103.87 68.91,108.32 66.1,108.32 65.59,108.83 65.59,109.41 66.79,110.61 66.79,112.98 66,113.77 66,114.9 65.57,115.33 v1(65.46,115.33)
  BOTTOM w0.178: PR153.2 PR157.1 68.13,116.56 65.82,116.56 65.46,116.2 v1(65.46,115.33)
  BOTTOM w0.203: v1(88.6,97.98) 89.05,97.98 89.59,97.44 PR202.1
N48041929: length 32.5
  IN2 w0.102: v1(87.61,97.96) 87.44,97.79 87.33,97.79 85.28,95.74 76.69,95.74 73.57,98.87 73.57,104 68.74,108.83 v1(66.23,108.83)
  BOTTOM w0.152: PR177.1 66.64,108.42 v1(66.23,108.83)
  BOTTOM w0.203: v1(87.61,97.96) 87.13,97.48 PR200.1
N48041930: length 31.9
  IN2 w0.102: v1(86.15,97.97) 86.15,97.22 85.11,96.18 76.84,96.18 73.98,99.03 73.98,104.2 70.06,108.11 v1(70.06,108.39) 70.49,108.82 70.49,110.71 v1(69.27,111.93)
  BOTTOM w0.203: PR200.2 86.35,97.77 v1(86.15,97.97) ; PR171.1 69.44,111.75 v1(69.27,111.93) ; PR178.1 70.04,108.42 v1(70.06,108.39)
N48041941: length 1.9
  BOTTOM w0.203: PR203.1 PR201.1 89.08,96.99 PR202.2
N48041971: length 29.9
  BOTTOM w0.102: PR165.1 68.6,115.15 69.02,115.57 69.02,117.59 68.6,118.01 PR150.2 68.6,118.03 68.92,118.35 68.92,121.43 70.14,122.65 70.14,123.21 71.02,124.09 76.02,124.09 76.76,123.35 86.43,123.35 86.78,123.7 87.98,123.7 87.98,123.7 88.52,123.7 88.91,124.09 88.91,124.68 88.77,124.82 PR117.1
N48041975: length 2.7
  BOTTOM w0.102: v1(88,125.55) PR117.2
  BOTTOM w0.203: PR123.1 89.6,124.84 89.6,124.85 PR118.1 89.37,125.55 PR117.2
N48041983: length 25.4
  BOTTOM w0.102: PR138.1 67.4,120.51 68.34,120.51 68.44,120.61 68.44,121.59 69.66,122.81 69.66,123.43 70.77,124.55 76.21,124.55 76.95,123.81 86.24,123.81 86.79,124.35 PR124.2
  BOTTOM w0.203: PR138.1 66.88,119.82 66.1,119.04 PR144.2
N48042007: length 13.5
  TOP w0.152: PR18.1 70.12,116.45 70.37,116.19 70.9,116.19 71.59,116.88 PR15.2 71.44,117.08 v1(70.51,118.01) 70.04,118.48 v2(70.04,119.37)
  IN1 w0.152: v1(75.58,117.44) 73.65,119.37 v2(70.04,119.37)
  BOTTOM w0.152: PR146.1 PC151.1 75.24,117.77 v1(75.58,117.44)
N48042043: length 0.9
  BOTTOM w0.203: PR150.1 PR149.2
N48042051: length 1
  BOTTOM w0.203: PR172.2 PR173.1
N48042052: length 1
  BOTTOM w0.203: PR175.2 PR176.1
N48042059: length 0.9
  BOTTOM w0.203: PR157.2 PR156.2
N48042060: length 0.9
  BOTTOM w0.203: PR153.1 PR152.2
N48042070: length 0.8
  BOTTOM w0.203: PR169.2 67.75,112.38 PC163.1
N48042075: length 1.4
  BOTTOM w0.381: PC166.2 78.52,111.14 77.96,110.58 PR174.2
N48042078: length 23.7
  BOTTOM w0.102: PR124.1 88.04,123.93 86.68,123.93 86.33,123.58 76.85,123.58 76.12,124.32 70.93,124.32 69.91,123.3 69.91,122.74 68.67,121.5 68.67,120.38 68.34,120.05 PR143.2
N48042080: length 1.3
  BOTTOM w0.381: PR158.2 77.38,114.43 PC159.2
N48042081: length 1.4
  BOTTOM w0.381: PR186.2 76.55,106.76 76.01,107.3 PC167.2
N48042082: length 0.9
  BOTTOM w0.203: PR165.2 PR164.1
N48043954: length 2.1
  TOP w0.102: PC30.1 v1(80.99,111.64)
  TOP w0.457: PR23.2 81.61,110.87 81.51,110.78 PC30.1
N48043955: length 1.3
  BOTTOM w0.457: PC175.1 82.64,98.18 PR199.2
N48073638: length 3.2
  BOTTOM w0.102: PR326.2 112.2,32.5 112.45,32.74 PC270.1 111.72,33.13 v1(111.59,33.26) 111.33,33.52 PU12.5
N48073642: length 4
  BOTTOM w0.102: PR311.1 112.19,38.04 111.81,37.65 111.59,37.65 111.33,37.39 PU12.1 111.33,36.48 110.65,35.8 v1(110.22,35.8)
N48073650: length 2.6
  BOTTOM w0.102: PR310.1 114.46,37.83 v1(114.01,37.83) 113.6,37.83 113.23,37.46 PU12.3
N48075705:
  vias: v1(193.18,30.16)
N48094139: length 7.7
  TOP w0.102: PR82.1 PC109.2 192.33,28.18 192.85,27.66 v1(192.85,27.42) 192.85,27.34 192.23,26.72 192.08,26.72 191.63,26.28 191.63,23.93 191.99,23.58 PR104.1
N48094145: length 3
  TOP w0.102: PR102.2 192.86,25.52 192.83,25.54 PC118.2 193.26,26.4 193.69,26.4 194.02,26.07 PU6.1
