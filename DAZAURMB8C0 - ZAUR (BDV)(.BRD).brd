# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_BS#1: length 39.3
  IN1 w0.102: 75.88,49.26 76.01,49.14 79.65,49.14 80.33,49.81 80.73,49.81 v2(81.41,50.49)
  IN1 w0.14: 75.88,49.26 75.35,49.8 72.01,49.8 69.59,52.21 65.22,52.21 63.24,54.19 62.06,54.19 60.69,55.56 59.46,55.56 57.47,57.56 57.47,59.2 56.61,60.06 54.42,60.06 54.21,59.85 54.21,59.24 54.42,59.04 55.98,59.04 v2(56.79,58.23)
  BOTTOM w0.165: CN5.145 56.82,58.21 v2(56.79,58.23) ; U30.AK27 81.81,50.89 v2(81.41,50.49)
M_A_CAS#: length 43.7
  TOP w0.102: v2(81.47,49.49) 81.39,49.41 80.35,49.41 79.94,49.01
  TOP w0.165: 79.94,49.01 78.48,47.54 73.35,47.54 65.74,55.15 65.01,55.15 64.58,54.72 61.66,54.72 61.35,55.03 56.15,55.03 55.69,55.49 54.84,55.49 54.67,55.65 54.67,56.25 54.29,56.63 51.37,56.63 51.12,56.37 51.12,55.23 51.62,54.72 53.15,54.72 v2(53.4,54.47)
  BOTTOM w0.165: CN5.156 52.42,55.46 v2(53.4,54.47) ; v2(81.47,49.49) 81.81,49.83 U30.AL27
M_A_CKE0: length 42.9
  TOP w0.165: v2(83.58,55.49) 83.07,54.98 82.48,54.98 81.98,55.49 80.07,55.49 79.06,56.5 78.5,56.5 75.83,59.17 72.2,59.17 71.92,59.45 71.54,59.45 67.53,63.45 61.61,63.45 59.24,65.82 59.24,68.69 58.35,69.58 57.47,69.58 56.94,69.06 55.29,69.06 v1(54.42,68.19)
  BOTTOM w0.165: CN5.109 55.31,69.21 54.42,68.31 v1(54.42,68.19) ; U30.AD24 84.08,55.99 v2(83.58,55.49)
M_A_CKE1: length 40.6
  IN1 w0.102: v2(82.91,55.52) 80.23,55.52 79.82,55.1 78.04,55.1 77.79,54.85 77.28,54.85 76.64,55.49 76.64,55.99 76.26,56.37 75.5,56.37 75.44,56.44
  IN1 w0.14: 75.44,56.44 74.04,57.83 72.34,57.83 71.66,58.52 70.04,58.52 65.06,63.5 62.25,63.5 60.73,65.01 59.95,65.01 57.53,67.43 57.53,68.22 57.05,68.69 53.27,68.69 v1(52.89,68.31)
  BOTTOM w0.165: U30.AD25 83.31,55.92 v2(82.91,55.52) ; CN5.110 52.5,68.96 52.89,68.57 v1(52.89,68.31)
M_A_CLKN0: length 45.3
  IN1 w0.102: 79.94,50.25 79.97,50.25 80,50.28 80.63,50.28 81.24,50.89 83.06,50.89 83.36,51.18 83.36,51.41 83.46,51.51 83.65,51.51 v2(83.65,51.51)
  IN1 w0.14: v2(56.23,60.83) 55.93,60.83 55.73,61.03 55.73,61.24 55.99,61.5 56.98,61.5 57.57,60.92 57.57,60.21 58.38,59.4 59.09,59.4 59.61,58.88 59.61,58.52 59.51,58.42 58.63,58.42 58.36,58.15 58.36,57.77 58.93,57.2 60.2,57.2 61.67,55.73 63.45,55.73 63.54,55.64 63.54,54.95 63.98,54.51 64.4,54.51 65.06,55.16 65.31,55.16 65.57,54.9 65.57,54.72 64.88,54.03 64.88,53.61 65.53,52.96 69.9,52.96 72.3,50.56 75.86,50.56 76.9,49.52 78.85,49.52 79.58,50.25 79.94,50.25
  BOTTOM w0.165: CN5.139 57.47,61.71 57.34,61.84 56.09,61.84 55.8,61.55 55.8,60.95 55.93,60.83 v2(56.23,60.83) ; U30.AJ24 83.65,51.54 v2(83.65,51.51)
M_A_CLKN1: length 45.3
  IN1 w0.102: v2(86.05,51.54) 85.86,51.73 85.86,51.85 85.53,52.18 84.9,52.18 84.81,52.1 81.86,52.1 81.44,51.68 79.82,51.68 79.31,51.17 76.52,51.17 76.13,51.55 73.67,51.55 71.92,53.29 71.62,53.29 71.59,53.33 71.56,53.33
  IN1 w0.14: 71.56,53.33 71.31,53.33 70.47,54.16 69.05,54.16 65.81,57.4 62.4,57.4 61.94,57.87 61.94,58.28 57.26,62.95 55.23,62.95 54.74,62.46 54.74,62.02 54.56,61.85 52.55,61.85 52.28,61.58 v2(52.28,60.82)
  BOTTOM w0.165: v2(52.28,60.82) 52.28,61.05 52.4,61.16 52.58,61.16 52.65,61.23 52.65,61.49 52.5,61.64 51.43,61.64 51.24,61.46 CN5.140 ; U30.AJ21 v2(86.05,51.54)
M_A_CLKP0: length 45.3
  IN1 w0.102: v2(82.85,51.51) 82.86,51.51 83.05,51.51 83.15,51.41 83.15,51.27 82.98,51.09 81.16,51.09 80.55,50.48 80,50.48 79.97,50.51 79.94,50.51
  IN1 w0.14: 79.94,50.51 79.47,50.51 78.74,49.78 77.01,49.78 75.97,50.82 72.41,50.82 70.01,53.22 65.64,53.22 65.14,53.72 65.14,53.92 65.83,54.61 65.83,55.01 65.42,55.43 64.95,55.43 64.29,54.78 64.09,54.78 63.81,55.06 63.81,55.75 63.56,55.99 61.78,55.99 60.31,57.47 59.04,57.47 58.63,57.88 58.63,58.04 58.74,58.15 59.62,58.15 59.88,58.41 59.88,58.99 59.2,59.66 58.49,59.66 57.83,60.32 57.83,61.03 57.09,61.77 55.88,61.77 55.46,61.35 55.46,60.95 55.43,60.92 55.43,60.92 v2(55.34,60.83)
  BOTTOM w0.165: v2(55.34,60.83) 55.48,60.97 55.48,61.68 55.96,62.15 57.47,62.15 57.52,62.21 CN5.137 ; v2(82.85,51.51) 83.31,51.96 U30.AJ25
M_A_CLKP1: length 45.3
  IN1 w0.102: 71.56,53.06 71.59,53.06 71.62,53.09 71.84,53.09 73.59,51.34 76.05,51.34 76.43,50.96 79.39,50.96 79.9,51.47 81.52,51.47 81.94,51.89 84.9,51.89 84.99,51.98 85.45,51.98 85.66,51.77 85.66,51.57 85.51,51.42 85.39,51.42 v2(85.27,51.54)
  IN1 w0.14: v2(52.97,60.82) 52.89,60.82 52.55,61.16 52.55,61.47 52.67,61.58 54.67,61.58 55,61.91 55,62.35 55.34,62.69 57.15,62.69 61.67,58.17 61.67,57.76 62.29,57.14 65.7,57.14 68.94,53.9 70.36,53.9 71.2,53.06 71.56,53.06
  BOTTOM w0.165: CN5.138 52.63,61.96 52.97,61.62 v2(52.97,60.82) ; v2(85.27,51.54) 85.7,51.97 U30.AJ22
M_A_CS#0: length 42.9
  TOP w0.102: v2(82.91,49.49) 82.91,49.98 82.8,50.09 80.95,50.09 80.88,50.01 79.81,50.01
  TOP w0.165: 79.81,50.01 79.06,49.26 78.17,49.26 77.53,49.9 72.11,49.9 65.48,56.53 65.48,56.86 65.34,57.01 62.42,57.01 62.29,57.14 61.47,57.14 61.31,56.97 61.31,56.04 61.14,55.88 60.81,55.88 60.64,56.04 60.64,56.97 60.48,57.14 60.15,57.14 59.98,56.97 59.98,56.04 59.82,55.88 59.36,55.88 59.2,56.04 59.2,57.95 59.06,58.09 58.7,58.09 58.54,57.93 58.54,56.06 58.35,55.88 58.04,55.88 57.85,56.07 57.85,56.97 57.68,57.14 57.26,57.14 57.08,56.96 57.08,56.58 56.91,56.4 56.53,56.4 56.38,56.55 56.38,56.81 56.66,57.09 v2(56.66,57.09)
  BOTTOM w0.165: U30.AL25 82.91,49.59 v2(82.91,49.49) ; v2(56.66,57.09) 56.78,57.21 CN5.149
M_A_CS#1: length 42.5
  TOP w0.102: 80.52,48.44 80.96,48.88 81.69,48.88 82.12,49.31 v2(82.12,49.5)
  TOP w0.165: 80.52,48.44 79.93,48.44 79.69,48.2 79.69,47.76 79.06,47.14 73.2,47.14 66.01,54.33 65.29,54.33 65.04,54.09 65.04,53.06 64.88,52.89 64.55,52.89 64.38,53.06 64.38,54.09 64.22,54.25 63.89,54.25 63.72,54.09 63.72,53.06 63.56,52.89 63.23,52.89 63.06,53.06 63.06,54.09 62.9,54.25 62.57,54.25 62.4,54.09 62.4,53.06 62.24,52.89 61.91,52.89 61.74,53.06 61.74,54.09 61.58,54.25 61.25,54.25 61.08,54.09 61.08,53.06 60.92,52.89 60.59,52.89 60.42,53.06 60.42,53.85 60.26,54.02 59.93,54.02 59.76,53.85 59.76,53.56 59.6,53.4 59.27,53.4 59.1,53.57 59.1,54.47 58.94,54.63 57.19,54.63 v2(57.05,54.49)
  BOTTOM w0.165: v2(82.12,49.5) 82.51,49.12 U30.AM26 ; CN5.157 57.57,55.21 57.05,54.68 v2(57.05,54.49)
M_A_DM0: length 47.7
  IN1 w0.089: v1(52.22,92.97) 52.22,93.29 53.51,94.58 57.48,94.58 59.1,92.96 61.26,92.96 63.41,90.82 63.41,90.05 76.26,77.2 77.15,77.2 79.69,74.66 79.69,73.65 79.97,73.37 79.97,69.25 81.51,67.72 v2(81.51,67.52)
  BOTTOM w0.102: U30.L27 81.81,67.22 81.61,67.41 v2(81.51,67.52) ; CN5.12 51.73,93.46 v1(52.22,92.97)
M_A_DM1: length 52.2
  IN1 w0.089: v2(85.18,64.48) 84.75,64.48 84.59,64.32 83.45,64.32 82.99,63.87 82.1,63.87 81.95,63.71 80.63,63.71 79.56,64.78 79.56,65.65 78.8,66.41 77.94,66.41 68.27,76.08 68.14,76.08 67.81,75.75 67.68,75.75 67.56,75.87 67.56,76 67.89,76.33 67.89,76.46 67.76,76.58 67.64,76.58 67.31,76.25 67.18,76.25 67.05,76.38 67.05,76.5 67.39,76.83 67.39,76.96 67.26,77.09 67.13,77.09 66.84,76.79 66.72,76.79 66.59,76.92 66.59,77.04 66.88,77.34 66.88,77.46 66.76,77.59 66.63,77.59 66.34,77.3 66.21,77.3 66.09,77.42 66.09,77.55 66.38,77.84 66.38,77.97 66.25,78.09 66.13,78.09 65.84,77.8 65.71,77.8 65.59,77.92 65.59,78.05 65.88,78.34 65.88,78.47 65.75,78.59 65.63,78.59 65.33,78.3 65.21,78.3 65.08,78.43 65.08,78.55 65.37,78.85 65.37,78.97 65.25,79.1 65.12,79.1 64.83,78.8 64.71,78.8 64.58,78.93 64.58,79.06 64.87,79.35 64.87,79.47 64.75,79.6 64.62,79.6 64.33,79.31 64.2,79.31 64.08,79.43 64.08,79.56 64.37,79.85 64.37,79.98 64.24,80.1 64.12,80.1 63.79,79.77 63.66,79.77 63.53,79.9 63.53,80.02 63.87,80.35 63.87,80.48 63.45,80.9 63.45,83.2 57.73,88.91 v1(57.08,88.91)
  BOTTOM w0.102: v1(57.08,88.91) 57.08,88.64 57.52,88.21 CN5.33 ; U30.N23 85.18,64.72 v2(85.18,64.48)
M_A_DM2: length 44.8
  TOP w0.102: v1(52.51,82.46) 53.07,81.9 58.58,81.9 61.37,79.11 61.37,78.97 61.21,78.81 61.21,78.67 61.35,78.52 61.5,78.52 61.66,78.68 61.8,78.68 63.94,76.54 63.94,73.42 71.33,66.03 75.37,66.03 76.39,65.01 76.39,64.23 77.77,62.85 79.18,62.85 79.96,62.08 81.1,62.08 81.45,61.73 v2(81.45,61.52)
  BOTTOM w0.102: v1(52.51,82.46) 52.51,82.54 52.09,82.96 CN5.54 ; U30.R27 81.45,62.63 v2(81.45,61.52)
M_A_DM3: length 45.8
  IN1 w0.089: v1(56.32,76.95) 56.32,76.64 56.41,76.55 57.58,76.55 59.04,75.08 59.04,74.96 58.81,74.72 58.81,74.59 58.93,74.47 59.06,74.47 59.3,74.7 59.42,74.7 59.55,74.58 59.55,74.45 59.31,74.21 59.31,74.09 59.43,73.96 59.56,73.96 59.8,74.2 59.92,74.2 60.05,74.08 60.05,73.95 59.81,73.71 59.81,73.59 59.94,73.46 60.06,73.46 60.3,73.7 60.43,73.7 60.55,73.57 60.55,73.45 60.31,73.21 60.31,73.08 60.44,72.96 60.57,72.96 60.8,73.2 60.93,73.2 61.06,73.07 61.06,72.94 60.82,72.71 60.82,72.58 60.94,72.45 61.07,72.45 61.31,72.69 61.43,72.69 61.56,72.57 61.56,72.44 61.32,72.2 61.32,72.08 61.45,71.95 61.57,71.95 61.81,72.19 61.94,72.19 62.06,72.06 62.06,71.94 61.82,71.7 61.82,71.57 61.95,71.45 62.07,71.45 62.31,71.69 62.44,71.69 62.56,71.56 62.56,71.44 62.33,71.2 62.33,71.07 62.45,70.95 62.58,70.95 62.82,71.18 62.94,71.18 63.07,71.06 63.07,70.93 62.83,70.69 62.83,70.57 62.95,70.44 63.08,70.44 63.32,70.68 63.44,70.68 71.53,62.6 75.25,62.6 78.27,59.58 79.79,59.58 80.34,59.03 82.02,59.03 82.22,59.23 82.93,59.23 83.6,58.56 v2(83.73,58.56)
  BOTTOM w0.102: U30.Y24 84.1,58.96 83.73,58.59 v2(83.73,58.56) ; CN5.75 57.08,77.71 v1(56.32,76.95)
M_A_DM4: length 38.5
  IN1 w0.089: v1(52.35,50.34) 52.35,49.94 52.64,49.64 53.48,49.64 54.66,50.82 57.07,50.82 57.59,50.3 57.59,49.52 61.28,45.83 63.8,45.83 65.61,44.02 69.26,44.02 69.64,43.65 71.28,43.65 71.66,44.02 79.18,44.02 80.47,45.31 81.02,45.31 82.19,46.48 v2(82.27,46.48)
  BOTTOM w0.102: CN5.178 51.18,49.96 51.24,49.9 51.91,49.9 v1(52.35,50.34) ; v2(82.27,46.48) 82.27,46.52 U30.AP27
M_A_DM5: length 40.7
  TOP w0.102: v1(56.32,45.1) 57.1,44.32 57.45,44.32 61.05,40.73 68.7,40.73 68.8,40.63 68.8,40.12 68.9,40.02 69.1,40.02 69.2,40.12 69.2,40.63 69.31,40.73 69.51,40.73 69.61,40.63 69.61,40.12 69.71,40.02 69.92,40.02 70.02,40.12 70.02,40.63 70.12,40.73 70.32,40.73 70.42,40.63 70.42,40.12 70.53,40.02 70.73,40.02 70.83,40.12 70.83,40.63 70.93,40.73 71.13,40.73 71.24,40.63 71.24,40.12 71.34,40.02 71.54,40.02 71.64,40.12 71.64,40.63 71.74,40.73 73.75,40.73 74.89,39.58 82.46,39.58 84.24,41.36 84.54,41.36 85,41.81 v2(85,42.44)
  BOTTOM w0.102: U30.AW23 84.51,43.02 84.99,42.54 84.99,42.45 v2(85,42.44) ; CN5.199 57.48,44.71 57.34,44.56 56.86,44.56 v1(56.32,45.1)
M_A_DM6: length 46.8
  IN1 w0.089: v1(53.51,39.01) 53.51,39.85 53.66,39.99 55.83,39.99 56.07,40.24 57.4,40.24 57.79,40.63 61.26,40.63 63.91,37.97 64.82,37.97 65.26,38.41 66.05,38.41 66.49,37.97 66.81,37.97 66.9,38.06 66.9,38.32 66.99,38.41 67.17,38.41 67.25,38.32 67.25,38.06 67.34,37.97 67.52,37.97 67.61,38.06 67.61,38.32 67.7,38.41 67.88,38.41 67.97,38.32 67.97,38.06 68.05,37.97 68.23,37.97 68.32,38.06 68.32,38.32 68.41,38.41 68.59,38.41 68.68,38.32 68.68,38.06 68.77,37.97 68.94,37.97 69.03,38.06 69.03,38.32 69.12,38.41 69.3,38.41 69.39,38.32 69.39,38.06 69.48,37.97 71.97,37.97 73.97,39.97 79.31,39.97 79.41,39.86 79.94,39.86 81.06,40.98 83.09,40.98 84.06,41.95 84.24,41.95 84.61,42.32 84.61,44.58 84.84,44.81 85.19,44.81 85.4,45.02 85.4,45.29 85.91,45.8 v2(85.91,45.95)
  BOTTOM w0.102: CN5.220 53.07,39.46 v1(53.51,39.01) ; U30.AT21 86.26,45.59 v2(85.91,45.95)
M_A_DM7: length 54.8
  IN1 w0.089: v1(56.44,33.91) 56.72,33.63 57.04,33.63 57.13,33.72 57.13,34.29 57.22,34.38 57.4,34.38 57.49,34.29 57.49,33.72 57.58,33.63 57.75,33.63 57.84,33.72 57.84,34.29 57.93,34.38 58.11,34.38 58.2,34.29 58.2,33.72 58.29,33.63 58.47,33.63 58.55,33.72 58.55,34.29 58.64,34.38 58.82,34.38 58.91,34.29 58.91,33.72 59,33.63 59.24,33.63 59.51,33.9 59.73,33.9 62.02,31.61 63.58,31.61 63.9,31.93 64.13,31.93 64.45,31.61 69.82,31.61 69.9,31.7 69.9,32.23 69.99,32.32 70.17,32.32 70.26,32.23 70.26,31.7 70.35,31.61 70.53,31.61 70.62,31.7 70.62,32.23 70.7,32.32 70.88,32.32 70.97,32.23 70.97,31.7 71.06,31.61 71.24,31.61 71.33,31.7 71.33,32.23 71.42,32.32 71.59,32.32 71.68,32.23 71.68,31.7 71.77,31.61 72.09,31.61 76.48,36 81.01,36 82.48,34.53 86.7,34.53 87.44,35.27 87.44,38.85 87.82,39.23 87.82,40.24 89.44,41.86 89.44,43.22 v2(89.04,43.63)
  BOTTOM w0.102: CN5.241 56.7,34.21 56.44,33.94 v1(56.44,33.91) ; v2(89.04,43.63) 89.04,43.64 89.39,43.99 U30.AV18
M_A_DQ0: length 47.9
  IN1 w0.089: v1(57.15,96.06) 57.83,95.38 57.95,95.38 58.46,95.89 58.59,95.89 58.71,95.77 58.71,95.64 58.21,95.13 58.21,95 58.33,94.88 58.46,94.88 58.97,95.39 59.09,95.39 59.22,95.26 59.22,95.14 58.71,94.63 58.71,94.5 58.83,94.38 58.96,94.38 59.47,94.89 59.6,94.89 59.72,94.76 59.72,94.63 59.21,94.12 59.21,94 59.5,93.71 61.5,93.71 76.11,79.11 79.18,79.11 80.96,77.33 80.96,73.52 80.5,73.05 80.5,69.39 81.36,68.52 v2(81.52,68.52)
  BOTTOM w0.102: v1(57.15,96.06) 57.51,95.71 CN5.3 ; v2(81.52,68.52) 81.53,68.51 81.53,68.38 81.81,68.1 U30.K27
M_A_DQ1: length 48.5
  IN1 w0.089: v2(82.18,67.52) 82.12,67.52 81.59,68.05 81.45,68.05 80.22,69.29 80.22,73.28 80.58,73.65 80.58,75.95 79.97,76.57 79.44,76.57 77.28,78.73 75.98,78.73 61.43,93.28 59.29,93.28 57.68,94.9 v1(52.35,94.9)
  BOTTOM w0.102: U30.L26 82.51,67.19 82.28,67.41 v2(82.18,67.52) ; CN5.8 51.9,94.46 v1(52.35,94.9)
M_A_DQ2: length 47.6
  IN1 w0.089: v2(82.15,65.54) 81.75,65.94 81.25,65.94 79.86,67.34 79.86,67.84 77.66,70.04 77.66,72.63 77.4,72.88 75.25,72.88 74.48,73.65 74.48,76.38 61.68,89.18 61.68,89.37 60.39,90.66 59.95,90.66 59.86,90.75 59.86,91.19 59.76,91.29 59.59,91.29 59.51,91.2 59.51,90.75 59.42,90.66 59.23,90.66 58.53,91.36 57.66,91.36 57.49,91.53 57.49,91.87 57.21,92.14 55.1,92.14 55.01,92.06 v1(55.01,91.72)
  BOTTOM w0.102: v1(55.01,91.72) 55.49,92.21 CN5.17 ; U30.N26 82.15,65.34 v2(82.15,65.54)
M_A_DQ3: length 47.5
  IN1 w0.089: v2(81.51,65.54) 81.3,65.54 79.49,67.35 79.49,67.9 77.33,70.07 77.33,72.33 77.15,72.5 75.12,72.5 73.98,73.65 73.98,76.44 65.14,85.28 64.35,85.28 63.97,85.66 63.97,85.79 64.24,86.05 64.24,86.18 64.11,86.31 63.98,86.31 63.71,86.04 63.59,86.04 63.46,86.16 63.46,86.29 63.73,86.56 63.73,86.68 63.61,86.81 63.48,86.81 63.21,86.54 63.09,86.54 62.96,86.67 62.96,86.79 63.23,87.06 63.23,87.19 63.1,87.31 62.98,87.31 62.71,87.04 62.58,87.04 62.46,87.17 62.46,87.29 62.73,87.56 62.73,87.69 62.6,87.81 62.48,87.81 62.21,87.55 62.08,87.55 61.95,87.67 61.95,87.8 62.22,88.07 62.22,88.19 62.1,88.32 61.97,88.32 61.7,88.05 61.58,88.05 61.35,88.27 61.35,89.25 60.32,90.28 59.16,90.28 58.4,91.05 56.7,91.05 56.43,91.32 v1(56.43,91.72)
  BOTTOM w0.102: U30.N27 81.81,65.24 v2(81.51,65.54) ; CN5.21 56.95,91.21 v1(56.43,91.72)
M_A_DQ4: length 48
  IN1 w0.089: v1(52.26,96) 54.8,96 56.03,96.78 59.4,96.78 76.31,79.87 79.44,79.87 81.72,77.58 81.72,73.27 81.08,72.62 81.08,70.71 v2(81.37,70.42)
  BOTTOM w0.102: v1(52.26,96) 51.72,95.46 CN5.4 ; U30.G27 v2(81.37,70.42)
M_A_DQ5: length 48.2
  IN1 w0.089: v1(55.73,96.07) 56.12,96.46 59.26,96.46 59.49,96.24 59.49,96.11 59.31,95.93 59.31,95.81 59.43,95.68 59.56,95.68 59.74,95.86 59.87,95.86 59.99,95.73 59.99,95.61 59.81,95.43 59.81,95.3 59.94,95.18 60.06,95.18 60.24,95.36 60.37,95.36 60.49,95.23 60.49,95.11 60.31,94.93 60.31,94.8 60.44,94.67 60.57,94.67 60.75,94.85 60.87,94.85 76.24,79.49 79.31,79.49 81.34,77.46 81.34,73.39 80.71,72.76 80.71,70.53 81.51,69.73 v2(81.51,69.49)
  BOTTOM w0.102: U30.H27 81.61,68.99 81.4,69.19 81.4,69.39 v2(81.51,69.49) ; v1(55.73,96.07) 56.17,95.62 57.33,94.71 CN5.7
M_A_DQ6: length 47.7
  IN1 w0.089: v2(81.51,66.54) 81.27,66.54 80.55,67.26 80.55,67.76 78.42,69.89 78.42,74.41 77.15,75.68 76.42,75.68 60.1,92 58.38,92 57.6,92.78 54.33,92.78 54.16,92.95 54.16,93.84 53.91,94.09 53.66,94.09 52.93,93.37 v1(52.93,93.05)
  BOTTOM w0.102: U30.M27 81.81,66.24 v2(81.51,66.54) ; v1(52.93,93.05) 52.34,92.46 CN5.16
M_A_DQ7: length 48.7
  IN1 w0.089: v2(83.7,65.54) 83.7,65.7 83.26,66.14 81.36,66.14 80.32,67.18 80.32,67.67 78.04,69.95 78.04,74.28 77.02,75.3 76.2,75.3 59.82,91.68 58.25,91.68 57.47,92.46 54.06,92.46 53.57,91.97 v1(52.24,91.97)
  BOTTOM w0.102: U30.N24 84.1,65.14 v2(83.7,65.54) ; CN5.20 51.72,91.46 v1(52.24,91.97)
M_A_DQ8: length 51.9
  IN1 w0.089: v1(53.52,90.07) 53.87,90.43 55.56,90.43 55.96,90.03 57.97,90.03 59.05,88.96 60.02,88.96 60.16,88.82 60.16,87.97 64.01,84.12 64.39,84.12 64.64,83.87 64.64,81.85 65.82,80.67 65.95,80.67 66.07,80.79 66.2,80.79 66.32,80.66 66.32,80.54 66.2,80.41 66.2,80.29 66.33,80.16 66.45,80.16 66.58,80.29 66.7,80.29 66.83,80.16 66.83,80.03 66.7,79.91 66.7,79.79 66.83,79.66 66.95,79.66 67.08,79.78 67.2,79.78 67.33,79.66 67.33,79.53 67.21,79.41 67.21,79.28 67.33,79.16 67.46,79.16 67.58,79.28 67.71,79.28 67.83,79.15 67.83,79.03 67.71,78.9 67.71,78.78 67.83,78.65 67.96,78.65 68.08,78.78 68.21,78.78 68.34,78.65 68.34,78.53 68.21,78.4 68.21,78.28 72.9,73.58 72.9,72.89 78.64,67.16 78.95,67.16 81.18,64.93 82.38,64.93 82.64,65.18 83.16,65.18 83.41,64.93 83.98,64.93 84.33,65.28 84.33,66.37 v2(84.48,66.52)
  BOTTOM w0.102: v2(84.48,66.52) 84.91,66.94 U30.L23 ; CN5.28 52.9,89.46 v1(53.52,90.07)
M_A_DQ9: length 52.5
  IN1 w0.089: v1(55.81,89.01) 56.11,89.31 57.78,89.31 63.82,83.28 63.82,81.08 64.04,80.85 64.17,80.85 64.39,81.08 64.51,81.08 64.64,80.95 64.64,80.82 64.42,80.6 64.42,80.48 64.54,80.35 64.67,80.35 64.89,80.57 65.02,80.57 65.14,80.45 65.14,80.32 64.92,80.1 64.92,79.97 65.05,79.85 65.17,79.85 65.39,80.07 65.52,80.07 65.65,79.94 65.65,79.82 65.42,79.6 65.42,79.47 65.55,79.35 65.68,79.35 65.9,79.57 66.02,79.57 66.15,79.44 66.15,79.32 65.93,79.09 65.93,78.97 66.05,78.84 66.18,78.84 66.34,79 66.46,79 66.59,78.88 66.59,78.75 66.43,78.59 66.43,78.47 66.56,78.34 66.68,78.34 66.84,78.5 66.96,78.5 67.09,78.37 67.09,78.25 66.93,78.09 66.93,77.96 67.06,77.84 67.18,77.84 67.34,78 67.47,78 67.59,77.87 67.59,77.74 67.44,77.59 67.44,77.46 78.24,66.66 78.83,66.66 79.85,65.64 79.85,64.82 80.77,63.91 81.78,63.91 81.99,64.11 82.95,64.11 83.36,64.52 84.18,64.52 84.76,65.1 84.76,65.63 85.12,65.99 85.6,65.99 v2(86.06,65.53)
  BOTTOM w0.102: v1(55.81,89.01) 56.17,89.37 57.36,89.37 57.53,89.21 CN5.29 ; v2(86.06,65.53) 86.51,65.09 U30.N21
M_A_DQ10: length 52.2
  IN1 w0.089: v2(85.9,62.49) 85.48,62.92 85.04,62.92 84.68,63.28 84.36,63.28 84.03,62.94 82.58,62.94 82.45,62.81 80.43,62.81 78.86,64.39 78.23,64.39 74.69,67.93 73.21,67.93 62.04,79.11 62.04,82.09 61.44,82.69 61.44,82.82 61.6,82.98 61.6,83.1 61.47,83.23 61.35,83.23 61.18,83.07 61.06,83.07 60.93,83.19 60.93,83.32 61.09,83.48 61.09,83.61 60.97,83.73 60.84,83.73 60.68,83.57 60.56,83.57 60.43,83.7 60.43,83.82 60.59,83.98 60.59,84.11 60.47,84.23 60.34,84.23 60.18,84.07 60.05,84.07 58.04,86.09 58.04,86.66 57.24,87.46 54.87,87.46 54.78,87.37 54.78,87.2 54.69,87.11 54.51,87.11 54.42,87.2 54.42,87.37 54.33,87.46 54.02,87.46 v1(53.14,86.59)
  BOTTOM w0.102: CN5.42 52.51,85.96 v1(53.14,86.59) ; U30.T21 86.4,61.99 v2(85.9,62.49)
M_A_DQ11: length 52.5
  IN1 w0.089: v2(86.01,61.44) 86.01,61.62 85.65,61.98 82.1,61.98 81.74,62.33 80.31,62.33 79.28,63.36 78.34,63.36 74.53,67.17 72.96,67.17 61.28,78.85 61.28,81.2 60.64,81.83 60.52,81.83 60.11,81.42 59.98,81.42 59.85,81.55 59.85,81.67 60.27,82.08 60.27,82.21 60.14,82.33 60.01,82.33 59.6,81.92 59.48,81.92 59.35,82.05 59.35,82.17 59.76,82.59 59.76,82.71 59.64,82.84 59.51,82.84 59.1,82.43 58.97,82.43 58.85,82.55 58.85,82.68 59.26,83.09 59.26,83.21 59.13,83.34 59.01,83.34 58.6,82.93 58.47,82.93 58.35,83.05 58.35,83.18 58.76,83.59 58.76,83.72 58.63,83.84 58.51,83.84 58.09,83.43 57.97,83.43 57.84,83.56 57.84,83.68 58.25,84.09 58.25,84.22 58.13,84.35 58,84.35 57.59,83.93 57.47,83.93 57.34,84.06 57.34,84.19 57.75,84.6 57.75,84.72 57.4,85.07 57.4,85.65 v1(56.45,86.6)
  BOTTOM w0.102: v1(56.45,86.6) 56.9,86.15 57.53,86.15 57.58,86.21 CN5.41 ; U30.T22 86.01,61.69 v2(86.01,61.44)
M_A_DQ12: length 52.2
  IN1 w0.089: v2(85.25,66.41) 84.53,65.69 84.53,65.18 84.06,64.71 83.35,64.71 83.07,64.98 82.72,64.98 82.3,64.57 82.12,64.57 81.66,64.11 80.85,64.11 80.06,64.9 80.06,65.75 78.9,66.92 78.43,66.92 70.12,75.23 70.12,75.35 70.34,75.57 70.34,75.7 70.21,75.83 70.09,75.83 69.87,75.6 69.74,75.6 69.61,75.73 69.61,75.86 69.84,76.08 69.84,76.2 69.71,76.33 69.58,76.33 69.36,76.11 69.24,76.11 69.11,76.23 69.11,76.36 69.33,76.58 69.33,76.71 69.21,76.83 69.08,76.83 68.86,76.61 68.73,76.61 68.61,76.74 68.61,76.86 68.83,77.08 68.83,77.21 68.7,77.33 68.58,77.33 68.36,77.11 68.23,77.11 68.01,77.34 68.01,78.03 64.13,81.91 64.13,83.41 57.91,89.63 55.15,89.63 v1(54.76,90.02)
  BOTTOM w0.102: CN5.25 56.53,90.21 56.25,90.48 55.22,90.48 v1(54.76,90.02) ; v2(85.25,66.41) 85.68,65.99 U30.M22
M_A_DQ13: length 51.8
  IN1 w0.089: v2(83.7,67.44) 84.1,67.03 84.1,65.33 83.9,65.13 83.49,65.13 83.32,65.3 83.32,65.76 83.13,65.94 82.74,65.94 82.53,65.74 82.53,65.36 82.3,65.13 81.33,65.13 79.18,67.28 79.18,67.93 75.76,71.36 74.89,71.36 73.22,73.04 73.22,74.27 65.97,81.52 65.97,83.45 64.84,84.58 64.06,84.58 60.49,88.15 60.49,88.94 60.15,89.27 59.18,89.27 58.11,90.35 56.09,90.35 55.69,90.75 52.92,90.75 v1(52.25,90.07)
  BOTTOM w0.102: U30.L24 84.1,67.03 v2(83.7,67.44) ; v1(52.25,90.07) 51.78,90.54 51.31,90.54 51.23,90.46 CN5.24
M_A_DQ14: length 52.5
  IN1 w0.089: v1(52.36,86.58) 53.58,87.8 57.35,87.8 58.52,86.63 58.52,86.51 58.35,86.35 58.35,86.22 58.48,86.09 58.61,86.09 58.77,86.26 58.89,86.26 59.02,86.13 59.02,86 58.86,85.84 58.86,85.72 58.98,85.59 59.11,85.59 59.27,85.75 59.4,85.75 59.52,85.63 59.52,85.5 59.36,85.34 59.36,85.21 59.49,85.09 59.61,85.09 59.77,85.25 59.9,85.25 60.03,85.12 60.03,85 59.86,84.84 59.86,84.71 59.99,84.59 60.11,84.59 60.28,84.75 60.4,84.75 62.44,82.71 62.44,79.21 73.39,68.26 74.81,68.26 78.46,64.62 78.91,64.62 80.49,63.04 82.3,63.04 82.4,63.14 83.95,63.14 84.28,63.47 84.76,63.47 85.12,63.12 85.71,63.12 v2(86.08,63.49)
  BOTTOM w0.102: v2(86.08,63.49) 86.51,63.07 U30.R21 ; CN5.38 51.27,86.96 51.37,87.06 51.88,87.06 v1(52.36,86.58)
M_A_DQ15: length 52.3
  IN1 w0.089: v2(85.32,62.48) 85.02,62.18 82.35,62.18 81.94,62.59 80.34,62.59 79.31,63.61 78.51,63.61 74.57,67.55 73.09,67.55 61.72,78.92 61.72,81.96 60.99,82.69 60.86,82.69 60.61,82.44 60.49,82.44 60.36,82.56 60.36,82.69 60.61,82.94 60.61,83.06 60.49,83.19 60.36,83.19 60.11,82.94 59.98,82.94 59.86,83.07 59.86,83.19 60.11,83.44 60.11,83.57 59.98,83.69 59.86,83.69 59.61,83.44 59.48,83.44 59.35,83.57 59.35,83.69 59.61,83.95 59.61,84.07 59.48,84.2 59.35,84.2 59.1,83.95 58.98,83.95 58.85,84.07 58.85,84.2 59.1,84.45 59.1,84.57 58.98,84.7 58.85,84.7 58.6,84.45 58.47,84.45 58.35,84.57 58.35,84.7 58.6,84.95 58.6,85.08 58.47,85.2 58.35,85.2 58.1,84.95 57.97,84.95 57.85,85.08 57.85,85.2 58.1,85.45 58.1,85.58 57.72,85.96 57.72,86.53 57.14,87.11 55.69,87.11 v1(55.18,86.6)
  BOTTOM w0.102: v1(55.18,86.6) 55.79,87.21 CN5.37 ; v2(85.32,62.48) 85.32,62.52 84.91,62.94 U30.R23
M_A_DQ16: length 45.1
  TOP w0.102: v1(55.04,84.61) 55.48,84.16 59.27,84.16 61.74,81.69 61.74,81.55 61.55,81.35 61.55,81.21 61.69,81.07 61.83,81.07 62.03,81.26 62.17,81.26 62.32,81.12 62.32,80.97 62.12,80.78 62.12,80.63 62.27,80.49 62.41,80.49 62.6,80.68 62.75,80.68 62.89,80.54 62.89,80.4 62.7,80.2 62.7,80.06 62.84,79.92 62.98,79.92 63.18,80.11 63.32,80.11 63.47,79.97 63.47,79.82 63.27,79.63 63.27,79.48 63.42,79.34 63.56,79.34 63.75,79.53 63.9,79.53 70.29,73.14 71.44,73.14 75.2,69.38 75.2,68.64 78.82,65.02 79.28,65.02 80.43,63.87 83.43,63.87 v2(83.77,63.53)
  BOTTOM w0.102: v2(83.77,63.53) 83.77,63.66 U30.P24 ; CN5.49 57.48,84.21 57.34,84.06 55.58,84.06 v1(55.04,84.61)
M_A_DQ17: length 45.7
  TOP w0.102: v1(52.23,84.57) 53,83.81 58.48,83.81 58.77,83.51 58.92,83.51 59.09,83.69 59.24,83.69 59.38,83.54 59.38,83.4 59.21,83.23 59.21,83.08 59.35,82.94 59.49,82.94 59.67,83.11 59.81,83.11 59.95,82.97 59.95,82.82 59.78,82.65 59.78,82.51 59.92,82.36 60.07,82.36 60.24,82.54 60.39,82.54 60.53,82.39 60.53,82.25 60.36,82.08 60.36,81.93 60.5,81.79 60.64,81.79 60.82,81.96 60.96,81.96 61.1,81.82 61.1,81.67 60.93,81.5 60.93,81.36 69.61,72.68 71.39,72.68 74.86,69.2 74.86,68.41 78.65,64.62 79.05,64.62 80.31,63.36 82.06,63.36 v2(82.86,62.56)
  BOTTOM w0.102: CN5.50 51.66,83.96 52.23,84.53 v1(52.23,84.57) ; v2(82.86,62.56) 82.86,62.64 U30.R26
M_A_DQ18: length 44.6
  TOP w0.102: v1(56.32,81.39) 56.75,80.96 57.94,80.96 62.16,76.73 62.16,76.4 62.27,76.3 63.46,76.3 63.56,76.2 63.56,76 63.46,75.9 62.27,75.9 62.16,75.8 62.16,75.59 62.27,75.49 63.46,75.49 63.56,75.39 63.56,75.19 63.46,75.08 62.27,75.08 62.16,74.98 62.16,74.73 62.36,74.54 62.8,74.54 63.21,74.12 63.21,73.68 71.2,65.7 75.24,65.7 76.06,64.87 76.06,63.98 77.55,62.49 78.91,62.49 79.8,61.6 80.21,61.6 80.7,61.11 81.82,61.11 v2(82.22,61.52)
  BOTTOM w0.102: U30.T27 81.81,61.94 v2(82.22,61.52) ; CN5.59 57.53,81.71 57.34,81.9 56.83,81.9 v1(56.32,81.39)
M_A_DQ19: length 44.7
  TOP w0.102: v2(82.12,60.55) 80.51,60.55 79.86,61.2 77.28,61.2 75.73,62.75 75.73,64.74 75.1,65.37 71.04,65.37 61.2,75.2 61.2,75.91 61.3,76.01 61.68,76.01 61.78,76.12 61.78,76.32 61.68,76.42 61.3,76.42 61.2,76.52 61.2,77.01 57.59,80.63 54.01,80.63 53.55,81.09 v1(53.55,81.44)
  BOTTOM w0.102: CN5.58 53.04,81.96 v1(53.55,81.44) ; v2(82.12,60.55) 81.81,60.87 U30.V27
M_A_DQ20: length 45.5
  TOP w0.102: v1(53.54,84.58) 54.41,85.46 58.02,85.46 58.41,85.07 60.48,85.07 65.72,79.83 65.72,79.69 65.27,79.24 65.27,79.1 65.41,78.96 65.56,78.96 66,79.4 66.15,79.4 66.29,79.26 66.29,79.11 65.84,78.67 65.84,78.52 65.99,78.38 66.13,78.38 66.58,78.83 66.72,78.83 75.08,70.47 75.12,70.47 78.43,67.16 79.07,67.16 81.23,65 82.1,65 82.5,64.59 v2(82.88,64.59)
  BOTTOM w0.102: CN5.46 51.25,84.96 51.3,85.01 53.11,85.01 v1(53.54,84.58) ; U30.P25 83.31,64.12 82.88,64.54 v2(82.88,64.59)
M_A_DQ21: length 45.3
  TOP w0.102: v1(56.43,84.61) 56.9,85.08 57.83,85.08 58.24,84.67 59.23,84.67 59.57,84.33 59.72,84.33 59.99,84.6 60.13,84.6 60.27,84.45 60.27,84.31 60,84.04 60,83.9 60.15,83.75 60.29,83.75 60.56,84.02 60.7,84.02 60.85,83.88 60.85,83.73 60.58,83.46 60.58,83.32 60.72,83.18 60.87,83.18 61.14,83.45 61.28,83.45 61.42,83.3 61.42,83.16 61.15,82.89 61.15,82.75 61.3,82.6 61.44,82.6 61.71,82.87 61.85,82.87 62,82.73 62,82.58 61.73,82.31 61.73,82.17 61.87,82.03 62.02,82.03 62.29,82.3 62.43,82.3 62.57,82.15 62.57,82.01 62.3,81.74 62.3,81.59 62.45,81.45 62.59,81.45 62.86,81.72 63,81.72 63.15,81.58 63.15,81.43 62.88,81.16 62.88,81.02 63.02,80.88 63.17,80.88 63.44,81.15 63.58,81.15 63.72,81 63.72,80.86 63.45,80.59 63.45,80.44 63.6,80.3 63.74,80.3 64.01,80.57 64.16,80.57 64.3,80.43 64.3,80.28 64.03,80.01 64.03,79.87 64.17,79.73 64.32,79.73 64.59,80 64.73,80 64.87,79.85 64.87,79.71 64.6,79.44 64.6,79.29 70.43,73.47 71.61,73.47 78.5,66.59 78.73,66.59 79.68,65.63 79.68,65.25 80.45,64.49 81.5,64.49 v2(81.51,64.49)
  BOTTOM w0.102: v1(56.43,84.61) 57.03,85.21 CN5.45 ; v2(81.51,64.49) 81.51,64.29 U30.P27
M_A_DQ22: length 45.5
  TOP w0.102: v2(84.51,60.55) 84.03,60.07 83.64,60.07 83.31,59.74 80.19,59.74 79.53,60.4 77.14,60.4 75.07,62.48 75.07,63.44 74.48,64.02 71.03,64.02 69.84,65.21 69.84,65.58 59.95,75.47 59.95,75.5 60.18,75.74 60.18,75.88 60.04,76.02 59.9,76.02 59.63,75.76 59.49,75.76 59.34,75.9 59.34,76.04 59.61,76.31 59.61,76.46 59.47,76.6 59.32,76.6 59.05,76.33 58.91,76.33 58.77,76.47 58.77,76.62 59.03,76.89 59.03,77.03 58.89,77.17 58.75,77.17 58.48,76.91 58.33,76.91 58.1,77.14 58.1,78.98 57.72,79.36 56.32,79.36 v1(55.81,79.86)
  BOTTOM w0.102: v1(55.81,79.86) 56.66,80.71 CN5.63 ; v2(84.51,60.55) 84.91,60.95 U30.V23
M_A_DQ23: length 45.9
  TOP w0.102: v2(83.71,61.54) 83.26,61.09 83.26,60.35 83.05,60.14 80.36,60.14 79.7,60.8 77.21,60.8 75.4,62.61 75.4,63.59 74.64,64.35 71.21,64.35 70.17,65.39 70.17,65.74 60.8,75.11 60.8,76.85 57.35,80.3 53.38,80.3 v1(52.25,81.44)
  BOTTOM w0.102: U30.T25 83.31,61.96 83.71,61.56 v2(83.71,61.54) ; v1(52.25,81.44) 51.76,80.96 CN5.62
M_A_DQ24: length 46.5
  IN1 w0.089: v2(85.3,60.62) 84.99,60.93 80.92,60.93 79,62.85 77.84,62.85 74.85,65.84 70.9,65.84 67.07,69.66 67.07,70.64 62.92,74.79 62.8,74.79 62.32,74.31 62.19,74.31 62.07,74.44 62.07,74.56 62.55,75.04 62.55,75.17 62.42,75.29 62.3,75.29 61.82,74.81 61.69,74.81 61.57,74.94 61.57,75.07 62.04,75.54 62.04,75.67 61.92,75.8 61.79,75.8 61.31,75.32 61.19,75.32 61.06,75.44 61.06,75.57 61.54,76.05 61.54,76.17 61.42,76.3 61.29,76.3 60.81,75.82 60.69,75.82 60.56,75.95 60.56,76.07 61.04,76.55 61.04,76.68 60.91,76.8 60.79,76.8 60.31,76.32 60.18,76.32 60.06,76.45 60.06,76.58 60.54,77.05 60.54,77.18 57.85,79.86 v1(57.08,79.86)
  BOTTOM w0.102: v2(85.3,60.62) 85.7,60.22 U30.W22 ; v1(57.08,79.86) 57.24,79.71 CN5.67
M_A_DQ25: length 45.7
  IN1 w0.089: v1(57.08,78.71) 57.08,78.52 62.44,73.17 62.56,73.17 62.92,73.53 63.04,73.53 63.17,73.4 63.17,73.28 62.81,72.92 62.81,72.8 62.94,72.67 63.06,72.67 63.42,73.03 63.55,73.03 63.67,72.9 63.67,72.78 63.32,72.42 63.32,72.29 63.44,72.17 63.57,72.17 63.92,72.52 64.05,72.52 64.17,72.4 64.17,72.27 63.82,71.92 63.82,71.79 63.94,71.66 64.07,71.66 64.43,72.02 64.55,72.02 64.68,71.9 64.68,71.77 64.32,71.41 64.32,71.29 64.45,71.16 64.57,71.16 64.77,71.36 64.93,71.52 65.05,71.52 65.18,71.39 65.18,71.27 64.82,70.91 64.82,70.78 64.95,70.66 65.08,70.66 65.43,71.02 65.56,71.02 65.68,70.89 65.68,70.76 65.33,70.41 65.33,70.28 65.45,70.16 65.58,70.16 65.64,70.22 65.94,70.51 66.06,70.51 66.19,70.39 66.19,70.26 66.14,70.22 65.83,69.9 65.83,69.78 71.23,64.38 75.63,64.38 77.63,62.37 78.88,62.37 81.27,59.97 84.09,59.97 v2(84.5,59.56)
  BOTTOM w0.102: U30.Y23 84.91,59.15 v2(84.5,59.56) ; CN5.71 v1(57.08,78.71)
M_A_DQ26: length 46
  IN1 w0.089: v1(55.18,75.01) 55.77,75.6 57.17,75.6 57.72,75.05 57.72,73.89 58.81,72.8 58.81,72.68 58.62,72.49 58.62,72.36 58.75,72.24 58.87,72.24 59.06,72.42 59.19,72.42 59.31,72.3 59.31,72.17 59.13,71.99 59.13,71.86 59.25,71.73 59.38,71.73 59.56,71.92 59.69,71.92 59.82,71.79 59.82,71.67 59.63,71.48 59.63,71.36 59.75,71.23 59.88,71.23 60.07,71.42 60.19,71.42 60.65,70.96 60.65,70.84 60.46,70.65 60.46,70.52 60.59,70.4 60.71,70.4 60.9,70.58 61.03,70.58 61.15,70.46 61.15,70.33 60.97,70.15 60.97,70.02 61.09,69.89 61.22,69.89 61.4,70.08 61.53,70.08 61.66,69.95 61.66,69.83 61.47,69.64 61.47,69.52 61.59,69.39 61.72,69.39 61.91,69.58 62.03,69.58 62.35,69.26 63.51,69.26 71.7,61.07 75.5,61.07 77.79,58.79 79.12,58.79 79.82,58.09 81.92,58.09 82.1,57.92 83.16,57.92 83.52,57.56 v2(83.72,57.56)
  BOTTOM w0.102: v2(83.72,57.56) 84.1,57.17 U30.AC24 ; CN5.79 57.6,76.71 57.08,76.19 55.81,76.19 55.18,75.55 v1(55.18,75.01)
M_A_DQ27: length 46.3
  IN1 w0.089: v1(52.27,74.96) 52.82,74.41 53.78,74.41 55.29,75.91 57.31,75.91 58.04,75.18 58.04,74.02 59.71,72.35 59.84,72.35 59.93,72.44 60.06,72.44 60.18,72.32 60.18,72.19 60.09,72.1 60.09,71.97 60.22,71.84 60.34,71.84 60.44,71.94 60.56,71.94 60.69,71.81 60.69,71.69 60.59,71.59 60.59,71.47 60.72,71.34 60.84,71.34 60.94,71.44 61.06,71.44 61.19,71.31 61.19,71.18 61.1,71.09 61.1,70.96 62.48,69.58 63.64,69.58 71.38,61.84 75.25,61.84 78.04,59.04 79.31,59.04 79.96,58.39 82.1,58.39 82.35,58.14 83.26,58.14 83.44,57.96 84.84,57.96 v2(85.27,57.53)
  BOTTOM w0.102: U30.AC23 84.91,57.17 v2(85.27,57.53) ; v1(52.27,74.96) 51.78,75.46 CN5.84
M_A_DQ28: length 46.3
  IN1 w0.089: v1(52.39,79.86) 53.13,80.61 57.74,80.61 67.47,70.88 67.47,69.86 71.18,66.15 74.97,66.15 78.01,63.11 79.18,63.11 80.34,61.95 81.59,61.95 81.84,61.7 81.84,61.32 82.02,61.14 85.48,61.14 v2(86.11,60.51)
  BOTTOM w0.102: v2(86.11,60.51) 86.51,60.91 U30.V21 ; v1(52.39,79.86) 51.95,80.3 51.56,80.3 51.22,79.96 CN5.66
M_A_DQ29: length 46.1
  IN1 w0.089: v2(86.01,59.54) 86.01,59.72 85.55,60.17 81.35,60.17 78.93,62.6 77.81,62.6 75.02,65.39 70.81,65.39 66.63,69.57 66.63,70.64 63.42,73.85 62.21,73.85 57.72,78.34 57.72,78.85 57.32,79.25 52.81,79.25 v1(52.26,78.71)
  BOTTOM w0.102: v1(52.26,78.71) 51.83,79.14 51.43,79.14 51.24,78.96 CN5.70 ; U30.W21 86.05,59.54 v2(86.01,59.54)
M_A_DQ30: length 46
  IN1 w0.089: v2(84.52,57.57) 84.07,57.11 82.36,57.11 81.7,57.77 79.69,57.77 78.93,58.53 77.66,58.53 75.45,60.74 71.58,60.74 63.37,68.95 61.05,68.95 60.83,69.17 60.83,69.3 60.97,69.44 60.97,69.57 60.84,69.69 60.72,69.69 60.57,69.55 60.45,69.55 60.32,69.68 60.32,69.8 60.47,69.94 60.47,70.07 60.34,70.2 60.21,70.2 60.07,70.05 59.95,70.05 59.2,70.8 59.2,70.93 59.34,71.07 59.34,71.19 59.22,71.32 59.09,71.32 58.95,71.18 58.82,71.18 58.7,71.3 58.7,71.43 58.84,71.57 58.84,71.7 58.71,71.82 58.59,71.82 58.44,71.68 58.32,71.68 58.19,71.81 58.19,71.93 58.34,72.07 58.34,72.2 58.21,72.33 58.08,72.33 57.94,72.18 57.82,72.18 57.59,72.41 57.59,72.53 58.05,72.99 58.05,73.11 57.92,73.24 57.79,73.24 57.06,72.5 56.58,72.5 56.49,72.59 56.49,74.09 56.58,74.18 57.32,74.18 57.41,74.27 57.41,74.45 57.32,74.54 56.58,74.54 56.49,74.63 v1(56.49,74.97)
  BOTTOM w0.102: U30.AA24 v2(84.52,57.57) ; CN5.83 57.17,75.71 56.49,75.02 v1(56.49,74.97)
M_A_DQ31: length 46.5
  IN1 w0.089: v2(85.29,58.54) 84.91,58.17 83.54,58.17 83.24,58.47 83.24,58.63 82.86,59 82.48,59 82.2,58.72 80.26,58.72 79.69,59.3 78.17,59.3 75.25,62.22 71.45,62.22 63.77,69.9 63.05,69.9 59.97,72.98 59.84,72.98 59.75,72.89 59.62,72.89 59.49,73.01 59.49,73.14 59.59,73.23 59.59,73.36 59.46,73.49 59.34,73.49 59.24,73.39 59.12,73.39 58.99,73.52 58.99,73.64 59.09,73.74 59.09,73.86 58.96,73.99 58.84,73.99 58.74,73.89 58.62,73.89 58.49,74.02 58.49,74.15 58.58,74.24 58.58,74.37 58.36,74.59 58.36,75.31 57.44,76.23 55.1,76.23 53.83,74.96 v1(53.57,74.96)
  BOTTOM w0.102: U30.AA22 85.7,58.12 v2(85.29,58.54) ; v1(53.57,74.96) 52.07,76.46 CN5.80
M_A_DQ32: length 38.4
  IN1 w0.089: v1(55.67,51.57) 55.67,51.88 55.76,51.97 57.35,51.97 61.76,47.55 61.76,47.19 62.11,46.85 64.13,46.85 65.35,45.62 67.83,45.62 67.92,45.53 67.92,45.1 68.01,45.01 68.19,45.01 68.28,45.1 68.28,45.53 68.36,45.62 68.54,45.62 68.63,45.53 68.63,45.1 68.72,45.01 68.9,45.01 68.99,45.1 68.99,45.53 69.08,45.62 69.25,45.62 69.34,45.53 69.34,45.16 69.43,45.07 69.61,45.07 69.7,45.16 69.7,45.53 69.79,45.62 69.96,45.62 70.05,45.53 70.05,45.16 70.14,45.07 70.32,45.07 70.41,45.16 70.41,45.53 70.5,45.62 70.82,45.62 71.24,45.2 79.51,45.2 80.5,46.19 80.61,46.19 81.51,47.09 81.74,47.09 82.12,47.47 v2(82.22,47.47)
  BOTTOM w0.102: v2(82.22,47.47) 82.51,47.19 U30.AP26 ; v1(55.67,51.57) 56.2,51.04 57.08,51.04 57.25,51.21 CN5.173
M_A_DQ33: length 39.2
  IN1 w0.089: v1(53.62,50.35) 54.41,51.14 57.2,51.14 57.97,50.37 57.97,50.08 61.84,46.21 63.87,46.21 65.72,44.36 69.15,44.36 69.2,44.41 72.51,44.41 72.71,44.22 79.09,44.22 80.55,45.67 81.09,45.67 81.9,46.47 81.9,46.69 82.07,46.86 82.55,46.86 82.78,47.09 83.24,47.09 83.6,47.46 v2(83.6,47.49)
  BOTTOM w0.102: v1(53.62,50.35) 53.01,50.96 CN5.174 ; v2(83.6,47.49) U30.AN24
M_A_DQ34: length 39
  IN1 w0.089: v2(82.98,45.42) 82.96,45.42 82.55,45.01 82.05,45.01 81.79,44.75 81.79,44.42 81,43.64 80.19,43.64 79.23,42.68 77.05,42.68 76.94,42.57 72.46,42.57 72.08,42.19 68.64,42.19 68.17,42.66 64.97,42.66 63.19,44.44 62.88,44.44 62.79,44.35 62.79,43.83 62.7,43.74 62.52,43.74 62.43,43.83 62.43,44.35 62.34,44.44 62.16,44.44 62.08,44.35 62.08,43.83 61.99,43.74 61.81,43.74 61.72,43.83 61.72,44.35 61.63,44.44 59.88,44.44 56.83,47.48 55.79,47.48 v1(54.93,48.35)
  BOTTOM w0.102: v2(82.98,45.42) 82.98,45.67 U30.AR25 ; CN5.183 57.39,48.71 57.29,48.8 55.38,48.8 v1(54.93,48.35)
M_A_DQ35: length 38.6
  IN1 w0.089: v1(52.39,48.35) 53.77,46.98 54.04,46.98 55.27,45.74 57.55,45.74 60.51,42.79 63.95,42.79 65.22,41.52 72.45,41.52 72.87,41.93 76.6,41.93 76.9,41.64 78.29,41.64 78.34,41.69 79.23,41.69 79.94,42.4 80.45,42.4 80.83,42.79 81.21,42.79 81.47,42.53 82.03,42.53 82.38,42.87 82.38,44.37 v2(82.17,44.57)
  BOTTOM w0.102: U30.AU26 82.51,44.98 82.17,44.65 v2(82.17,44.57) ; v1(52.39,48.35) 51.9,47.86 51.38,47.86 51.29,47.96 CN5.186
M_A_DQ36: length 37.9
  IN1 w0.089: v1(56.97,51.57) 57.3,51.57 58.29,50.58 58.29,50.22 58.52,49.99 58.64,49.99 58.7,50.05 58.82,50.05 58.95,49.92 58.95,49.79 58.89,49.74 58.89,49.61 59.02,49.49 59.15,49.49 59.2,49.54 59.33,49.54 59.45,49.42 59.45,49.29 59.4,49.24 59.4,49.11 59.52,48.98 59.65,48.98 59.7,49.04 59.83,49.04 59.96,48.91 59.96,48.79 59.9,48.73 59.9,48.61 60.03,48.48 60.15,48.48 60.21,48.54 60.33,48.54 60.46,48.41 60.46,48.29 60.4,48.23 60.4,48.1 60.53,47.98 60.65,47.98 60.71,48.03 60.84,48.03 60.96,47.91 60.96,47.78 60.91,47.73 60.91,47.6 61.02,47.48 61.31,47.48 61.45,47.35 61.45,47.06 61.98,46.53 64,46.53 65.47,45.06 65.71,45.06 65.96,45.31 66.09,45.31 66.18,45.22 66.18,44.77 66.27,44.68 66.45,44.68 66.54,44.77 66.54,45.22 66.62,45.31 66.8,45.31 66.89,45.22 66.89,44.77 66.98,44.68 67.16,44.68 67.25,44.77 67.25,45.22 67.34,45.31 67.51,45.31 67.6,45.22 67.6,44.82 67.73,44.69 69.03,44.69 69.07,44.73 70.43,44.73 70.77,45.07 70.92,45.07 71.26,44.73 71.86,44.73 71.99,44.87 72.53,44.87 72.98,44.42 75.23,44.42 75.5,44.69 75.86,44.69 76.13,44.42 79.01,44.42 80.54,45.95 81.09,45.95 81.69,46.55 81.69,46.76 81.99,47.07 82.45,47.07 82.86,47.47 v2(82.98,47.47)
  BOTTOM w0.102: CN5.169 57.61,52.21 v1(56.97,51.57) ; U30.AN25 83.31,47.79 v2(82.98,47.47)
M_A_DQ37: length 38.2
  IN1 w0.089: v2(81.56,47.47) 81.56,47.43 80.6,46.47 80.5,46.47 79.44,45.4 77.96,45.4 77.79,45.58 71.31,45.58 70.95,45.94 65.49,45.94 64.45,46.98 64.45,47.23 63.82,47.87 61.9,47.87 57.46,52.31 53.24,52.31 53.15,52.22 53.15,51.64 53.06,51.55 52.88,51.55 52.79,51.64 52.79,52.22 52.7,52.31 52.39,52.31 52.17,52.09 v1(52.17,51.57)
  BOTTOM w0.102: v1(52.17,51.57) 52.17,51.89 52,52.06 51.24,52.06 51.14,51.96 CN5.170 ; U30.AN27 81.81,47.72 v2(81.56,47.47)
M_A_DQ38: length 38.2
  IN1 w0.089: v2(82.25,45.47) 82.17,45.47 81.59,44.88 81.59,44.65 80.86,43.93 80.2,43.93 79.16,42.89 75.5,42.89 75.4,42.99 72.43,42.99 71.95,42.51 68.77,42.51 68.29,42.99 65.09,42.99 63.32,44.75 60.91,44.75 60.41,45.25 60.29,45.25 59.96,44.93 59.84,44.93 59.71,45.05 59.71,45.18 60.03,45.5 60.03,45.63 59.91,45.75 59.78,45.75 59.46,45.43 59.33,45.43 59.21,45.56 59.21,45.68 59.53,46.01 59.53,46.13 59.41,46.26 59.28,46.26 58.96,45.93 58.83,45.93 58.7,46.06 58.7,46.18 59.03,46.51 59.03,46.63 58.9,46.76 58.78,46.76 58.45,46.44 58.33,46.44 58.2,46.56 58.2,46.69 58.53,47.01 58.53,47.14 58.4,47.26 58.27,47.26 57.95,46.94 57.82,46.94 57.7,47.06 57.7,47.19 58.02,47.51 58.02,47.64 57.8,47.87 56.81,47.87 v1(56.32,48.35)
  BOTTOM w0.102: v1(56.32,48.35) 56.97,47.71 CN5.187 ; v2(82.25,45.47) 81.81,45.91 U30.AR27
M_A_DQ39: length 38.4
  IN1 w0.089: v2(81.41,43.48) 81.35,43.42 80.33,43.42 79.69,42.79 79.69,42.53 79.06,41.9 78.17,41.9 78.14,41.87 77.18,41.87 76.8,42.25 72.68,42.25 72.3,41.87 65.31,41.87 63.76,43.42 61.4,43.42 61.31,43.51 61.31,44.03 61.22,44.12 61.05,44.12 60.96,44.03 60.96,43.51 60.87,43.42 60.44,43.42 56.76,47.1 54.42,47.1 53.77,47.76 v1(53.77,48.35)
  BOTTOM w0.102: v2(81.41,43.48) 81.41,44.59 U30.AU27 ; CN5.182 53.16,48.96 v1(53.77,48.35)
M_A_DQ40: length 41
  TOP w0.102: v1(53.17,46.45) 54.08,47.36 58.91,47.36 63.05,43.22 75.25,43.22 75.35,43.32 75.35,43.75 75.45,43.85 75.66,43.85 75.76,43.75 75.76,43.32 75.86,43.22 78.73,43.22 78.83,43.32 78.83,43.75 78.93,43.85 79.14,43.85 79.24,43.75 79.24,43.32 79.34,43.22 79.58,43.22 79.68,43.12 79.68,42.33 79.78,42.23 79.99,42.23 80.09,42.33 80.09,43.32 80.19,43.42 80.66,43.42 81.19,42.89 81.19,42.86 81.62,42.43 82.33,42.43 82.55,42.65 82.55,43.25 v2(83,43.69)
  BOTTOM w0.102: v1(53.17,46.45) 52.67,46.96 CN5.190 ; v2(83,43.69) 83.29,43.99 U30.AV25
M_A_DQ41: length 40.7
  TOP w0.102: v2(84,43.08) 83.95,43.08 83.42,42.55 83.42,42.19 82.79,41.57 79.13,41.57 78.93,41.77 73.77,41.77 73.67,41.87 73.67,42.28 73.57,42.38 73.37,42.38 73.26,42.28 73.26,41.87 73.16,41.77 72.96,41.77 72.86,41.87 72.86,42.4 72.76,42.51 72.55,42.51 72.45,42.4 72.45,41.87 72.35,41.77 72.15,41.77 72.05,41.87 72.05,42.4 71.94,42.51 71.74,42.51 71.64,42.4 71.64,41.87 71.54,41.77 71.33,41.77 71.23,41.87 71.23,42.4 71.13,42.51 70.93,42.51 70.83,42.4 70.83,41.87 70.72,41.77 70.52,41.77 70.42,41.87 70.42,42.4 70.32,42.51 70.12,42.51 70.01,42.4 70.01,41.87 69.91,41.77 69.71,41.77 69.61,41.87 69.61,42.4 69.51,42.51 69.3,42.51 69.2,42.4 69.2,41.87 69.1,41.77 68.9,41.77 68.79,41.87 68.79,42.4 68.69,42.51 68.49,42.51 68.39,42.4 68.39,41.87 68.29,41.77 63.56,41.77 58.86,46.47 56.84,46.47 v1(56.84,46.46)
  BOTTOM w0.102: v1(56.84,46.46) 57.08,46.71 CN5.191 ; v2(84,43.08) 83.72,43.08 U30.AW25
M_A_DQ42: length 41
  TOP w0.102: v1(56.45,42.47) 57.08,41.85 57.35,41.85 60.83,38.37 79.15,38.37 79.25,38.26 79.25,37.93 79.36,37.83 79.56,37.83 79.66,37.93 79.66,38.26 79.76,38.37 79.97,38.37 80.07,38.26 80.07,37.93 80.17,37.83 80.37,37.83 80.47,37.93 80.47,38.26 80.58,38.37 80.78,38.37 80.88,38.26 80.88,37.93 80.98,37.83 81.19,37.83 81.29,37.93 81.29,38.26 81.39,38.37 82.69,38.37 83.59,39.27 84.43,39.27 85.58,40.41 85.58,40.67 86.39,41.48 86.39,42.75 86.53,42.9 86.53,43.18 v2(87.04,43.68)
  BOTTOM w0.102: U30.AV20 87.34,43.99 v2(87.04,43.68) ; v1(56.45,42.47) 56.45,42.58 56.79,42.91 57.34,42.91 57.55,42.71 CN5.207
M_A_DQ43: length 41.9
  TOP w0.102: v1(55.18,42.47) 56.14,41.52 57.21,41.52 61.17,37.55 76.8,37.55 77.23,37.12 82.89,37.12 85.98,40.21 85.98,40.49 86.62,41.12 86.62,42.6 v2(87,42.99)
  BOTTOM w0.102: CN5.203 56.41,43.71 v1(55.18,42.47) ; v2(87,42.99) 87.3,43.29 U30.AW20
M_A_DQ44: length 40.7
  TOP w0.102: v2(81.99,43.48) 81.99,43.66 81.47,44.18 80.21,44.18 80.11,44.08 80.11,43.9 80.01,43.8 79.8,43.8 79.7,43.9 79.7,44.08 79.6,44.18 74.91,44.18 74.8,44.08 74.8,43.65 74.7,43.55 74.5,43.55 74.4,43.65 74.4,44.08 74.3,44.18 74.09,44.18 73.99,44.08 73.99,43.65 73.89,43.55 73.69,43.55 73.59,43.65 73.59,44.08 73.48,44.18 73.28,44.18 73.18,44.08 73.18,43.65 73.08,43.55 72.87,43.55 72.77,43.65 72.77,44.08 72.67,44.18 72.47,44.18 72.37,44.08 72.37,43.65 72.26,43.55 72.06,43.55 71.96,43.65 71.96,44.08 71.86,44.18 71.44,44.18 70.88,43.62 63.11,43.62 58.99,47.74 52.64,47.74 52.5,47.6 v1(52.5,46.46)
  BOTTOM w0.102: U30.AV27 81.81,43.67 v2(81.99,43.48) ; CN5.194 51.99,45.96 v1(52.5,46.46)
M_A_DQ45: length 40.5
  TOP w0.102: v2(82.49,41.99) 82.4,41.9 79.55,41.9 78.61,42.84 76.83,42.84 76.72,42.73 76.72,42.2 76.62,42.1 76.42,42.1 76.32,42.2 76.32,42.73 76.22,42.84 76.01,42.84 75.91,42.73 75.91,42.2 75.81,42.1 75.61,42.1 75.5,42.2 75.5,42.73 75.4,42.84 75.2,42.84 75.1,42.73 75.1,42.2 75,42.1 74.79,42.1 74.69,42.2 74.69,42.73 74.59,42.84 65.38,42.84 65.28,42.73 65.28,42.2 65.18,42.1 64.98,42.1 64.87,42.2 64.87,42.73 64.77,42.84 64.57,42.84 64.47,42.73 64.47,42.2 64.37,42.1 64.16,42.1 64.06,42.2 64.06,42.73 63.96,42.84 62.96,42.84 58.82,46.98 56.03,46.98 v1(55.5,46.44)
  BOTTOM w0.102: U30.AW26 82.12,42.9 82.12,42.36 v2(82.49,41.99) ; CN5.195 57.39,45.71 57.26,45.58 56.36,45.58 v1(55.5,46.44)
M_A_DQ46: length 41.9
  TOP w0.102: v2(86.03,44.26) 85.87,44.26 85.52,43.92 85.52,42.98 85.38,42.83 85.38,42.22 85.28,42.12 85.28,41.53 84.64,40.89 84.24,40.89 82.61,39.25 73.44,39.25 73.09,39.61 68.64,39.61 68.62,39.58 61.56,39.58 57.85,43.29 52.42,43.29 v1(51.61,42.48)
  BOTTOM w0.102: CN5.208 51.58,42.46 v1(51.61,42.48) ; v2(86.03,44.26) 86.51,44.74 U30.AU21
M_A_DQ47: length 41.2
  TOP w0.102: v1(53.17,42.48) 53.61,42.91 57.77,42.91 61.98,38.7 82.54,38.7 84.34,40.5 84.77,40.5 85.6,41.32 85.6,42.58 v2(85.99,42.97)
  BOTTOM w0.102: v2(85.99,42.97) 86.31,43.29 U30.AW21 ; v1(53.17,42.48) 53.17,42.51 52.22,43.46 CN5.204
M_A_DQ48: length 46.6
  IN1 w0.089: v1(55.05,40.95) 55.45,40.55 57.27,40.55 57.66,40.94 61.39,40.94 63.59,38.75 63.99,38.75 64.08,38.66 64.08,38.38 64.17,38.29 64.35,38.29 64.44,38.38 64.44,38.64 64.53,38.73 67.83,38.73 67.92,38.82 67.92,39.21 68.01,39.3 68.19,39.3 68.28,39.21 68.28,38.82 68.36,38.73 69.85,38.73 69.94,38.64 69.94,38.38 70.03,38.29 70.21,38.29 70.29,38.38 70.29,38.64 70.38,38.73 70.56,38.73 70.65,38.64 70.65,38.38 70.74,38.29 70.92,38.29 71.01,38.38 71.01,38.64 71.09,38.73 71.27,38.73 71.36,38.64 71.36,38.38 71.45,38.29 71.63,38.29 71.72,38.38 71.72,39.76 71.82,39.86 71.98,39.86 72.07,39.78 72.07,38.87 72.16,38.79 72.34,38.79 72.43,38.87 72.43,39.78 72.52,39.86 72.7,39.86 72.78,39.78 72.78,39.59 72.87,39.5 73.05,39.5 73.14,39.59 73.14,39.78 73.23,39.86 73.42,39.86 73.84,40.28 79.2,40.28 80.1,41.18 83.02,41.18 83.97,42.14 84.15,42.14 84.41,42.4 84.41,44.83 84.77,45.19 v2(85,45.19)
  BOTTOM w0.102: v2(85,45.19) 85.4,45.59 U30.AT22 ; v1(55.05,40.95) 55.74,40.27 57.11,40.27 57.55,40.71 CN5.215
M_A_DQ49: length 46.9
  IN1 w0.089: v2(85.65,47.14) 85.58,47.06 85.58,46.25 85.47,46.15 85.47,45.82 85.25,45.59 84.79,45.59 84.01,44.82 83.76,44.82 83.42,44.48 83.42,42.16 82.84,41.59 79.89,41.59 79.01,40.7 78.22,40.7 78,40.92 73.57,40.92 73.16,40.5 64.79,40.5 63.72,41.58 63,41.58 62.91,41.49 62.91,40.68 62.82,40.59 62.64,40.59 62.55,40.68 62.55,41.49 62.46,41.58 58.29,41.58 57.8,42.07 57.48,42.07 57.39,41.98 57.39,41.79 57.3,41.71 57.12,41.71 57.03,41.79 57.03,41.98 56.95,42.07 56.77,42.07 56.68,41.98 56.68,41.79 56.59,41.71 56.41,41.71 56.32,41.79 56.32,41.98 56.23,42.07 56.06,42.07 55.97,41.98 55.97,41.79 55.88,41.71 55.7,41.71 55.61,41.79 55.61,41.98 55.52,42.07 55.35,42.07 55.26,41.98 55.26,41.79 55.17,41.71 54.99,41.71 54.9,41.79 54.9,41.98 54.81,42.07 53.96,42.07 53.64,41.75 v1(53.64,40.95)
  BOTTOM w0.102: v1(53.64,40.95) 53.14,41.46 CN5.212 ; v2(85.65,47.14) 85.68,47.16 86.48,47.16 U30.AP21
M_A_DQ50: length 47.1
  IN1 w0.089: v1(57.08,36.95) 57.58,37.45 59.13,37.45 59.22,37.36 59.22,37.16 59.31,37.07 59.49,37.07 59.57,37.16 59.57,37.36 59.66,37.45 59.84,37.45 59.93,37.36 59.93,37.16 60.02,37.07 60.2,37.07 60.29,37.16 60.29,37.36 60.37,37.45 60.55,37.45 60.64,37.36 60.64,37.16 60.73,37.07 60.91,37.07 61,37.16 61,37.36 61.09,37.45 61.4,37.45 63.33,35.53 70.45,35.53 70.54,35.62 70.54,35.95 70.63,36.04 70.81,36.04 70.9,35.95 70.9,35.62 70.99,35.53 71.16,35.53 71.25,35.62 71.25,35.95 71.34,36.04 71.52,36.04 71.61,35.95 71.61,35.62 71.7,35.53 71.88,35.53 71.97,35.62 71.97,35.95 72.05,36.04 72.23,36.04 72.32,35.95 72.32,35.62 72.41,35.53 72.56,35.53 75.02,37.98 82.26,37.98 84.01,39.74 84.01,40.09 84.29,40.37 86.04,40.37 87.63,41.96 87.63,45.34 87.89,45.59 88.22,45.59 88.51,45.89 88.51,47.11 v2(89,47.6)
  BOTTOM w0.102: v1(57.08,36.95) 57.33,37.21 CN5.229 ; v2(89,47.6) 88.61,47.99 U30.AN19
M_A_DQ51: length 47.5
  IN1 w0.089: v2(88.98,48.27) 88.59,47.88 87.84,47.88 87.43,47.47 87.43,46.56 87.25,46.38 87.25,45.82 86.9,45.47 86.9,45.12 86.42,44.63 86.42,42.29 85.26,41.13 84.09,41.13 82.94,39.99 82.74,39.99 81.72,38.98 74.41,38.98 72.42,36.99 63.26,36.99 61.81,38.44 52.74,38.44 v1(52.17,39.01)
  BOTTOM w0.102: CN5.224 51.61,38.46 v1(52.17,39.01) ; v2(88.98,48.27) 89.25,47.99 U30.AN18
M_A_DQ52: length 46.8
  IN1 w0.089: v2(84,44.39) 84,44.36 83.61,43.97 83.61,42.09 82.91,41.39 80,41.39 79.11,40.5 77.91,40.5 77.81,40.6 73.71,40.6 73.29,40.18 71.36,40.18 71.27,40.09 71.27,39.67 71.18,39.58 71,39.58 70.91,39.67 70.91,40.09 70.82,40.18 70.64,40.18 70.56,40.09 70.56,39.61 70.47,39.53 70.29,39.53 70.2,39.61 70.2,40.09 70.11,40.18 69.93,40.18 69.84,40.09 69.84,39.61 69.76,39.53 69.58,39.53 69.49,39.61 69.49,40.09 69.4,40.18 69.22,40.18 69.13,40.09 69.13,39.58 69.04,39.49 68.87,39.49 68.78,39.58 68.78,40.09 68.69,40.18 68.51,40.18 68.42,40.09 68.42,39.71 68.33,39.62 65.09,39.62 65,39.71 65,40.09 64.91,40.18 64.74,40.18 64.65,40.09 64.65,39.13 64.56,39.04 64.38,39.04 64.29,39.13 64.29,40.55 64.2,40.64 64.03,40.64 63.94,40.55 63.94,39.2 63.85,39.11 63.67,39.11 63.58,39.2 63.58,41.05 63.49,41.13 63.31,41.13 63.23,41.05 63.23,39.99 63.14,39.9 62.88,39.9 61.52,41.26 57.97,41.26 57.85,41.39 56.76,41.39 v1(56.32,40.95)
  BOTTOM w0.102: CN5.211 57.07,41.71 v1(56.32,40.95) ; v2(84,44.39) 84.1,44.39 U30.AU23
M_A_DQ53: length 46.4
  IN1 w0.089: v2(85.07,45.97) 84.84,45.97 83.89,45.02 82.9,45.02 82.58,44.7 82.58,42.7 81.88,42 80.02,42 78.93,40.91 78.4,40.91 78.07,41.24 73.44,41.24 73.02,40.82 64.93,40.82 63.85,41.9 58.99,41.9 57.87,43.02 57.46,43.02 57.37,43.11 57.37,43.71 57.28,43.8 57.1,43.8 57.01,43.71 57.01,43.11 56.92,43.02 56.74,43.02 56.65,43.11 56.65,43.71 56.57,43.8 56.39,43.8 56.3,43.71 56.3,43.11 56.21,43.02 56.03,43.02 55.94,43.11 55.94,43.71 55.85,43.8 55.68,43.8 55.59,43.71 55.59,43.11 55.5,43.02 55.32,43.02 55.23,43.11 55.23,43.71 55.14,43.8 54.97,43.8 54.88,43.71 54.88,43.11 54.79,43.02 54.41,43.02 v1(52.34,40.95)
  BOTTOM w0.102: v2(85.07,45.97) 85.09,46 85.09,46 85.48,46.39 U30.AR22 ; CN5.216 51.84,40.46 v1(52.34,40.95)
M_A_DQ54: length 47.1
  IN1 w0.089: v1(52.22,36.99) 53.32,38.09 61.7,38.09 63.63,36.16 68.14,36.16 68.65,36.68 72.78,36.68 74.74,38.64 81.9,38.64 84.14,40.88 85.54,40.88 86.62,41.96 86.62,44.55 87.1,45.03 87.1,45.39 87.45,45.74 87.45,46.3 87.66,46.51 87.66,47.09 v2(88.04,47.48)
  BOTTOM w0.102: v1(52.22,36.99) 51.75,37.46 CN5.228 ; U30.AN20 87.53,47.99 v2(88.04,47.48)
M_A_DQ55: length 46.6
  IN1 w0.089: v2(88.05,46.8) 88.05,46.62 87.65,46.21 87.65,45.66 87.43,45.44 87.43,42.14 85.92,40.63 84.26,40.63 83.63,39.99 83.63,39.86 82.08,38.31 74.88,38.31 72.92,36.36 70.22,36.36 70.13,36.27 70.13,35.93 70.04,35.84 69.86,35.84 69.77,35.93 69.77,36.27 69.68,36.36 69.51,36.36 69.42,36.27 69.42,35.93 69.33,35.84 69.15,35.84 69.06,35.93 69.06,36.27 68.97,36.36 68.78,36.36 68.27,35.84 63.48,35.84 61.55,37.77 55.75,37.77 55.56,37.58 v1(55.56,36.94)
  BOTTOM w0.102: v2(88.05,46.8) 88.44,47.19 U30.AP19 ; CN5.225 56.82,38.21 v1(55.56,36.94)
M_A_DQ56: length 55.9
  IN1 w0.089: v2(88.05,45.17) 88.66,44.57 88.66,41.84 87.28,40.46 87.28,39.48 86.8,39.01 86.8,38.85 85.6,37.64 85.34,37.64 83.32,35.62 82.36,35.62 81.34,36.64 76.22,36.64 72.91,33.32 72.33,33.32 72.25,33.23 72.25,33.04 72.16,32.96 71.98,32.96 71.89,33.04 71.89,33.23 71.8,33.32 71.62,33.32 71.53,33.23 71.53,33.04 71.45,32.96 71.27,32.96 71.18,33.04 71.18,33.23 71.09,33.32 70.91,33.32 70.82,33.23 70.82,33.04 70.73,32.96 70.56,32.96 70.47,33.04 70.47,33.23 70.38,33.32 70.2,33.32 70.11,33.23 70.11,33.04 70.02,32.96 69.84,32.96 69.76,33.04 69.76,33.23 69.67,33.32 69.49,33.32 69.4,33.23 69.4,33.04 69.31,32.96 69.13,32.96 69.04,33.04 69.04,33.23 68.96,33.32 68.78,33.32 68.69,33.23 68.69,33.04 68.6,32.96 68.42,32.96 68.33,33.04 68.33,33.23 68.24,33.32 68.07,33.32 67.98,33.23 67.98,33.04 67.89,32.96 67.71,32.96 67.62,33.04 67.62,33.23 67.53,33.32 67.36,33.32 67.27,33.23 67.27,33.04 67.18,32.96 67,32.96 66.91,33.04 66.91,33.23 66.82,33.32 66.64,33.32 66.56,33.23 66.56,33.04 66.47,32.96 66.29,32.96 66.2,33.04 66.2,33.23 66.11,33.32 65.93,33.32 65.84,33.23 65.84,33.04 65.76,32.96 65.58,32.96 65.49,33.04 65.49,33.23 65.4,33.32 65.22,33.32 65.13,33.23 65.13,33.04 65.04,32.96 64.87,32.96 64.78,33.04 64.78,33.23 64.69,33.32 64.01,33.32 63.82,33.13 63.82,32.74 63.32,32.24 62.28,32.24 59.51,35.01 53.16,35.01 v1(52.24,35.93)
  BOTTOM w0.102: U30.AT19 88.44,45.59 88.05,45.2 v2(88.05,45.17) ; v1(52.24,35.93) 51.77,35.46 CN5.236
