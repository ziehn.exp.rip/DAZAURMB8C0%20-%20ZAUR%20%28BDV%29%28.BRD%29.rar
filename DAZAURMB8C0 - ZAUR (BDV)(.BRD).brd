# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ31: length 62.5
  TOP w0.102: U6.D7 v1(44.13,71.13)
  IN3 w0.089: v2(71.87,61.45) 71.87,61.91 71.39,62.39 69.05,62.39 64.87,66.57 64.44,66.57 64.24,66.78 64.24,67.08 64.15,67.17 63.89,67.17 63.81,67.08 63.81,65.86 63.72,65.77 63.54,65.77 63.45,65.86 63.45,67.11 63.36,67.19 63.18,67.19 63.09,67.11 63.09,65.86 63.01,65.77 62.83,65.77 62.74,65.86 62.74,67.23 62.57,67.4 58.94,67.4 58.66,67.68 58.52,67.68 58.41,67.57 58.41,67.34 58.31,67.24 58.16,67.24 58.06,67.34 58.06,67.57 57.95,67.68 57.81,67.68 57.7,67.57 57.7,67.37 57.6,67.26 57.45,67.26 57.35,67.37 57.35,67.57 57.24,67.68 57.09,67.68 56.99,67.57 56.99,67.37 56.9,67.28 56.72,67.28 56.63,67.37 56.63,67.57 56.53,67.68 53.81,67.68 53.43,67.3 53.25,67.3 53.15,67.4 53.15,67.8 53.05,67.91 52.84,67.91 52.76,67.82 52.76,67.52 52.64,67.41 52.51,67.41 52.4,67.52 52.4,67.82 52.31,67.91 52.13,67.91 52.04,67.82 52.04,67.52 51.96,67.43 51.78,67.43 51.69,67.52 51.69,67.82 51.6,67.91 51.42,67.91 50.99,67.47 45.34,67.47 45.24,67.58 45.24,68.49 44.53,69.2 44.53,71.02 44.42,71.13 v1(44.13,71.13)
  BOTTOM w0.089: 78.89,61.69 79.36,61.69 79.49,61.82 79.73,61.82 80.06,61.49 U30.U29
  BOTTOM w0.102: 78.89,61.69 78.73,61.53 76.82,61.53 75.75,62.6 68.13,62.6 68.01,62.47 68.01,61.2 68.26,60.95 71.36,60.95 v2(71.87,61.45)
M_B_DQ32: length 60.3
  TOP w0.102: U9.C2 v1(44.93,51.53)
  IN3 w0.089: v1(44.93,51.53) 44.93,52.34 45.05,52.47 45.43,52.47 45.65,52.69 47.05,52.69 47.18,52.56 47.18,52.18 47.31,52.06 47.95,52.06 48.04,52.14 48.04,52.59 48.13,52.68 48.3,52.68 48.39,52.59 48.39,52.14 48.48,52.06 49.41,52.06 49.5,52.14 49.5,52.47 49.59,52.56 49.77,52.56 49.86,52.47 49.86,52.14 49.95,52.06 50.12,52.06 50.21,52.14 50.21,52.47 50.3,52.56 50.48,52.56 50.57,52.47 50.57,52.14 50.66,52.06 50.84,52.06 50.92,52.14 50.92,52.47 51.01,52.56 51.19,52.56 51.28,52.47 51.28,52.14 51.37,52.06 51.55,52.06 51.64,52.14 51.64,52.47 51.72,52.56 51.9,52.56 51.99,52.47 51.99,52.14 52.08,52.06 52.26,52.06 52.39,52.18 52.39,52.44 52.49,52.54 52.67,52.54 52.77,52.44 52.77,52.06 52.98,51.84 52.98,51.66 52.77,51.45 52.77,51.27 52.91,51.13 57.95,51.13 58.04,51.04 58.04,50.62 58.13,50.53 58.31,50.53 58.4,50.62 58.4,51.59 58.48,51.68 58.66,51.68 58.75,51.59 58.75,50.62 58.84,50.53 59.02,50.53 59.11,50.62 59.11,51.59 59.2,51.68 59.37,51.68 59.46,51.59 59.46,50.62 59.55,50.53 59.73,50.53 59.82,50.62 59.82,51.04 59.91,51.13 61.02,51.13 61.28,50.87 61.4,50.87 61.66,51.13 61.95,51.13 62.23,50.85 62.35,50.85 62.63,51.13 62.97,51.13 63.12,50.98 63.24,50.98 63.4,51.13 63.85,51.13 64.24,50.74 64.24,50.61 63.98,50.35 63.98,50.22 64.1,50.1 64.23,50.1 64.94,50.81 65.07,50.81 65.19,50.68 65.19,50.56 64.48,49.84 64.48,49.72 64.61,49.59 64.73,49.59 65.44,50.3 65.57,50.3 65.81,50.06 65.81,49.94 65.1,49.22 65.1,49.1 65.27,48.93 65.39,48.93 66.1,49.64 66.23,49.64 66.61,49.26 66.61,49.14 66.23,48.75 66.23,48.63 66.74,48.12 66.99,48.12 67.31,48.44 67.43,48.44 67.63,48.25 67.63,48.07 68.43,47.27 68.86,47.27 69.02,47.1 69.02,46.94 69.11,46.85 69.33,46.85 69.42,46.94 69.42,47.42 69.51,47.51 69.69,47.51 69.77,47.42 69.77,46.94 69.86,46.85 70.55,46.85 72.2,45.2 76.55,45.2 v2(76.94,44.81)
  BOTTOM w0.089: U30.AT29 80.06,45.49 79.73,45.16 79.48,45.16 79.35,45.29 79.08,45.29 78.98,45.2 78.8,45.2
  BOTTOM w0.102: v2(76.94,44.81) 76.97,44.81 77.36,45.2 78.8,45.2
M_B_DQ33: length 59.7
  TOP w0.102: U9.D3 v1(44.13,50.73)
  IN3 w0.089: v2(78.11,44.81) 78.25,44.94 79.8,44.94 79.94,44.8 79.94,44.4 80.03,44.31 80.87,44.31 81.09,44.52 81.09,45.2 80.96,45.33 77.66,45.33 77.43,45.55 72.35,45.55 69.78,48.12 68.26,48.12 64.91,51.47 64.5,51.47 64.32,51.29 64.2,51.29 64.07,51.42 64.07,51.96 63.98,52.06 63.71,52.06 63.62,51.97 63.62,51.56 63.53,51.47 63.35,51.47 63.26,51.56 63.26,51.97 63.18,52.06 63,52.06 62.91,51.97 62.91,51.56 62.82,51.47 62.64,51.47 62.55,51.56 62.55,51.97 62.46,52.06 62.29,52.06 62.2,51.97 62.2,51.56 62.11,51.47 61.93,51.47 61.84,51.56 61.84,51.97 61.75,52.06 61.58,52.06 61.49,51.97 61.49,51.56 61.4,51.47 61.22,51.47 61.13,51.56 61.13,51.97 61.04,52.06 60.86,52.06 60.78,51.97 60.78,51.56 60.69,51.47 60.51,51.47 60.42,51.56 60.42,51.97 60.33,52.06 57.95,52.06 57.86,51.97 57.86,51.56 57.77,51.47 57.59,51.47 57.5,51.56 57.5,51.97 57.41,52.06 54.28,52.06 54.19,52.14 54.19,52.43 54.1,52.52 53.92,52.52 53.83,52.43 53.83,52.14 53.75,52.06 53.49,52.06 53.4,52.14 53.4,52.74 53.24,52.9 51.3,52.9 51.18,53.02 50.91,53.02 50.79,52.9 50.58,52.9 50.46,53.02 50.2,53.02 50.08,52.9 49.87,52.9 49.75,53.02 49.49,53.02 49.37,52.9 48.81,52.9 48.68,53.03 45.49,53.03 45.27,52.82 42.73,52.82 42.48,52.56 42.48,52.18 42.76,51.9 43.6,51.9 43.62,51.93 44.4,51.93 44.53,51.8 44.53,50.82 44.44,50.73 v1(44.13,50.73)
  BOTTOM w0.089: 78.8,44.94 79.16,44.94 U30.AU32
  BOTTOM w0.102: 78.8,44.94 78.25,44.94 v2(78.11,44.81)
M_B_DQ34: length 63.3
  TOP w0.102: v1(45.24,47.87) 44.89,47.52 44.89,46.69 U9.C8
  IN3 w0.089: v2(67.12,42.28) 66.71,41.87 65.49,41.87 61.28,46.09 58.23,46.09 57.45,46.87 55.02,46.87 54.91,46.76 54.91,46.63 54.84,46.56 54.32,46.56 54.24,46.65 54.24,46.8 54.17,46.87 50.91,46.87 49.53,48.25 48.06,48.25 47.23,47.42 45.69,47.42 v1(45.24,47.87)
  BOTTOM w0.089: U30.AW31 79.42,43.3 78.91,43.3 78.8,43.19
  BOTTOM w0.102: v2(67.12,42.28) 66.48,42.91 61.76,42.91 61.66,43.01 61.66,45.73 61.76,45.83 62.19,45.83 62.29,45.73 62.29,43.65 62.39,43.55 62.59,43.55 62.7,43.65 62.7,45.73 62.8,45.83 63.18,45.83 63.31,45.71 63.31,43.65 63.41,43.55 63.79,43.55 63.89,43.65 63.89,43.83 63.99,43.93 64.35,43.93 64.45,43.83 64.45,43.65 64.55,43.55 64.75,43.55 64.85,43.65 64.85,43.83 64.96,43.93 65.16,43.93 65.32,43.77 65.32,43.65 65.42,43.55 65.67,43.55 65.77,43.65 65.77,43.83 65.87,43.93 66.07,43.93 66.17,43.83 66.17,43.65 66.28,43.55 66.73,43.55 67.5,42.79 70.67,42.79 71.39,43.5 74.03,43.5 74.86,42.66 77.43,42.66 77.81,43.05 78.66,43.05 78.8,43.19
M_B_DQ35: length 60
  TOP w0.102: U9.C7 44.53,47.67 v1(45.27,49.01)
  IN3 w0.089: v2(78.58,42.29) 78.84,42.29 78.93,42.38 78.93,42.95 79.02,43.04 79.22,43.04 79.31,42.95 79.31,42.53 79.44,42.4 79.64,42.4 79.73,42.49 79.73,42.95 79.82,43.04 79.99,43.04 80.08,42.95 80.08,42.49 80.17,42.4 80.45,42.4 80.83,42.79 81.21,42.79 81.6,42.4 82.1,42.4 82.61,42.91 82.61,44.04 82.7,44.13 83.32,44.13 83.5,44.31 83.5,44.93 83.41,45.02 81.56,45.02 81.47,44.93 81.47,44.02 81.38,43.93 79.82,43.93 79.56,44.18 79.56,44.44 79.44,44.56 78.55,44.56 78.4,44.41 78.4,44.14 78.48,44.06 78.55,44.06 78.67,43.93 78.67,43.42 78.42,43.17 76.77,43.17 76.39,42.79 76.39,42.37 76.3,42.28 73.85,42.28 73.06,43.06 65.79,43.06 65.34,43.52 65.34,45.2 65.21,45.33 63.53,45.33 61.7,47.15 59.19,47.15 58.45,47.9 54.77,47.9 54.42,48.25 54.22,48.25 53.87,47.9 51.33,47.9 49.93,49.3 47.66,49.3 46.96,48.61 45.38,48.61 45.27,48.71 v1(45.27,49.01)
  BOTTOM w0.089: 79.05,42.81 79.83,42.81 U30.AW30
  BOTTOM w0.102: v2(78.58,42.29) 78.61,42.32 78.61,42.37 79.05,42.81
M_B_DQ36: length 63.2
  TOP w0.102: U9.C3 v1(44.93,50.73)
  IN3 w0.089: v1(44.93,50.73) 45.33,51.13 45.33,51.78 45.89,52.35 46.38,52.35 47.01,51.71 50.7,51.71 51.62,50.79 54,50.79 54.09,50.7 54.09,50.2 54.17,50.11 54.35,50.11 54.44,50.2 54.44,50.7 54.53,50.79 57.21,50.79 57.85,50.15 63.56,50.15 65.97,47.74 67.45,47.74 69.02,46.16 69.02,46.02 69.11,45.93 70.95,45.93 72.08,44.81 v2(73.18,44.81)
  BOTTOM w0.089: U30.AR30 79.84,45.82 79.49,45.82 79.35,45.69 78.85,45.69 78.8,45.64
  BOTTOM w0.102: 78.8,45.64 78.78,45.62 74.83,45.62 74.23,46.21 71.69,46.21 69.78,48.12 65.59,48.12 64.07,46.6 64.07,45.2 64.46,44.81 66.47,44.81 67.12,45.45 70.42,45.45 71.07,44.81 v2(73.18,44.81)
M_B_DQ37: length 62.7
  TOP w0.102: U9.A3 v1(46.53,50.73)
  IN3 w0.089: v2(74.35,44.81) 73.95,44.41 71.97,44.41 70.8,45.58 68.77,45.58 68.55,45.79 68.55,46.13 67.32,47.36 65.3,47.36 65.09,47.57 65.09,48.12 63.44,49.77 51.52,49.77 51.12,50.17 51.12,50.79 50.53,51.37 47.17,51.37 v1(46.53,50.73)
  BOTTOM w0.089: 78.8,45.42 78.89,45.42 78.97,45.49 79.6,45.49 U30.AT31
  BOTTOM w0.102: v2(74.35,44.81) 73.93,45.22 71.16,45.22 70.47,45.91 67.07,45.91 66.36,45.2 64.7,45.2 64.45,45.45 64.45,46.47 64.96,46.98 66,46.98 66.1,47.08 66.1,47.38 66.21,47.48 66.41,47.48 66.51,47.38 66.51,47.08 66.61,46.98 66.82,46.98 66.92,47.08 66.92,47.38 67.02,47.48 67.22,47.48 67.32,47.38 67.32,47.08 67.43,46.98 67.63,46.98 67.73,47.08 67.73,47.38 67.83,47.48 68.03,47.48 68.14,47.38 68.14,47.08 68.24,46.98 70.29,46.98 71.44,45.83 74.23,45.83 74.65,45.42 78.8,45.42
M_B_DQ38: length 63.3
  TOP w0.102: U9.B8 46.34,46.87 46.42,46.97 v1(46.7,47.82)
  IN3 w0.089: v2(65.85,42.25) 65.6,42.25 61.41,46.44 58.49,46.44 57.72,47.21 51.05,47.21 49.64,48.62 47.94,48.62 47.14,47.82 v1(46.7,47.82)
  BOTTOM w0.089: U30.AV30 79.81,43.8 79.48,43.8 79.24,43.56 78.87,43.56 78.8,43.49
  BOTTOM w0.102: 78.8,43.49 78.56,43.26 77.7,43.26 77.52,43.08 75.08,43.08 74.31,43.85 71.23,43.85 70.55,43.17 67.75,43.17 66.61,44.31 63.94,44.31 63.69,44.56 63.69,46.72 64.2,47.23 64.2,47.87 64.07,47.99 63.59,47.99 63.49,48.09 63.49,49.03 63.39,49.14 63.02,49.14 62.92,49.03 62.92,48.09 62.82,47.99 62.62,47.99 62.52,48.09 62.52,49.29 62.41,49.39 61.53,49.39 61.28,49.14 61.28,42.63 61.38,42.53 65.57,42.53 v2(65.85,42.25)
M_B_DQ39: length 60
  TOP w0.102: U9.D7 v1(44.64,49.01)
  IN3 w0.089: v1(44.64,49.01) 44.64,48.5 44.87,48.27 45.64,48.27 45.78,48.12 45.78,47.95 45.87,47.87 46.07,47.87 46.16,47.95 46.16,48.14 46.29,48.27 47.11,48.27 47.8,48.96 49.79,48.96 51.19,47.55 58.29,47.55 58.47,47.37 58.47,46.96 58.63,46.8 61.55,46.8 63.79,44.56 64.07,44.56 64.45,44.94 64.83,44.94 64.96,44.82 64.96,44.47 64.87,44.39 64.54,44.39 64.45,44.3 64.45,44.12 64.54,44.03 64.87,44.03 64.96,43.94 64.96,43.39 65.64,42.71 68.25,42.71 68.34,42.62 68.34,41.85 68.26,41.77 68.1,41.77 68.01,41.68 68.01,41.41 68.29,41.13 68.61,41.13 68.7,41.22 68.7,42.62 68.79,42.71 68.97,42.71 69.05,42.62 69.05,41.86 69.14,41.77 69.32,41.77 69.41,41.86 69.41,42.62 69.5,42.71 69.68,42.71 69.77,42.62 69.77,42.05 69.85,41.96 70.03,41.96 70.12,42.05 70.12,42.62 70.21,42.71 70.39,42.71 70.48,42.62 70.48,42.05 70.57,41.96 70.74,41.96 70.83,42.05 70.83,42.62 70.92,42.71 71.1,42.71 71.19,42.62 71.19,41.86 71.28,41.77 71.46,41.77 71.54,41.86 71.54,42.62 71.63,42.71 71.81,42.71 71.9,42.62 71.9,40.97 71.99,40.88 72.24,40.88 72.32,40.97 72.32,42.53 72.45,42.66 72.83,42.66 72.96,42.53 72.96,41.77 73.09,41.64 76.68,41.64 76.77,41.73 76.77,42.66 76.9,42.79 77.53,42.79 77.66,42.66 77.66,42.53 v2(77.4,42.27)
  BOTTOM w0.089: U30.AW29 80.07,43.49 79.65,43.07 79.02,43.07
  BOTTOM w0.102: v2(77.4,42.27) 77.42,42.27 77.99,42.83 78.78,42.83 79.02,43.07
M_B_DQ40: length 62.5
  TOP w0.102: U9.H3 v1(40.93,49.93)
  IN3 w0.089: v1(40.93,49.93) 42.24,49.93 43.25,48.91 43.25,47.89 44.53,46.62 44.53,45.76 44.74,45.55 47.32,45.55 47.87,46.1 48.17,46.1 48.29,46.23 48.29,46.47 48.42,46.6 49.22,46.6 49.33,46.49 49.33,46.23 49.46,46.1 49.72,46.1 51.14,44.68 60.68,44.68 64.91,40.45 65.72,40.45 65.81,40.36 65.81,40.23 65.57,39.99 v2(65.47,39.99)
  BOTTOM w0.102: U30.AY29 79.88,42.49 79.4,42.01 79.17,42.01 78.85,41.69 78.4,41.69 78.08,41.38 76.62,41.38 76.46,41.54 76.22,41.54 76.05,41.38 75.81,41.38 75.65,41.54 75.4,41.54 75.24,41.38 74.62,41.38 73.59,42.4 71.82,42.4 71.05,41.64 68.39,41.64 68.16,41.41 60.64,41.41 60.54,41.31 60.54,41.11 60.74,40.91 61.42,40.91 61.52,40.8 61.52,40.62 61.4,40.5 61.02,40.5 60.89,40.37 60.89,39.61 61.02,39.48 61.3,39.48 61.4,39.58 61.4,39.86 61.53,39.99 61.81,39.99 61.92,39.89 61.92,39.58 62.02,39.48 62.22,39.48 62.32,39.58 62.32,39.89 62.42,39.99 v2(65.47,39.99)
M_B_DQ41: length 63.2
  TOP w0.102: v1(40.81,48.97) 40.81,49.24 U9.J3
  IN3 w0.089: v1(40.81,48.97) 41.36,49.52 42.17,49.52 42.91,48.77 42.91,47.75 44.18,46.48 44.18,45.62 44.59,45.21 47.46,45.21 48.01,45.76 49.58,45.76 51,44.33 60.53,44.33 65.31,39.56 66.28,39.56 v2(66.74,39.1)
  BOTTOM w0.102: v2(66.74,39.1) 66.28,39.56 62.88,39.56 62.42,39.1 60.89,39.1 60.51,39.48 60.51,40.5 60.13,40.88 60.13,41.52 60.39,41.77 67.98,41.77 68.24,42.02 70.93,42.02 71.69,42.79 73.72,42.79 74.61,41.9 76.9,41.9 77.05,41.74 78.04,41.74 78.21,41.91 78.77,41.91 79.21,42.35 U30.AY32
M_B_DQ42: length 62.9
  TOP w0.102: v1(41.72,46.69) 42.13,47.1 U9.F7
  IN3 w0.089: v1(41.72,46.69) 41.29,46.27 41.04,46.27 40.92,46.14 40.92,45.96 40.98,45.9 41.2,45.9 41.33,45.78 41.33,45.6 41.23,45.5 40.93,45.5 40.87,45.44 40.87,45.25 41,45.12 41.16,45.12 42.72,43.56 49.44,43.56 50.92,42.07 60.41,42.07 65.04,37.45 65.72,37.45 66.23,36.94 66.99,36.94 v2(67.37,36.56)
  BOTTOM w0.102: v2(67.37,36.56) 66.93,36.12 66.58,36.12 66.48,36.02 66.48,35.42 66.61,35.29 66.99,35.29 67.12,35.17 67.12,33.74 67.22,33.64 67.54,33.64 67.64,33.74 67.64,35.95 67.74,36.05 67.95,36.05 68.05,35.95 68.05,33.74 68.15,33.64 68.35,33.64 68.46,33.74 68.46,34.94 68.56,35.04 68.76,35.04 68.86,34.94 68.86,33.87 68.96,33.77 69.17,33.77 69.27,33.87 69.27,34.94 69.37,35.04 70.55,35.04 74.36,38.85 79.67,38.85 80.95,40.12 81.21,40.12 81.56,40.48 81.56,40.79 81.86,41.09 U30.BC27
M_B_DQ43: length 63
  TOP w0.102: v1(41.01,47.61) U9.H7
  IN3 w0.089: v2(65.34,37.96) 65.04,37.96 60.08,42.91 59.59,42.91 59.5,42.82 59.5,42.53 59.38,42.42 57.6,42.42 57.49,42.53 57.49,42.94 57.4,43.03 54.11,43.03 54.02,42.94 54.02,42.51 53.93,42.42 53.75,42.42 53.66,42.51 53.66,42.94 53.57,43.03 51.32,43.03 51.19,42.9 51.19,42.72 51.07,42.6 50.89,42.6 49.58,43.9 42.86,43.9 42.35,44.41 42.35,46.85 42.1,47.1 41.52,47.1 v1(41.01,47.61)
  BOTTOM w0.102: U30.BB26 81.96,41.49 81.33,40.87 81.33,40.56 81.14,40.37 80.89,40.37 79.75,39.23 74.23,39.23 71.56,36.56 70.43,36.56 70.32,36.46 70.32,35.52 70.22,35.42 70.02,35.42 69.92,35.52 69.92,36.46 69.82,36.56 69.61,36.56 69.51,36.46 69.51,35.52 69.41,35.42 69.21,35.42 69.1,35.52 69.1,36.46 69,36.56 68.64,36.56 68.13,37.07 64.25,37.07 64.15,36.97 64.15,36.28 64.04,36.18 63.84,36.18 63.74,36.28 63.74,36.97 63.64,37.07 63.28,37.07 63.18,37.17 63.18,37.86 63.28,37.96 v2(65.34,37.96)
M_B_DQ44: length 62.4
  TOP w0.102: v1(40.35,48.35) 40.35,47.75 U9.J7
  IN3 w0.089: v2(64.86,36.59) 60.06,41.39 50.64,41.39 49.15,42.87 42.11,42.87 40.53,44.46 40.53,46.39 40.52,46.39 40.52,46.98 40.6,47.05 40.6,48.09 v1(40.35,48.35)
  BOTTOM w0.089: U30.BC25 83,40.48 82.68,40.15 82.5,40.15 82.36,40.02
  BOTTOM w0.102: 82.36,40.02 82.33,39.99 81.67,39.99 79.77,38.09 78.58,38.09 78.47,37.98 78.47,37.76 78.37,37.65 78.17,37.65 78.07,37.76 78.07,37.98 77.97,38.09 77.76,38.09 77.66,37.98 77.66,37.76 77.56,37.65 77.36,37.65 77.25,37.76 77.25,37.98 77.15,38.09 76.95,38.09 76.85,37.98 76.85,37.76 76.75,37.65 76.54,37.65 76.44,37.76 76.44,37.98 76.34,38.09 76.14,38.09 76.04,37.98 76.04,37.76 75.93,37.65 75.73,37.65 75.63,37.76 75.63,37.98 75.53,38.09 74.99,38.09 72.82,35.92 72.61,35.92 72.43,35.73 72.43,35.52 72.25,35.34 72.04,35.34 71.86,35.16 71.86,34.95 71.67,34.77 71.46,34.77 71.28,34.58 71.28,34.38 71.18,34.28 70.29,34.28 70.13,34.11 70.13,33.22 69.66,32.75 66.23,32.75 63.76,35.22 63.76,35.36 64.86,36.46 v2(64.86,36.59)
M_B_DQ45: length 63
  TOP w0.102: v1(40.97,44.59) 40.96,44.6 40.96,45.89 U9.H8
  IN3 w0.089: v1(40.97,44.59) 42.35,43.21 49.3,43.21 50.78,41.73 60.25,41.73 64.91,37.07 65.59,37.07 v2(66.1,36.56)
  BOTTOM w0.089: 82.48,40.37 82.63,40.37 82.81,40.55 82.81,40.84 82.7,40.95 82.7,41.22 83,41.52 U30.BA25
  BOTTOM w0.102: v2(66.1,36.56) 66.1,35.93 66,35.83 64.81,35.83 64.7,35.73 64.7,35.53 64.81,35.42 66,35.42 66.1,35.32 66.1,35.12 66,35.02 64.93,35.02 64.83,34.92 64.83,34.71 64.93,34.61 66.64,34.61 66.74,34.51 66.74,34.28 66.61,34.15 65.85,34.15 65.72,34.02 65.72,33.77 65.85,33.64 66.61,33.64 66.74,33.51 66.74,33.23 66.84,33.13 69.15,33.13 69.66,33.64 69.66,34.49 69.82,34.66 70.67,34.66 72.44,36.42 72.59,36.42 72.63,36.38 72.78,36.38 72.92,36.52 72.92,36.66 72.87,36.71 72.87,36.86 73.02,37 73.16,37 73.21,36.95 73.35,36.95 73.5,37.09 73.5,37.24 73.45,37.29 73.45,37.43 73.59,37.57 73.74,37.57 73.78,37.53 73.93,37.53 74.07,37.67 74.07,37.81 74.02,37.86 74.02,38.01 74.48,38.47 79.69,38.47 81.09,39.86 81.24,39.86 81.57,40.19 82.23,40.19 82.41,40.37 82.48,40.37
M_B_DQ46: length 62.5
  TOP w0.102: U9.G2 v1(41.73,50.73)
  IN3 w0.089: v1(41.73,50.73) 42.13,51.13 42.73,51.13 42.93,50.93 42.93,50.21 43.94,49.2 43.94,48.17 45.4,46.72 47.52,46.72 48.08,47.28 49.51,47.28 50.92,45.86 57.46,45.86 57.95,45.38 61,45.38 65.21,41.16 67.26,41.16 68.01,40.41 v2(68.01,39.99)
  BOTTOM w0.102: U30.BB30 79.93,41.59 78.94,40.6 74.13,40.6 73.98,40.75 73.98,41.01 73.32,41.67 72.1,41.67 71.94,41.52 71.94,41.01 71.82,40.88 68.9,40.88 68.64,40.63 68.64,40.35 68.74,40.25 69.28,40.25 69.4,40.12 69.4,39.84 69.3,39.74 68.77,39.74 68.64,39.61 68.64,38.72 68.77,38.59 71.18,38.59 71.44,38.34 71.44,38.06 71.33,37.96 70.63,37.96 70.53,37.86 70.53,37.43 70.43,37.32 70.23,37.32 70.13,37.43 70.13,37.86 70.03,37.96 69.82,37.96 69.72,37.86 69.72,37.43 69.62,37.32 69.42,37.32 69.31,37.43 69.31,37.86 69.21,37.96 66.97,37.96 66.86,38.06 66.86,38.49 66.97,38.59 67.75,38.59 67.88,38.72 67.88,39.86 v2(68.01,39.99)
M_B_DQ47: length 62.5
  TOP w0.102: U9.H2 v1(40.93,50.73)
  IN3 w0.089: v1(40.93,50.73) 40.93,50.45 41.05,50.33 42.33,50.33 43.6,49.06 43.6,48.03 44.92,46.71 44.92,46.5 45.05,46.37 45.87,46.37 46,46.24 46.21,46.24 46.34,46.37 46.78,46.37 46.91,46.25 46.91,46.08 47.03,45.96 47.24,45.96 48.22,46.94 49.36,46.94 51.03,45.27 51.21,45.27 51.46,45.52 53.93,45.52 54.02,45.43 54.02,45.11 54.11,45.02 54.28,45.02 54.37,45.11 54.37,45.43 54.46,45.52 54.64,45.52 54.73,45.43 54.73,45.11 54.82,45.02 55,45.02 55.08,45.11 55.08,45.43 55.17,45.52 57.31,45.52 57.8,45.03 60.83,45.03 65.06,40.8 66.17,40.8 66.25,40.71 66.25,40.55 66.34,40.46 66.52,40.46 66.61,40.55 66.61,40.71 66.7,40.8 67.07,40.8 67.24,40.63 67.24,40.5 v2(66.74,39.99)
  BOTTOM w0.102: U30.BA28 80.84,41.89 80.72,42.01 80.06,42.01 78.93,40.88 78.37,40.88 78.29,40.96 74.53,40.96 73.47,42.02 71.94,42.02 71.56,41.64 71.56,41.36 71.46,41.26 68.67,41.26 68.41,41.01 62.01,41.01 61.89,40.88 61.89,40.5 61.99,40.4 66.64,40.4 66.74,40.3 v2(66.74,39.99)
M_B_DQ48: length 63.4
  TOP w0.102: U12.F7 v1(41.73,36.15)
  IN3 w0.089: v2(61.91,34.28) 61.28,34.28 60.64,34.91 60.04,34.91 58.75,36.2 55.79,36.2 55.06,35.48 51.26,35.48 48.15,38.59 45.42,38.59 45.29,38.71 43.87,38.71 42.93,37.77 42.93,36.94 42.15,36.15 v1(41.73,36.15)
  BOTTOM w0.089: U30.BA24 84,41.56 83.7,41.26 83.7,40.94 83.81,40.83 83.81,40.55 83.63,40.37 83.63,40.25 83.12,39.74
  BOTTOM w0.102: v2(61.91,34.28) 62.42,34.28 63.18,33.51 63.18,31.1 63.69,30.59 64.56,30.59 64.66,30.49 64.66,30.19 64.77,30.09 64.97,30.09 65.07,30.19 65.07,30.49 65.17,30.59 65.38,30.59 65.48,30.49 65.48,30.19 65.58,30.09 65.78,30.09 65.88,30.19 65.88,30.49 65.98,30.59 66.19,30.59 66.29,30.49 66.29,30.19 66.39,30.09 66.59,30.09 66.7,30.19 66.7,30.49 66.8,30.59 67,30.59 67.1,30.49 67.1,30.19 67.2,30.09 67.41,30.09 67.51,30.19 67.51,30.49 67.61,30.59 67.81,30.59 67.92,30.49 67.92,30.19 68.02,30.09 68.22,30.09 68.32,30.19 68.32,30.49 68.42,30.59 68.63,30.59 68.73,30.49 68.73,30.19 68.83,30.09 69.03,30.09 69.13,30.19 69.13,30.49 69.24,30.59 69.44,30.59 69.54,30.49 69.54,30.19 69.64,30.09 69.85,30.09 69.95,30.19 69.95,30.49 70.05,30.59 70.25,30.59 70.35,30.49 70.35,30.19 70.46,30.09 70.66,30.09 70.76,30.19 70.76,30.49 70.86,30.59 72.73,30.59 72.83,30.69 72.83,33.9 75.12,36.18 79.39,36.18 82.43,39.23 82.61,39.23 83.12,39.74
M_B_DQ49: length 63.5
  TOP w0.102: U12.H8 v1(40.93,35.35)
  IN3 w0.089: v2(62.7,33.26) 62.57,33.39 62.16,33.39 61.66,33.9 61.02,33.9 60.39,34.53 59.88,34.53 58.55,35.86 55.93,35.86 55.2,35.13 51.1,35.13 47.99,38.24 45.28,38.24 45.15,38.37 44.01,38.37 43.27,37.63 43.27,36.79 42.23,35.75 41.33,35.75 v1(40.93,35.35)
  BOTTOM w0.089: U30.BC24 84,40.47 83.83,40.29 83.83,40.17 82.64,38.98
  BOTTOM w0.102: 82.64,38.98 82.5,38.84 82.5,38.83 81.48,37.82 81.48,37.59 79.69,35.8 75.25,35.8 73.85,34.4 73.85,33.71 73.75,33.6 73.29,33.6 73.19,33.5 73.19,33.3 73.29,33.2 73.75,33.2 73.85,33.1 73.85,32.89 73.75,32.79 73.29,32.79 73.19,32.69 73.19,32.49 73.29,32.39 73.75,32.39 73.85,32.28 73.85,32.08 73.75,31.98 73.29,31.98 73.19,31.88 73.19,31.67 73.29,31.57 73.75,31.57 73.85,31.47 73.85,31.12 73.75,31.01 73.32,31.01 73.21,30.91 73.21,30.71 73.32,30.61 73.75,30.61 73.85,30.51 73.85,29.83 73.72,29.7 63.43,29.7 62.7,30.44 v2(62.7,33.26)
M_B_DQ50: length 59.9
  TOP w0.102: v1(40.14,39.34) 39.75,38.95 U12.J3
  IN3 w0.089: v2(85.53,38.85) 85.53,39.48 85.47,39.55 85.34,39.55 85.15,39.36 85.02,39.36 84.83,39.55 84.83,39.67 85.02,39.86 85.02,39.99 84.45,40.57 84.07,40.57 84.01,40.63 84.01,41.01 83.88,41.13 83.68,41.13 83.59,41.05 83.59,40.64 83.5,40.55 83.34,40.55 83.25,40.64 83.25,41.01 83.12,41.13 82.93,41.13 82.84,41.05 82.84,40.63 82.75,40.54 82.57,40.54 82.48,40.63 82.48,41.05 82.4,41.13 81.98,41.13 81.85,41.26 81.09,41.26 80.96,41.13 80.33,41.13 80.2,41.26 79.67,41.26 78.93,40.52 73.42,40.52 70.85,37.96 70.55,37.96 68.14,35.55 64.32,35.55 60.26,39.61 60.13,39.61 59.88,39.36 59.88,39.34 59.61,39.34 59.37,39.58 59.37,39.99 59.19,40.17 50.38,40.17 48.83,41.73 44.97,41.73 44.87,41.83 41.55,41.83 40.87,41.15 40.87,40.19 40.54,39.85 40.54,39.74 v1(40.14,39.34)
  BOTTOM w0.089: 85.82,40.24 86,40.43 U30.BC22
  BOTTOM w0.102: v2(85.53,38.85) 85.91,39.23 85.91,39.64 85.82,39.74 85.82,40.24
M_B_DQ51: length 61
  TOP w0.102: v1(40.88,39.35) 41.28,39.75 U12.G2
  IN3 w0.089: v1(40.88,39.35) 40.88,39.71 41.31,40.14 41.31,41.11 41.69,41.49 44.72,41.49 44.83,41.38 48.68,41.38 50.24,39.83 58.39,39.83 59.37,38.85 60.44,38.85 64.1,35.19 68.59,35.19 68.91,35.51 68.91,35.64 68.87,35.67 68.87,35.8 69,35.92 69.12,35.92 69.16,35.89 69.29,35.89 69.41,36.01 69.41,36.14 69.38,36.18 69.38,36.3 69.5,36.43 69.63,36.43 69.66,36.39 69.79,36.39 69.92,36.52 69.92,36.64 69.88,36.68 69.88,36.8 70,36.93 70.13,36.93 70.17,36.89 70.29,36.89 70.42,37.02 70.42,37.14 70.38,37.18 70.38,37.31 70.51,37.43 70.63,37.43 70.67,37.4 70.8,37.4 73.57,40.17 74.12,40.17 74.2,40.08 74.2,40.07 74.29,39.98 74.47,39.98 74.56,40.07 74.56,40.08 74.65,40.17 74.83,40.17 74.92,40.08 74.92,40.07 75,39.98 75.18,39.98 75.27,40.07 75.27,40.08 75.36,40.17 75.54,40.17 75.63,40.08 75.63,40.07 75.72,39.98 75.89,39.98 75.98,40.07 75.98,40.08 76.07,40.17 76.25,40.17 76.34,40.08 76.34,40.07 76.43,39.98 76.6,39.98 76.69,40.07 76.69,40.08 76.78,40.17 76.96,40.17 77.05,40.08 77.05,40.07 77.14,39.98 77.32,39.98 77.4,40.07 77.4,40.08 77.49,40.17 77.67,40.17 77.76,40.08 77.76,40.07 77.85,39.98 78.03,39.98 78.12,40.07 78.12,40.08 78.21,40.17 79.08,40.17 79.67,40.75 80.21,40.75 80.3,40.66 80.3,40.07 80.39,39.98 80.57,39.98 80.66,40.07 80.66,40.66 80.75,40.75 81.34,40.75 81.47,40.63 81.47,40.25 81.6,40.12 83.73,40.12 84.75,39.1 84.75,38.47 84.62,38.34 v2(84.62,38.06)
  BOTTOM w0.089: 85.62,39.61 85.62,40.33 85.81,40.52 85.81,40.82 85.68,40.95 85.68,41.22 86,41.55 U30.BA22
  BOTTOM w0.102: v2(84.62,38.06) 84.62,38.09 84.75,38.21 84.75,38.61 85.62,39.48 85.62,39.61
M_B_DQ52: length 63.3
  TOP w0.102: U12.J7 v1(40.13,36.15)
  IN3 w0.089: v2(60.26,36.18) 60.26,36.65 59.95,36.97 57.82,36.97 57.34,37.45 55.16,37.45 55.07,37.36 55.07,36.97 54.98,36.89 54.81,36.89 54.72,36.97 54.72,37.36 54.63,37.45 54.45,37.45 54.36,37.36 54.36,36.97 54.27,36.89 54.09,36.89 54.01,36.97 54.01,37.36 53.92,37.45 53.74,37.45 53.65,37.36 53.65,36.97 53.56,36.89 53.38,36.89 53.29,36.97 53.29,37.36 53.21,37.45 52.94,37.45 52.79,37.3 52.47,37.3 52.32,37.45 50.28,37.45 48,39.73 47.62,39.73 47.53,39.64 47.53,39.36 47.44,39.27 47.26,39.27 47.17,39.36 47.17,39.64 47.09,39.73 44.76,39.73 44.43,39.4 43.59,39.4 42.25,38.06 42.25,37.22 42,36.97 41.51,36.97 41.42,37.06 41.42,37.99 41.31,38.1 41.16,38.1 41.03,37.98 41.03,37.06 v1(40.13,36.15)
  BOTTOM w0.089: 82.5,39.85 82.61,39.96 82.77,39.96 83.2,40.39 83.2,40.84 83.51,41.14 U30.BB25
  BOTTOM w0.102: v2(60.26,36.18) 60.34,36.1 61.55,36.1 61.65,36 61.65,35.77 61.75,35.67 61.96,35.67 62.06,35.77 62.06,36 62.16,36.1 62.75,36.1 62.93,35.93 62.93,35.04 64.49,33.48 64.49,33.33 64.06,32.9 64.06,32.76 64.21,32.62 64.35,32.62 64.78,33.04 64.92,33.04 65.06,32.9 65.06,32.76 64.64,32.33 64.64,32.19 64.78,32.04 64.92,32.04 65.35,32.47 65.5,32.47 65.97,31.99 69.91,31.99 74.86,36.94 79.13,36.94 81.93,39.74 82.38,39.74 82.5,39.85
M_B_DQ53: length 63.2
  TOP w0.102: U12.H7 v1(40.93,36.15)
  IN3 w0.089: v1(40.93,36.15) 41.4,36.63 42.14,36.63 42.59,37.08 42.59,37.92 43.73,39.06 45.43,39.06 45.56,38.93 48.32,38.93 50.44,36.8 50.6,36.8 50.84,37.05 50.98,37.05 51.09,36.94 51.09,36.67 51.22,36.54 52.39,36.54 52.63,36.78 52.93,36.78 53.17,36.54 59.12,36.54 60.37,35.29 61.07,35.29 v2(61.15,35.22)
  BOTTOM w0.089: 82.74,39.74 82.75,39.75 82.85,39.75 83.43,40.33 83.43,40.61 U30.BD25
  BOTTOM w0.102: 82.74,39.74 82.48,39.48 82.18,39.48 79.26,36.56 74.99,36.56 72.39,33.96 72.39,33.27 72.29,33.16 71.79,33.16 71.69,33.06 71.69,32.86 71.79,32.76 72.29,32.76 72.39,32.66 72.39,31.84 72.16,31.61 70.03,31.61 69.93,31.51 69.93,31.08 69.83,30.97 69.62,30.97 69.52,31.08 69.52,31.51 69.42,31.61 69.22,31.61 69.12,31.51 69.12,31.08 69.01,30.97 68.81,30.97 68.71,31.08 68.71,31.51 68.61,31.61 68.4,31.61 68.3,31.51 68.3,31.08 68.2,30.97 68,30.97 67.9,31.08 67.9,31.51 67.79,31.61 67.59,31.61 67.49,31.51 67.49,31.08 67.39,30.97 67.19,30.97 67.08,31.08 67.08,31.51 66.98,31.61 66.78,31.61 66.68,31.51 66.68,31.08 66.58,30.97 66.37,30.97 66.27,31.08 66.27,31.51 66.17,31.61 65.97,31.61 65.86,31.51 65.86,31.08 65.76,30.97 65.56,30.97 65.46,31.08 65.46,31.51 65.36,31.61 65.15,31.61 65.05,31.51 65.05,31.08 64.95,30.97 64.75,30.97 64.65,31.08 64.65,31.51 64.54,31.61 63.79,31.61 63.56,31.84 63.56,33.77 62.11,35.22 v2(61.15,35.22)
M_B_DQ54: length 60.1
  TOP w0.102: U12.H3 v1(40.93,38.55)
  IN3 w0.089: v1(40.93,38.55) 41.28,38.91 41.28,39.58 41.49,39.79 42.02,39.79 42.15,39.91 42.15,40.98 42.31,41.14 44.58,41.14 44.68,41.04 48.54,41.04 50.1,39.48 58.04,39.48 59.05,38.47 60.31,38.47 63.95,34.83 68.74,34.83 73.54,39.64 83.7,39.64 84.39,38.95 84.39,38.72 82.87,37.2 v2(82.87,36.54)
  BOTTOM w0.089: U30.BB22 85.32,41.31 85.32,40.94 85.2,40.82 85.2,40.55 85.21,40.55 85.21,39.66
  BOTTOM w0.102: v2(82.87,36.54) 82.87,37.2 84.34,38.67 84.34,38.78 84.34,38.79 85.21,39.66
M_B_DQ55: length 61.3
  TOP w0.102: U12.H2 v1(40.14,40.14)
  IN3 w0.089: v1(40.14,40.14) 40.53,40.53 40.53,41.31 41.38,42.17 45.01,42.17 45.11,42.07 48.97,42.07 50.53,40.51 59.94,40.51 64.53,35.93 68.01,35.93 70.48,38.4 70.79,38.4 73.26,40.88 78.78,40.88 79.54,41.64 82.05,41.64 82.18,41.52 84.01,41.52 85.91,39.61 85.91,38.59 85.28,37.96 85.05,37.96 84.39,37.3 v2(83.73,37.3)
  BOTTOM w0.089: 85.41,39.61 85.41,40.6 U30.BD22
  BOTTOM w0.102: v2(83.73,37.3) 83.73,37.77 84.54,38.59 84.54,38.7 85.41,39.57 85.41,39.61
M_B_DQ56: length 61.7
  TOP w0.102: v1(45.41,37.21) 45,37.62 45,38.18 44.53,38.66 U12.C3
  IN3 w0.089: v1(45.41,37.21) 45.82,36.8 47.17,36.8 50.83,33.14 59.11,33.14 60.39,31.86 71.21,31.86 75.15,35.81 76.54,37.2 80.58,37.2 82.46,35.32 83.54,35.32 84.2,34.66 84.39,34.66 v2(84.64,34.91)
  BOTTOM w0.089: U30.BA21 87,41.56 86.67,41.22 86.67,41 86.81,40.86 86.81,39.82
  BOTTOM w0.102: v2(84.64,34.91) 84.64,33.11 84.54,33.01 82.99,33.01 82.74,33.26 82.74,34.28 82.87,34.4 83.63,34.4 83.75,34.53 83.75,36.18 86.42,38.85 86.42,39.43 86.81,39.82
M_B_DQ57: length 61.9
  TOP w0.102: v1(45.41,37.84) 44.96,38.94 44.9,39.1 U12.C2
  IN3 w0.089: v1(45.41,37.84) 46.11,37.14 47.31,37.14 50.38,34.08 51.32,34.08 51.37,34.02 51.37,33.61 51.5,33.48 56.84,33.48 56.93,33.57 56.93,33.99 57.01,34.07 57.19,34.07 57.28,33.99 57.28,33.57 57.37,33.48 57.55,33.48 57.64,33.57 57.64,33.99 57.73,34.07 57.9,34.07 57.99,33.99 57.99,33.57 58.08,33.48 58.32,33.48 58.41,33.56 58.41,33.92 58.51,34.02 58.74,34.02 58.86,33.9 58.86,33.64 59.02,33.48 59.27,33.48 60.54,32.22 71.05,32.22 75,36.17 75.63,36.79 75.63,37.45 75.75,37.58 80.71,37.58 82.61,35.67 83.37,35.67 83.88,36.18 84.14,36.18 84.26,36.05 84.26,35.77 84.75,35.29 84.9,35.29 v2(85.28,35.67)
  BOTTOM w0.089: U30.BC21 87.01,41.09 87.01,40.36 87.02,40.35 87.02,39.74
  BOTTOM w0.102: 87.02,39.74 86.65,39.37 86.65,38.7 84.26,36.31 84.26,35.72 84.5,35.48 84.71,35.48 85.15,35.04 85.15,34.5 85.25,34.4 85.56,34.4 85.66,34.5 85.66,35.57 85.56,35.67 v2(85.28,35.67)
M_B_DQ58: length 60
  TOP w0.102: U12.B8 v1(45.73,34.55)
  IN3 w0.089: v1(45.73,34.55) 46.16,34.12 46.16,33.19 48.91,30.44 53.38,30.44 53.53,30.59 55.43,30.59 55.74,30.29 58.56,30.29 58.99,29.86 71.59,29.86 77.02,35.29 80.1,35.29 82.08,33.31 85.58,33.31 87.18,34.91 87.18,38.48 87.27,38.57 87.86,38.57 87.95,38.66 87.95,38.84 87.86,38.92 87.27,38.92 87.18,39.01 87.18,39.36 87.44,39.61 88.2,39.61 88.45,39.36 v2(88.45,38.24)
  BOTTOM w0.089: 89.23,39.86 89.23,40.22 89,40.45 U30.BC18
  BOTTOM w0.102: v2(88.45,38.24) 88.45,38.41 88.83,38.79 88.83,39.35 89.23,39.75 89.23,39.86
M_B_DQ59: length 60.5
  TOP w0.102: U12.C8 v1(44.93,34.55)
  IN3 w0.089: v2(88.45,37.07) 87.95,37.58 87.95,38 87.86,38.09 87.65,38.09 87.56,38 87.56,36.97 87.65,36.88 87.98,36.88 88.07,36.79 88.07,36.61 87.98,36.52 87.65,36.52 87.56,36.43 87.56,34.78 85.74,32.96 81.93,32.96 79.97,34.91 77.15,34.91 71.69,29.45 58.74,29.45 58.25,29.93 55.59,29.93 55.31,30.21 53.66,30.21 53.53,30.09 48.78,30.09 45.33,33.54 45.33,34.48 45.25,34.55 v1(44.93,34.55)
  BOTTOM w0.089: 89.46,39.86 89.46,40.29 89.2,40.54 89.2,40.84 89.51,41.14 U30.BB18
  BOTTOM w0.102: v2(88.45,37.07) 89.09,37.71 89.09,39.23 89.46,39.59 89.46,39.86
M_B_DQ60: length 60.6
  TOP w0.102: v1(46.68,37.84) 46.68,38.4 U12.A3
  IN3 w0.089: v2(84.64,35.93) 84.9,36.18 84.9,36.44 84.77,36.56 83.75,36.56 83.25,36.05 82.74,36.05 80.86,37.93 75.35,37.93 75.25,37.83 75.25,36.94 70.93,32.63 70.58,32.63 70.49,32.71 70.49,32.85 70.4,32.94 70.22,32.94 70.13,32.85 70.13,32.71 70.05,32.63 69.87,32.63 69.78,32.71 69.78,32.85 69.69,32.94 69.51,32.94 69.42,32.85 69.42,32.71 69.33,32.63 68.97,32.63 68.88,32.71 68.88,32.85 68.8,32.94 68.62,32.94 68.53,32.85 68.53,32.71 68.44,32.63 68.26,32.63 68.17,32.71 68.17,32.85 68.08,32.94 67.91,32.94 67.82,32.85 67.82,32.71 67.73,32.63 67.55,32.63 67.46,32.71 67.46,32.85 67.37,32.94 67.2,32.94 67.11,32.85 67.11,32.71 67.02,32.63 66.84,32.63 66.75,32.71 66.75,32.85 66.66,32.94 66.48,32.94 66.4,32.85 66.4,32.71 66.31,32.63 66.13,32.63 66.04,32.71 66.04,32.85 65.95,32.94 65.77,32.94 65.68,32.85 65.68,32.71 65.6,32.63 65.42,32.63 65.33,32.71 65.33,32.85 65.24,32.94 65.06,32.94 64.97,32.85 64.97,32.71 64.88,32.63 64.71,32.63 64.62,32.71 64.62,32.85 64.53,32.94 64.35,32.94 64.26,32.85 64.26,32.71 64.17,32.63 60.77,32.63 60.19,33.2 60.19,33.33 60.32,33.45 60.32,33.58 60.2,33.71 60.07,33.71 59.94,33.58 59.82,33.58 58.23,35.16 57.8,35.16 57.72,35.07 57.72,34.49 57.63,34.4 57.45,34.4 57.36,34.49 57.36,35.07 57.27,35.16 57.09,35.16 57,35.07 57,34.49 56.92,34.4 56.74,34.4 56.65,34.49 56.65,35.07 56.56,35.16 56.27,35.16 56.15,35.03 56.15,34.78 55.8,34.44 50.64,34.44 47.59,37.49 47.04,37.49 v1(46.68,37.84)
  BOTTOM w0.089: U30.BB20 87.35,41.34 87.35,41 87.2,40.85 87.2,40.54 87.24,40.5 87.24,39.66
  BOTTOM w0.102: 87.24,39.66 86.85,39.28 86.85,38.52 84.64,36.31 v2(84.64,35.93)
M_B_DQ61: length 61.1
  TOP w0.102: U12.D3 44.73,37.95 v1(44.73,37.32)
  IN3 w0.089: v1(44.73,37.32) 44.73,36.85 45.12,36.46 47.03,36.46 50.69,32.8 58.94,32.8 60.29,31.46 71.31,31.46 75.3,35.45 76.67,36.82 80.45,36.82 82.36,34.91 v2(82.74,34.91)
  BOTTOM w0.089: 86.17,39.61 86.17,39.69 86.02,39.83 86.02,40.15 86.2,40.33 86.2,40.84 86.34,40.98 86.34,41.32 U30.BB21
  BOTTOM w0.102: v2(82.74,34.91) 82.08,34.91 81.98,35.01 81.98,35.8 81.88,35.9 81.67,35.9 81.57,35.8 81.57,35.01 81.47,34.91 80.96,34.91 80.62,35.25 80.62,35.71 81.71,36.81 82.11,36.81 82.36,36.56 82.36,36.31 82.61,36.05 82.61,35.81 82.71,35.71 82.95,35.71 86.17,38.92 86.17,39.61
M_B_DQ62: length 60.8
  TOP w0.102: U12.D7 43.73,35.75 v1(44.13,35.35)
  IN3 w0.089: v1(44.13,35.35) 43.71,34.65 43.71,33.64 43.83,33.45 46.04,31.86 48.55,29.35 53.81,29.35 53.91,29.45 54.93,29.45 55.15,29.22 57.95,29.22 58.48,28.69 71.94,28.69 77.4,34.15 79.74,34.15 81.65,32.24 86.17,32.24 v2(88.45,34.53)
  BOTTOM w0.089: 88.33,39.74 88.2,39.87 88.2,40.83 88.32,40.94 88.32,41.3 U30.BB19
  BOTTOM w0.102: 88.33,39.74 88.33,39.23 87.82,38.72 87.82,35.17 v2(88.45,34.53)
M_B_DQ63: length 60.6
  TOP w0.102: U12.C7 v1(44.93,35.35)
  IN3 w0.089: v1(44.93,35.35) 44.53,34.95 44.53,33.59 44.93,33.18 45.2,33.18 48.65,29.73 53.68,29.73 53.78,29.83 55.05,29.83 55.31,29.58 58.1,29.58 58.58,29.09 71.84,29.09 77.28,34.53 79.85,34.53 81.78,32.6 85.89,32.6 87.95,34.66 87.95,35.93 88.07,36.05 88.2,36.05 v2(88.45,35.8)
  BOTTOM w0.089: U30.BA18 89,41.55 88.7,41.25 88.7,40.95 88.81,40.84 88.81,40.36 89.01,40.15 89.01,39.91 88.96,39.86
  BOTTOM w0.102: 88.96,39.86 88.57,39.47 88.57,38.96 88.02,38.41 88.02,36.23 v2(88.45,35.8)
M_B_DQSN0: length 60.5
  TOP w0.102: v1(41.71,84.93) 42.09,85.31 U5.F3
  IN3 w0.089: v1(41.71,84.93) 42.02,85.24 42.02,85.44 42.13,85.55 42.36,85.55 43.09,86.28 43.09,87.59 44,88.51 48.2,88.51 48.45,88.76 48.45,89.35 48.55,89.45 49.64,89.45 49.73,89.36 49.73,88.7 49.93,88.51 50.49,88.51 50.69,88.7 50.69,89.36 50.77,89.45 54.23,89.45 54.32,89.36 54.32,88.7 54.51,88.51 55.08,88.51 55.27,88.7 55.27,89.36 55.36,89.45 57.54,89.45 57.67,89.32 57.67,88.7 57.86,88.51 58.43,88.51 58.62,88.7 58.62,89.76 58.71,89.85 59.13,89.85 59.22,89.76 59.22,89.16 59.41,88.96 59.98,88.96 60.17,89.16 60.17,89.76 60.26,89.85 61.15,89.85 61.35,89.65 61.35,88.68 61.58,88.45 63.19,88.45 65.8,85.84 66.1,85.84 66.99,84.95 69.53,84.95 76.54,77.94 77.81,77.94 78.6,77.15 79.46,77.15 v2(79.49,77.18)
  BOTTOM w0.102: U30.D28 80.92,72 80.74,72 80.64,72.09 80.64,73.44 80.86,73.66 80.86,76.16 80.36,76.66 79.62,76.66 79.38,76.89 79.38,77.07 v2(79.49,77.18)
M_B_DQSN1: length 61.3
  TOP w0.102: v1(46.16,83.04) 45.94,83.04 45.81,82.92 45.81,82.23 45.94,82.11 U5.A7
  IN3 w0.089: v1(75.65,72.07) 75.42,72.3 75.42,72.45 74.61,73.27 73.59,73.27 73.41,73.45 73.41,73.57 74.23,74.39 74.23,74.66 73.83,75.06 73.56,75.06 72.74,74.25 72.61,74.25 72.31,74.54 72.31,74.67 73.13,75.49 73.13,75.76 72.73,76.16 72.46,76.16 71.64,75.34 71.52,75.34 71.22,75.64 71.22,75.76 72.04,76.58 72.04,76.86 71.64,77.26 71.36,77.26 70.54,76.44 70.42,76.44 70.12,76.74 70.12,76.86 70.94,77.68 70.94,77.95 70.54,78.35 70.27,78.35 69.45,77.53 69.32,77.53 69.08,77.77 69.08,77.9 69.58,78.4 69.58,78.67 69.22,79.03 68.95,79.03 68.45,78.53 68.33,78.53 65.82,81.04 64.68,81.04 63.86,81.85 63.54,81.85 62.75,81.06 62.62,81.06 62.33,81.36 62.33,81.48 63.14,82.3 63.14,82.57 62.74,82.97 62.47,82.97 61.4,81.9 61.27,81.9 60.97,82.2 60.97,82.32 61.78,83.13 61.78,83.5 61.51,83.77 49.62,83.77 49.13,83.29 47.61,83.29 46.96,82.64 46.05,82.64 45.96,82.74 45.96,82.84 v1(46.16,83.04)
  BOTTOM w0.102: v1(75.65,72.07) 75.42,71.84 75.42,71.71 75.58,71.55 76.45,71.55 77.4,70.6 77.4,70.14 78.71,68.83 78.88,68.83 79.03,68.68 79.35,68.68 79.48,68.81 79.74,68.81 80.07,68.49 U30.J29
M_B_DQSN2: length 60.7
  TOP w0.102: U6.F3 v1(41.73,74.33)
  IN3 w0.089: v1(41.73,74.33) 41.73,74 41.78,73.95 41.92,73.95 43.14,75.18 43.14,75.53 43.54,75.93 43.54,76.16 43.43,76.26 42.78,76.26 42.58,76.46 42.58,77.03 42.79,77.24 48.7,77.24 48.9,77.03 48.9,76.43 49.01,76.33 57.86,76.33 57.92,76.39 57.92,76.74 58.15,76.97 58.72,76.97 58.99,76.69 58.99,75.68 59.09,75.58 59.49,75.58 59.57,75.67 59.57,76.3 59.77,76.49 60.32,76.49 60.51,76.3 60.51,75.67 60.6,75.58 61.01,75.58 61.1,75.67 61.1,76.68 61.29,76.87 61.77,76.87 61.96,76.68 61.96,75.67 62.05,75.58 62.46,75.58 62.55,75.67 62.55,76.68 62.74,76.87 63.29,76.87 63.49,76.68 63.49,75.67 63.57,75.58 65.06,75.58 72.27,68.36 74.86,68.36 75.12,68.11 75.12,67.68 74.86,67.42 72.96,67.42 72.83,67.3 72.83,66.92 72.99,66.76 v1(73.09,66.76)
  BOTTOM w0.102: U30.M31 78.99,65.49 78.91,65.41 78.02,65.41 77.07,66.36 73.14,66.36 72.98,66.51 72.98,66.66 73.09,66.76 v1(73.09,66.76)
M_B_DQSN3: length 60.2
  TOP w0.102: U6.A7 45.82,71.03 45.82,71.84 45.97,72 v1(46.16,72)
  IN3 w0.089: v1(46.16,72) 46.11,72.05 45.78,72.05 45.67,71.94 45.67,71.47 45.78,71.37 57.46,71.37 57.9,70.93 59.2,70.93 59.63,71.37 60.5,71.37 60.89,70.98 60.89,70.07 60.98,69.98 61.32,69.98 61.41,70.07 61.41,71.17 61.6,71.37 62.1,71.37 62.29,71.17 62.29,70.07 62.38,69.98 62.79,69.98 62.88,70.07 62.88,70.78 63.08,70.98 63.59,70.98 63.87,70.7 63.87,70.06 63.99,69.94 64.6,69.94 70.19,64.35 74.2,64.35 74.43,64.13 74.43,63.07 74.52,62.98 74.85,62.98 74.94,63.07 74.94,64.11 75.13,64.3 75.63,64.3 75.82,64.11 75.82,59.58 75.95,59.45 76.32,59.45 76.47,59.6 76.47,61.13 76.66,61.33 77.21,61.33 77.4,61.13 77.4,59.07 77.53,58.94 78.04,58.94 78.14,59.04 78.14,61.23 78.04,61.33 77.79,61.33 77.61,61.51 77.61,61.87 77.52,61.96 v2(77.28,61.96)
  BOTTOM w0.102: v2(77.28,61.96) 77.63,62.31 77.74,62.31 77.99,62.57 78.89,62.57 78.97,62.49 U30.T31
M_B_DQSN4: length 59.9
  TOP w0.102: U9.A7 46,47.13 45.83,47.3 45.83,47.61 46.23,48.01 46.23,48.56 46.42,48.75 46.54,48.75 v1(46.8,49.01)
  IN3 w0.089: v1(46.8,49.01) 46.52,49.01 46.43,49.1 46.43,49.2 46.24,49.39 46.24,49.6 46.33,49.69 47.1,49.69 47.18,49.77 47.77,49.77 47.97,49.96 47.97,50.25 48.06,50.34 48.48,50.34 48.56,50.25 48.56,49.96 48.76,49.77 49.27,49.77 49.46,49.96 49.46,50.2 49.59,50.33 50.05,50.33 50.15,50.23 50.15,49.64 51.03,48.75 51.44,48.75 51.52,48.83 51.98,48.83 52.06,48.75 52.63,48.75 52.73,48.85 53.43,48.85 53.53,48.75 54.18,48.75 54.28,48.85 54.98,48.85 55.08,48.75 55.73,48.75 55.83,48.85 56.53,48.85 56.63,48.75 57.52,48.75 57.61,48.67 57.61,48.48 57.8,48.29 58.37,48.29 58.56,48.48 58.56,48.67 58.65,48.75 59.07,48.75 59.16,48.67 59.16,47.8 59.35,47.61 59.92,47.61 60.11,47.8 60.11,48.67 60.2,48.75 60.68,48.75 60.77,48.67 60.77,47.82 60.96,47.63 61.8,47.63 61.97,47.8 62.23,47.8 62.42,47.99 62.42,48.67 62.51,48.76 62.92,48.76 63.12,48.56 63.12,48.06 63.31,47.87 63.82,47.87 64.12,47.56 64.12,46.94 64.03,46.85 63.39,46.85 63.2,46.66 63.2,46.33 63.56,45.96 64.24,45.96 64.44,45.76 65.7,45.76 65.78,45.67 65.78,43.74 66.05,43.47 66.54,43.47 66.74,43.66 66.74,45.51 66.94,45.71 67.23,45.71 67.32,45.62 67.32,43.79 67.64,43.47 68.2,43.47 68.4,43.66 68.4,44.55 68.49,44.64 68.9,44.64 68.99,44.55 68.99,43.66 69.19,43.47 71.61,43.47 71.89,43.75 72.12,43.75 72.4,43.47 73.01,43.47 73.2,43.66 73.2,43.75 73.29,43.84 73.71,43.84 73.8,43.75 73.8,43.06 73.99,42.87 75.56,42.87 75.75,43.06 75.75,44.14 75.84,44.23 77.19,44.23 77.34,44.09 77.34,43.99 77.15,43.8 77.15,43.74 77.06,43.65 v2(76.9,43.65)
  BOTTOM w0.102: v2(76.9,43.65) 76.92,43.67 76.93,43.67 77.26,44 77.48,44.22 78.39,44.22 78.66,44.49 79.6,44.49 U30.AU31
M_B_DQSN5: length 61.3
  TOP w0.102: U9.F3 42.08,50.33 41.87,50.12 41.87,49.25 v1(42.13,48.99)
  IN3 w0.089: v1(42.13,48.99) 41.95,48.99 41.84,48.88 41.84,48.26 42.92,47.18 42.92,44.75 43.2,44.47 49.82,44.47 50.69,43.6 58.16,43.6 58.36,43.4 58.36,43.08 58.45,42.99 58.86,42.99 58.95,43.08 58.95,43.4 59.15,43.6 60.21,43.6 65.21,38.59 66.81,38.59 67.01,38.39 68.31,38.39 68.65,38.72 68.65,38.85 68.21,39.28 68.21,39.56 69.91,41.26 70.73,41.26 70.93,41.07 70.93,40.26 70.73,40.07 70.12,40.07 69.91,39.86 69.91,39.51 70.27,39.15 v2(70.47,39.15)
  BOTTOM w0.102: U30.BB27 81.31,41.49 80.85,41.03 79.93,41.03 79.29,40.39 79.29,40.22 79.08,40 73.49,40 73.28,40.22 73.28,40.8 73.07,41.01 72.73,41.01 72.63,40.91 72.63,38.81 72.42,38.59 71.85,38.59 71.64,38.81 71.64,40.08 71.54,40.18 70.13,40.18 70.03,40.08 70.03,39.44 70.32,39.15 v2(70.47,39.15)
M_B_DQSN6: length 60.1
  TOP w0.102: v1(41.71,38.58) 41.75,38.58 U12.F3
  IN3 w0.089: v1(41.71,38.58) 41.73,38.58 42.86,39.72 42.86,40.42 42.99,40.55 44.37,40.55 44.45,40.47 48.3,40.47 50.43,38.34 57.97,38.34 58.53,37.78 60.18,37.78 63.87,34.1 68.82,34.1 70.18,35.46 70.31,35.46 71.01,34.76 71.28,34.76 71.69,35.16 71.69,35.43 70.98,36.14 70.98,36.26 71.28,36.56 71.41,36.56 72.11,35.86 72.38,35.86 72.78,36.26 72.78,36.53 72.08,37.23 72.08,37.36 72.38,37.65 72.5,37.65 73.2,36.95 73.48,36.95 73.88,37.35 73.88,37.63 73.18,38.33 73.18,38.45 73.77,39.05 82.08,39.05 v2(83.04,38.09)
  BOTTOM w0.102: v2(83.04,38.09) 83.04,38.71 83.15,38.81 83.15,38.9 83.72,39.47 84.46,39.47 84.82,39.83 84.82,40.81 84.67,40.95 84.67,41.23 84.75,41.3 84.89,41.44 84.89,41.77 U30.BA23
M_B_DQSN7: length 60.2
  TOP w0.102: U12.A7 v1(46.53,35.35)
  IN3 w0.089: v2(86.68,36.44) 86.68,36.23 86.59,36.14 86.33,36.14 86.1,35.91 86.1,34.72 85.28,33.9 82.3,33.9 80.22,35.98 76.9,35.98 71.51,30.59 59.5,30.59 59.37,30.72 59.37,31.23 59,31.6 58.69,31.6 58.43,31.34 58.43,31.05 58.28,30.9 57.92,30.9 57.77,31.05 57.77,31.81 57.59,31.99 57.09,31.99 56.54,31.44 55.61,31.44 55.45,31.28 53.89,31.28 53.73,31.44 51.2,31.44 50.86,31.1 49.72,31.1 49.46,31.35 49.46,31.48 49.97,31.99 49.97,32.37 49.59,32.75 48.83,32.75 48.21,33.37 47.94,33.37 47.48,32.91 47.35,32.91 47.1,33.16 47.1,33.28 47.56,33.75 47.56,34.65 47.31,34.91 46.44,34.91 46.29,35.06 46.29,35.24 46.4,35.35 v1(46.53,35.35)
  BOTTOM w0.102: v2(86.68,36.44) 87.04,36.44 87.31,36.7 87.31,38.85 87.81,39.35 87.81,40.81 87.81,40.82 87.7,40.92 87.7,40.92 87.67,40.95 87.67,41.23 87.7,41.26 87.7,41.26 88,41.56 U30.BA20
M_B_DQSP0: length 60.5
  TOP w0.102: v1(41.71,85.73) 41.71,85.69 U5.G3
  IN3 w0.089: v1(41.71,85.73) 42.29,85.73 42.91,86.36 42.91,87.67 43.93,88.68 48.12,88.68 48.27,88.83 48.27,89.42 48.47,89.62 49.72,89.62 49.91,89.43 49.91,88.77 50,88.68 50.42,88.68 50.51,88.77 50.51,89.43 50.7,89.62 54.31,89.62 54.5,89.43 54.5,88.77 54.59,88.68 55.01,88.68 55.1,88.77 55.1,89.43 55.29,89.62 57.62,89.62 57.84,89.4 57.84,88.77 57.93,88.68 58.35,88.68 58.44,88.77 58.44,89.84 58.63,90.03 59.2,90.03 59.39,89.84 59.39,89.23 59.48,89.14 59.9,89.14 59.99,89.23 59.99,89.84 60.18,90.03 61.22,90.03 61.53,89.72 61.53,88.76 61.65,88.63 63.26,88.63 65.88,86.02 66.18,86.02 67.06,85.13 69.61,85.13 76.62,78.12 77.89,78.12 78.67,77.33 78.97,77.33 79.06,77.42 v2(79.06,77.58)
  BOTTOM w0.102: U30.E29 80.45,71.54 80.45,73.52 80.67,73.73 80.67,76.08 80.29,76.47 79.54,76.47 79.06,76.95 v2(79.06,77.58)
M_B_DQSP1: length 61.2
  TOP w0.102: v1(45.27,83.04) 45.52,83.04 45.62,82.94 45.62,82.2 45.53,82.11 U5.B7
  IN3 w0.089: v1(74.9,72.07) 75.16,72.07 75.25,72.16 75.25,72.38 74.54,73.09 73.52,73.09 73.23,73.37 73.23,73.65 74.05,74.46 74.05,74.59 73.75,74.89 73.63,74.89 72.81,74.07 72.54,74.07 72.14,74.47 72.14,74.74 72.96,75.56 72.96,75.69 72.66,75.98 72.53,75.98 71.71,75.16 71.44,75.16 71.04,75.57 71.04,75.84 71.86,76.66 71.86,76.78 71.56,77.08 71.44,77.08 70.62,76.26 70.35,76.26 69.94,76.66 69.94,76.93 70.76,77.75 70.76,77.88 70.47,78.18 70.34,78.18 69.52,77.36 69.25,77.36 68.91,77.7 68.91,77.97 69.41,78.47 69.41,78.6 69.15,78.85 69.02,78.85 68.52,78.35 68.25,78.35 65.75,80.86 64.61,80.86 63.79,81.67 63.61,81.67 62.82,80.88 62.55,80.88 62.15,81.28 62.15,81.56 62.97,82.37 62.97,82.5 62.67,82.8 62.54,82.8 61.47,81.72 61.2,81.72 60.8,82.13 60.8,82.4 61.61,83.21 61.61,83.43 61.43,83.6 49.7,83.6 49.21,83.11 47.68,83.11 47.04,82.47 45.98,82.47 45.78,82.66 45.78,82.92 45.65,83.04 v1(45.27,83.04)
  BOTTOM w0.102: v1(74.9,72.07) 75.23,71.74 75.23,71.63 75.5,71.36 76.37,71.36 77.21,70.52 77.21,70.06 78.63,68.64 78.8,68.64 78.95,68.49 U30.J31
M_B_DQSP2: length 61.1
  TOP w0.102: U6.G3 v1(41.73,73.53)
  IN3 w0.089: v1(41.73,73.53) 41.74,73.53 43.32,75.1 43.32,75.46 43.71,75.85 43.71,76.23 43.51,76.44 42.86,76.44 42.76,76.54 42.76,76.96 42.87,77.06 48.62,77.06 48.73,76.96 48.73,76.36 48.94,76.15 57.94,76.15 58.1,76.31 58.1,76.67 58.22,76.79 58.64,76.79 58.81,76.62 58.81,75.6 59.02,75.4 59.56,75.4 59.75,75.59 59.75,76.22 59.84,76.31 60.25,76.31 60.34,76.22 60.34,75.59 60.53,75.4 61.08,75.4 61.28,75.59 61.28,76.61 61.36,76.69 61.7,76.69 61.78,76.61 61.78,75.59 61.98,75.4 62.53,75.4 62.72,75.59 62.72,76.61 62.81,76.69 63.22,76.69 63.31,76.61 63.31,75.59 63.5,75.4 64.98,75.4 72.2,68.19 74.79,68.19 74.94,68.03 74.94,67.75 74.79,67.6 72.88,67.6 72.66,67.37 72.66,66.97 v2(72.45,66.76)
  BOTTOM w0.102: U30.N30 79.87,65.13 79.5,65.13 79.33,65.3 79.07,65.3 78.98,65.21 77.94,65.21 76.99,66.17 73.06,66.17 72.46,66.76 v2(72.45,66.76)
M_B_DQSP3: length 60.1
  TOP w0.102: v1(45.27,72) 45.46,72 45.63,71.83 45.63,71.03 U6.B7
  IN3 w0.089: v2(77.98,61.96) 77.79,61.77 77.79,61.58 77.86,61.5 78.12,61.5 78.32,61.3 78.32,58.96 78.12,58.76 77.46,58.76 77.23,58.99 77.23,61.06 77.14,61.15 76.73,61.15 76.64,61.06 76.64,59.52 76.39,59.27 75.88,59.27 75.64,59.51 75.64,64.03 75.55,64.12 75.21,64.12 75.12,64.03 75.12,62.99 74.93,62.8 74.44,62.8 74.25,62.99 74.25,64.05 74.13,64.17 70.12,64.17 64.53,69.76 63.92,69.76 63.69,69.99 63.69,70.62 63.51,70.8 63.15,70.8 63.05,70.7 63.05,69.99 62.86,69.8 62.31,69.8 62.11,69.99 62.11,71.1 62.03,71.19 61.67,71.19 61.59,71.1 61.59,69.99 61.39,69.8 60.91,69.8 60.72,69.99 60.72,70.9 60.43,71.19 59.71,71.19 59.27,70.75 57.82,70.75 57.39,71.19 45.7,71.19 45.49,71.4 45.49,71.78 v1(45.27,72)
  BOTTOM w0.102: U30.T30 79.89,62.11 79.52,62.11 79.33,62.3 78.89,62.3 78.81,62.38 78.07,62.38 77.97,62.27 77.97,61.97 v2(77.98,61.96)
M_B_DQSP4: length 60
  TOP w0.102: U9.B7 45.64,47.44 45.64,47.68 46.04,48.08 v1(46.04,49.01)
  IN3 w0.089: v1(46.04,49.01) 46.04,49.39 46.06,49.41 46.06,49.68 46.25,49.87 47.03,49.87 47.1,49.95 47.7,49.95 47.79,50.04 47.79,50.33 47.98,50.52 48.55,50.52 48.74,50.33 48.74,50.04 48.83,49.95 49.2,49.95 49.29,50.04 49.29,50.28 49.52,50.51 50.13,50.51 50.33,50.3 50.33,49.71 51.11,48.93 51.37,48.93 51.45,49.01 52.06,49.01 52.13,48.93 52.56,48.93 52.66,49.03 53.5,49.03 53.6,48.93 54.11,48.93 54.21,49.03 55.05,49.03 55.15,48.93 55.66,48.93 55.76,49.03 56.6,49.03 56.7,48.93 57.6,48.93 57.79,48.74 57.79,48.56 57.88,48.47 58.3,48.47 58.39,48.56 58.39,48.74 58.58,48.93 59.15,48.93 59.34,48.74 59.34,47.88 59.43,47.79 59.85,47.79 59.94,47.88 59.94,48.74 60.13,48.93 60.75,48.93 60.95,48.74 60.95,47.9 61.03,47.81 61.73,47.81 61.9,47.98 62.15,47.98 62.24,48.07 62.24,48.75 62.43,48.94 62.99,48.94 63.3,48.64 63.3,48.13 63.39,48.04 63.89,48.04 64.3,47.64 64.3,46.86 64.11,46.67 63.47,46.67 63.38,46.58 63.38,46.4 63.64,46.14 64.31,46.14 64.51,45.93 65.77,45.93 65.96,45.74 65.96,43.81 66.13,43.65 66.47,43.65 66.56,43.74 66.56,45.58 66.86,45.88 67.31,45.88 67.5,45.69 67.5,43.86 67.71,43.65 68.13,43.65 68.22,43.74 68.22,44.62 68.41,44.82 68.98,44.82 69.17,44.62 69.17,43.74 69.26,43.65 71.54,43.65 71.82,43.93 72.2,43.93 72.48,43.65 72.93,43.65 73.02,43.74 73.02,43.82 73.22,44.02 73.78,44.02 73.98,43.82 73.98,43.13 74.06,43.04 75.49,43.04 75.58,43.13 75.58,44.22 75.77,44.41 77.26,44.41 77.51,44.16 77.51,43.91 77.53,43.9 77.53,43.65 v2(77.53,43.65)
  BOTTOM w0.102: U30.AU29 80.13,44.49 79.93,44.29 79.88,44.29 79.77,44.18 79.76,44.18 79.74,44.16 79.47,44.16 79.33,44.3 78.74,44.3 78.47,44.03 77.56,44.03 77.49,43.97 77.49,43.72 77.53,43.67 v2(77.53,43.65)
M_B_DQSP5: length 61.5
  TOP w0.102: U9.G3 41.68,49.98 41.68,49.2 v1(41.45,48.97)
  IN3 w0.089: v1(41.45,48.97) 41.67,48.75 41.67,48.18 42.75,47.1 42.75,44.68 43.13,44.29 49.74,44.29 50.62,43.42 58.09,43.42 58.18,43.33 58.18,43 58.37,42.81 58.94,42.81 59.13,43 59.13,43.33 59.22,43.42 60.13,43.42 65.14,38.42 66.74,38.42 66.94,38.21 68.39,38.21 68.82,38.65 68.82,38.92 68.39,39.36 68.39,39.48 69.99,41.08 70.66,41.08 70.75,40.99 70.75,40.33 70.66,40.25 70.04,40.25 69.73,39.94 v2(69.73,39.15)
  BOTTOM w0.102: U30.BA27 81.44,41.89 80.77,41.22 79.86,41.22 79.1,40.47 79.1,40.3 79,40.19 73.57,40.19 73.47,40.3 73.47,40.88 73.14,41.2 72.65,41.2 72.44,40.99 72.44,38.89 72.34,38.78 71.93,38.78 71.83,38.89 71.83,40.16 71.62,40.37 70.05,40.37 69.84,40.16 69.84,39.26 v2(69.73,39.15)
M_B_DQSP6: length 60
  TOP w0.102: U12.G3 41.67,39.3 41.67,39.31 41.68,39.32 v1(41.68,39.36)
  IN3 w0.089: v1(41.68,39.36) 41.68,39.09 41.76,39.01 41.9,39.01 42.68,39.79 42.68,40.5 42.91,40.73 44.44,40.73 44.52,40.65 48.38,40.65 50.51,38.52 58.05,38.52 58.61,37.96 60.26,37.96 63.94,34.28 68.75,34.28 70.11,35.64 70.38,35.64 71.09,34.94 71.21,34.94 71.51,35.23 71.51,35.36 70.81,36.06 70.81,36.34 71.21,36.74 71.48,36.74 72.18,36.03 72.31,36.03 72.6,36.33 72.6,36.46 71.9,37.16 71.9,37.43 72.3,37.83 72.58,37.83 73.28,37.13 73.4,37.13 73.7,37.43 73.7,37.55 73,38.26 73,38.53 73.7,39.23 82.15,39.23 82.76,38.62 82.9,38.62 82.99,38.71 82.99,38.98 83.12,39.1 83.37,39.1 83.45,39.03 v2(83.45,38.54)
  BOTTOM w0.102: v2(83.45,38.54) 83.34,38.66 83.34,38.82 83.79,39.28 84.54,39.28 85.01,39.75 85.01,41.09 U30.BC23
M_B_DQSP7: length 60.2
  TOP w0.102: U12.B7 v1(45.73,35.35)
  IN3 w0.089: v1(45.73,35.35) 45.99,35.35 46.11,35.23 46.11,34.99 46.37,34.73 47.23,34.73 47.39,34.58 47.39,33.82 46.92,33.36 46.92,33.08 47.28,32.73 47.55,32.73 48.01,33.19 48.14,33.19 48.76,32.57 49.52,32.57 49.8,32.3 49.8,32.06 49.29,31.56 49.29,31.28 49.64,30.92 50.94,30.92 51.27,31.26 53.66,31.26 53.82,31.1 55.53,31.1 55.69,31.26 56.61,31.26 57.16,31.81 57.52,31.81 57.59,31.74 57.59,30.97 57.85,30.72 58.35,30.72 58.61,30.97 58.61,31.27 58.76,31.42 58.93,31.42 59.19,31.15 59.19,30.65 59.42,30.42 71.59,30.42 76.97,35.8 80.15,35.8 82.23,33.72 85.36,33.72 86.28,34.64 86.28,35.84 86.41,35.97 86.59,35.97 86.68,35.88 v2(86.68,35.67)
  BOTTOM w0.102: v2(86.68,35.67) 86.68,35.8 87.5,36.63 87.5,38.77 88,39.27 U30.BC20
M_B_EVENT#: length 7.4
  BOTTOM w0.102: R578.1 74.48,51.8 75.09,51.19 77.18,51.19 77.69,50.68 78.75,50.68 78.95,50.48 79.16,50.48 79.51,50.14 79.86,50.14 U30.AL30
M_B_ODT0: length 149.8
  TOP w0.102: R113.2 v1(38.67,89.52)
  TOP w0.165: v1(38.55,85.7) 38.55,85.68 U5.K3 ; U6.K3 38.56,73.56 v1(38.56,73.53) ; v1(39.33,49.93) U9.K3 ; U12.K3 v1(38.52,38.54)
  IN2 w0.089: v1(38.55,85.7) 38.67,85.58 38.67,85.2 38.54,85.08 38.54,84.57 38.67,84.44 38.67,79.23 38.27,78.83 38.27,77.35 38.42,77.2 38.7,77.2 38.82,77.08 38.82,76.82 38.7,76.69 37.91,76.69 37.78,76.57 37.78,74.53 38.56,73.76 v1(38.56,73.53) 38.8,73.29 38.8,72.38 38.42,72 38.42,68.57 37.4,67.55 37.4,61.96 37.53,61.84 39.43,61.84 39.56,61.71 39.56,61.45 39.43,61.33 38.54,61.33 38.42,61.2 38.42,60.95 38.54,60.82 39.43,60.82 39.56,60.69 39.56,52.95 38.54,51.93 38.54,50.71 v1(39.33,49.93) 39.58,49.93 39.69,49.82 39.69,49.14 39.05,48.5 38.03,48.5 37.91,48.37 37.91,46.85 38.67,46.09 38.67,44.69 37.88,43.9 37.88,39 38.34,38.54 v1(38.52,38.54)
  IN3 w0.089: v1(38.55,85.7) 38.55,89.4 v1(38.67,89.52)
  IN3 w0.133: v1(38.52,38.54) 37.73,39.33 37.73,43.7 37.61,43.82 37.61,44.27 38.2,44.86 38.2,46.17 37.95,46.42 37.95,47.48 37.27,48.16 37.27,50.28 37.91,50.91 37.91,53.25 40.4,55.74 50.99,55.74 51.2,55.52 52.71,55.52 52.74,55.56 57.29,55.56 57.43,55.71 58.04,55.71 58.48,55.26 60.87,55.26 61.58,54.55 65.32,54.55 68.63,51.25 70.15,51.25 72.65,48.75 73.63,48.75 v2(74.07,48.31)
  BOTTOM w0.165: v2(74.07,48.31) 74.07,47.7 73.98,47.61 72.96,47.61 72.83,47.74 72.83,48.5 72.67,48.67 71.02,48.67 69.4,50.28 63.84,50.28 63.69,50.13 63.69,49.9 64.2,49.39 69.57,49.39 71.97,46.99 U30.AP32
