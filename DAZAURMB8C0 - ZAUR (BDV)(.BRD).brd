# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BGA1140-AMD-FP5
  round 0.305 smd: A3(-16.3,-10.4) A5(-16.3,-9.5) A7(-16.3,-8) A8(-16.3,-7) A10(-16.3,-6) A11(-16.3,-5) A12(-16.3,-4) A13(-16.3,-3) A14(-16.3,-2) A15(-16.3,-1) A16(-16.3,0) A18(-16.3,1) A19(-16.3,2) A20(-16.3,3) A21(-16.3,4) A22(-16.3,5) A23(-16.3,6) A25(-16.3,7) A26(-16.3,8) A28(-16.3,9.5) A30(-16.3,10.4) AA1(-1,-11.3) AA2(-1.5,-10.9) AA3(-1,-10.5) AA4(-1.5,-10.1) AA5(-1,-9.4) AA13(-1.2,-2.8) AA14(-1.2,-2) AA15(-1.2,-1.2) AA16(-1.2,-0.4) AA17(-1.2,0.4) AA18(-1.2,1.2) AA19(-1.2,2) AA20(-1.2,2.8) AA28(-1,9.4) AA29(-1.5,10.1) AA30(-1,10.5) AA31(-1.5,10.9) AA32(-1,11.3) AB2(-0.5,-10.9) AB4(-0.5,-10.1) AB13(-0.4,-2.8) AB14(-0.4,-2) AB15(-0.4,-1.2) AB16(-0.4,-0.4) AB17(-0.4,0.4) AB18(-0.4,1.2) AB19(-0.4,2) AB20(-0.4,2.8) AB29(-0.5,10.1) AB31(-0.5,10.9) AC1(0,-11.3) AC2(0.5,-10.9) AC3(0,-10.5) AC4(0.5,-10.1) AC5(0,-9.4) AC13(0.4,-2.8) AC14(0.4,-2) AC15(0.4,-1.2) AC16(0.4,-0.4) AC17(0.4,0.4) AC18(0.4,1.2) AC19(0.4,2) AC20(0.4,2.8) AC28(0,9.4) AC29(0.5,10.1) AC30(0,10.5) AC31(0.5,10.9) AC32(0,11.3) AD1(1,-11.3) AD2(1.5,-10.9) AD3(1,-10.5) AD4(1.5,-10.1) AD5(1,-9.4) AD13(1.2,-2.8) AD14(1.2,-2) AD15(1.2,-1.2) AD16(1.2,-0.4) AD17(1.2,0.4) AD18(1.2,1.2) AD19(1.2,2) AD20(1.2,2.8) AD28(1,9.4) AD29(1.5,10.1) AD30(1,10.5) AD31(1.5,10.9) AD32(1,11.3) AE1(2,-11.3) AE3(2,-10.5) AE5(2,-9.4) AE13(2,-2.8) AE14(2,-2) AE15(2,-1.2) AE16(2,-0.4) AE17(2,0.4) AE18(2,1.2) AE19(2,2) AE20(2,2.8) AE28(2,9.4) AE30(2,10.5) AE32(2,11.3) AF1(3,-11.3) AF2(2.5,-10.9) AF3(3,-10.5) AF4(2.5,-10.1) AF5(3,-9.4) AF13(2.8,-2.8) AF14(2.8,-2) AF15(2.8,-1.2) AF16(2.8,-0.4) AF17(2.8,0.4) AF18(2.8,1.2) AF19(2.8,2) AF20(2.8,2.8) AF28(3,9.4) AF29(2.5,10.1) AF30(3,10.5) AF31(2.5,10.9) AF32(3,11.3) AG1(4,-11.3) AG2(3.5,-10.9) AG3(4,-10.5) AG4(3.5,-10.1) AG5(4,-9.4) AG13(3.6,-2.8) AG14(3.6,-2) AG15(3.6,-1.2) AG16(3.6,-0.4) AG17(3.6,0.4) AG18(3.6,1.2) AG19(3.6,2) AG20(3.6,2.8) AG28(4,9.4) AG29(3.5,10.1) AG30(4,10.5) AG31(3.5,10.9) AG32(4,11.3) AH2(4.5,-10.9) AH4(4.5,-10.1) AH13(4.4,-2.8) AH14(4.4,-2) AH15(4.4,-1.2) AH16(4.4,-0.4) AH17(4.4,0.4) AH18(4.4,1.2) AH19(4.4,2) AH20(4.4,2.8) AH29(4.5,10.1) AH31(4.5,10.9) AJ1(5,-11.3) AJ2(5.5,-10.9) AJ3(5,-10.5) AJ4(5.5,-10.1) AJ5(5,-9.4) AJ13(5.2,-2.8) AJ14(5.2,-2) AJ15(5.2,-1.2) AJ16(5.2,-0.4) AJ17(5.2,0.4) AJ18(5.2,1.2) AJ19(5.2,2) AJ20(5.2,2.8) AJ28(5,9.4) AJ29(5.5,10.1) AJ30(5,10.5) AJ31(5.5,10.9) AJ32(5,11.3) AK1(6,-11.3) AK3(6,-10.5) AK5(6,-9.4) AK13(6,-2.8) AK14(6,-2) AK15(6,-1.2) AK16(6,-0.4) AK17(6,0.4) AK18(6,1.2) AK19(6,2) AK20(6,2.8) AK28(6,9.4) AK30(6,10.5) AK32(6,11.3) AL1(7,-11.3) AL2(6.5,-10.9) AL3(7,-10.5) AL4(6.5,-10.1) AL5(7,-9.4) AL13(6.8,-2.8) AL14(6.8,-2) AL15(6.8,-1.2) AL16(6.8,-0.4) AL17(6.8,0.4) AL18(6.8,1.2) AL19(6.8,2) AL20(6.8,2.8) AL28(7,9.4) AL29(6.5,10.1) AL30(7,10.5) AL31(6.5,10.9) AL32(7,11.3) AM1(8,-11.3) AM2(7.5,-10.9) AM3(8,-10.5) AM4(7.5,-10.1) AM5(8,-9.4) AM13(7.6,-2.8) AM14(7.6,-2) AM15(7.6,-1.2) AM16(7.6,-0.4) AM17(7.6,0.4) AM18(7.6,1.2) AM19(7.6,2) AM20(7.6,2.8) AM28(8,9.4) AM29(7.5,10.1) AM30(8,10.5) AM31(7.5,10.9) AM32(8,11.3) AN1(9,-11.3) AN2(8.5,-10.9) AN3(9,-10.5) AN4(8.5,-10.1) AN5(9,-9.4) AN28(9,9.4) AN29(8.5,10.1) AN30(9,10.5) AN31(8.5,10.9) AN32(9,11.3) AP1(10,-11.3) AP2(9.5,-10.9) AP3(10,-10.5) AP4(9.5,-10.1) AP5(10,-9.4) AP28(10,9.4) AP29(9.5,10.1) AP30(10,10.5) AP31(9.5,10.9) AP32(10,11.3) AR1(11,-11.3) AR2(10.5,-10.9) AR3(11,-10.5) AR4(10.5,-10.1) AR5(11,-9.4) AR28(11,9.4) AR29(10.5,10.1) AR30(11,10.5) AR31(10.5,10.9) AR32(11,11.3) AT2(11.5,-10.9) AT4(11.5,-10.1) AT29(11.5,10.1) AT31(11.5,10.9) AU1(12,-11.3) AU2(12.5,-10.9) AU3(12,-10.5) AU4(12.5,-10.1) AU5(12,-9.4) AU28(12,9.4) AU29(12.5,10.1) AU30(12,10.5) AU31(12.5,10.9) AU32(12,11.3) AV1(13,-11.3) AV3(13,-10.5) AV5(13,-9.4) AV28(13,9.4) AV30(13,10.5) AV32(13,11.3) AW2(13.5,-10.9) AW3(14,-10.5) AW4(13.5,-10.1) AW5(14,-9.5) AW28(14,9.5) AW29(13.5,10.1) AW30(14,10.5) AW31(13.5,10.9) AY1(14.5,-11.3) AY4(14.5,-10.1) AY6(14.5,-9) AY7(14.4,-8) AY8(14.4,-7) AY10(14.4,-6) AY11(14.4,-5) AY12(14.4,-4) AY13(14.4,-3) AY14(14.4,-2) AY15(14.4,-1) AY16(14.4,0) AY18(14.4,1) AY19(14.4,2) AY20(14.4,3) AY21(14.4,4) AY22(14.4,5) AY23(14.4,6) AY25(14.4,7) AY26(14.4,8) AY27(14.5,9) AY29(14.5,10.1) AY32(14.5,11.3) B6(-15.9,-8.5) B8(-15.9,-7.5) B9(-15.9,-6.5) B10(-15.9,-5.5) B11(-15.9,-4.5) B12(-15.9,-3.5) B13(-15.9,-2.5) B15(-15.9,-1.5) B16(-15.9,-0.5) B17(-15.9,0.5) B18(-15.9,1.5) B20(-15.9,2.5) B21(-15.9,3.5) B22(-15.9,4.5) B23(-15.9,5.5) B24(-15.9,6.5) B25(-15.9,7.5) B27(-15.9,8.5) BA5(15.1,-9.5) BA6(15.1,-8.5) BA8(15.1,-7.5) BA9(15.1,-6.5) BA10(15.1,-5.5) BA11(15.1,-4.5) BA12(15.1,-3.5) BA13(15.1,-2.5) BA15(15.1,-1.5) BA16(15.1,-0.5) BA17(15.1,0.5) BA18(15.1,1.5) BA20(15.1,2.5) BA21(15.1,3.5) BA22(15.1,4.5) BA23(15.1,5.5) BA24(15.1,6.5) BA25(15.1,7.5) BA27(15.1,8.5) BA28(15.1,9.5) BB1(15.4,-11.3) BB3(15.4,-10.4) BB6(15.5,-9) BB7(15.5,-8) BB8(15.5,-7) BB10(15.5,-6) BB11(15.5,-5) BB12(15.5,-4) BB13(15.5,-3) BB14(15.5,-2) BB15(15.5,-1) BB16(15.5,0) BB18(15.5,1) BB19(15.5,2) BB20(15.5,3) BB21(15.5,4) BB22(15.5,5) BB23(15.5,6) BB25(15.5,7) BB26(15.5,8) BB27(15.5,9) BB30(15.4,10.4) BB32(15.4,11.3) BC6(15.9,-8.5) BC8(15.9,-7.5) BC9(15.9,-6.5) BC10(15.9,-5.5) BC11(15.9,-4.5) BC12(15.9,-3.5) BC13(15.9,-2.5) BC15(15.9,-1.5) BC16(15.9,-0.5) BC17(15.9,0.5) BC18(15.9,1.5) BC20(15.9,2.5) BC21(15.9,3.5) BC22(15.9,4.5) BC23(15.9,5.5) BC24(15.9,6.5) BC25(15.9,7.5) BC27(15.9,8.5) BD3(16.3,-10.4) BD5(16.3,-9.5) BD7(16.3,-8) BD8(16.3,-7) BD10(16.3,-6) BD11(16.3,-5) BD12(16.3,-4) BD13(16.3,-3) BD14(16.3,-2) BD15(16.3,-1) BD16(16.3,0) BD18(16.3,1) BD19(16.3,2) BD20(16.3,3) BD21(16.3,4) BD22(16.3,5) BD23(16.3,6) BD25(16.3,7) BD26(16.3,8) BD28(16.3,9.5) BD30(16.3,10.4) C1(-15.4,-11.3) C3(-15.4,-10.4) C6(-15.5,-9) C7(-15.5,-8) C8(-15.5,-7) C10(-15.5,-6) C11(-15.5,-5) C12(-15.5,-4) C13(-15.5,-3) C14(-15.5,-2) C15(-15.5,-1) C16(-15.5,0) C18(-15.5,1) C19(-15.5,2) C20(-15.5,3) C21(-15.5,4) C22(-15.5,5) C23(-15.5,6) C25(-15.5,7) C26(-15.5,8) C27(-15.5,9) C30(-15.4,10.4) C32(-15.4,11.3) D5(-15.1,-9.5) D6(-15.1,-8.5) D8(-15.1,-7.5) D9(-15.1,-6.5) D10(-15.1,-5.5) D11(-15.1,-4.5) D12(-15.1,-3.5) D13(-15.1,-2.5) D15(-15.1,-1.5) D16(-15.1,-0.5) D17(-15.1,0.5) D18(-15.1,1.5) D20(-15.1,2.5) D21(-15.1,3.5) D22(-15.1,4.5) D23(-15.1,5.5) D24(-15.1,6.5) D25(-15.1,7.5) D27(-15.1,8.5) D28(-15.1,9.5) E1(-14.5,-11.3) E4(-14.5,-10.1) E6(-14.5,-9) E7(-14.4,-8) E8(-14.4,-7) E10(-14.4,-6) E11(-14.4,-5) E12(-14.4,-4) E13(-14.4,-3) E14(-14.4,-2) E15(-14.4,-1) E16(-14.4,0) E18(-14.4,1) E19(-14.4,2) E20(-14.4,3) E21(-14.4,4) E22(-14.4,5) E23(-14.4,6) E25(-14.4,7) E26(-14.4,8) E27(-14.5,9) E29(-14.5,10.1) E32(-14.5,11.3) F2(-13.5,-10.9) F3(-14,-10.5) F4(-13.5,-10.1) F5(-14,-9.5) F28(-14,9.5) F29(-13.5,10.1) F30(-14,10.5) F31(-13.5,10.9) G1(-13,-11.3) G3(-13,-10.5) G5(-13,-9.4) G28(-13,9.4) G30(-13,10.5) G32(-13,11.3) H1(-12,-11.3) H2(-12.5,-10.9) H3(-12,-10.5) H4(-12.5,-10.1) H5(-12,-9.4) H28(-12,9.4) H29(-12.5,10.1) H30(-12,10.5) H31(-12.5,10.9) H32(-12,11.3) J2(-11.5,-10.9) J4(-11.5,-10.1) J29(-11.5,10.1) J31(-11.5,10.9) K1(-11,-11.3) K2(-10.5,-10.9) K3(-11,-10.5) K4(-10.5,-10.1) K5(-11,-9.4) K28(-11,9.4) K29(-10.5,10.1) K30(-11,10.5) K31(-10.5,10.9) K32(-11,11.3) L1(-10,-11.3) L2(-9.5,-10.9) L3(-10,-10.5) L4(-9.5,-10.1) L5(-10,-9.4) L28(-10,9.4) L29(-9.5,10.1) L30(-10,10.5) L31(-9.5,10.9) L32(-10,11.3) M1(-9,-11.3) M2(-8.5,-10.9) M3(-9,-10.5) M4(-8.5,-10.1) M5(-9,-9.4) M28(-9,9.4) M29(-8.5,10.1) M30(-9,10.5) M31(-8.5,10.9) M32(-9,11.3) N1(-8,-11.3) N2(-7.5,-10.9) N3(-8,-10.5) N4(-7.5,-10.1) N5(-8,-9.4) N13(-7.6,-2.8) N14(-7.6,-2) N15(-7.6,-1.2) N16(-7.6,-0.4) N17(-7.6,0.4) N18(-7.6,1.2) N19(-7.6,2) N20(-7.6,2.8) N28(-8,9.4) N29(-7.5,10.1) N30(-8,10.5) N31(-7.5,10.9) N32(-8,11.3) P1(-7,-11.3) P2(-6.5,-10.9) P3(-7,-10.5) P4(-6.5,-10.1) P5(-7,-9.4) P13(-6.8,-2.8) P14(-6.8,-2) P15(-6.8,-1.2) P16(-6.8,-0.4) P17(-6.8,0.4) P18(-6.8,1.2) P19(-6.8,2) P20(-6.8,2.8) P28(-7,9.4) P29(-6.5,10.1) P30(-7,10.5) P31(-6.5,10.9) P32(-7,11.3) R1(-6,-11.3) R3(-6,-10.5) R5(-6,-9.4) R13(-6,-2.8) R14(-6,-2) R15(-6,-1.2) R16(-6,-0.4) R17(-6,0.4) R18(-6,1.2) R19(-6,2) R20(-6,2.8) R28(-6,9.4) R30(-6,10.5) R32(-6,11.3) T1(-5,-11.3) T2(-5.5,-10.9) T3(-5,-10.5) T4(-5.5,-10.1) T5(-5,-9.4) T13(-5.2,-2.8) T14(-5.2,-2) T15(-5.2,-1.2) T16(-5.2,-0.4) T17(-5.2,0.4) T18(-5.2,1.2) T19(-5.2,2) T20(-5.2,2.8) T28(-5,9.4) T29(-5.5,10.1) T30(-5,10.5) T31(-5.5,10.9) T32(-5,11.3) U2(-4.5,-10.9) U4(-4.5,-10.1) U13(-4.4,-2.8) U14(-4.4,-2) U15(-4.4,-1.2) U16(-4.4,-0.4) U17(-4.4,0.4) U18(-4.4,1.2) U19(-4.4,2) U20(-4.4,2.8) U29(-4.5,10.1) U31(-4.5,10.9) V1(-4,-11.3) V2(-3.5,-10.9) V3(-4,-10.5) V4(-3.5,-10.1) V5(-4,-9.4) V13(-3.6,-2.8) V14(-3.6,-2) V15(-3.6,-1.2) V16(-3.6,-0.4) V17(-3.6,0.4) V18(-3.6,1.2) V19(-3.6,2) V20(-3.6,2.8) V28(-4,9.4) V29(-3.5,10.1) V30(-4,10.5) V31(-3.5,10.9) V32(-4,11.3) W1(-3,-11.3) W2(-2.5,-10.9) W3(-3,-10.5) W4(-2.5,-10.1) W5(-3,-9.4) W13(-2.8,-2.8) W14(-2.8,-2) W15(-2.8,-1.2) W16(-2.8,-0.4) W17(-2.8,0.4) W18(-2.8,1.2) W19(-2.8,2) W20(-2.8,2.8) W28(-3,9.4) W29(-2.5,10.1) W30(-3,10.5) W31(-2.5,10.9) W32(-3,11.3) Y1(-2,-11.3) Y3(-2,-10.5) Y5(-2,-9.4) Y13(-2,-2.8) Y14(-2,-2) Y15(-2,-1.2) Y16(-2,-0.4) Y17(-2,0.4) Y18(-2,1.2) Y19(-2,2) Y20(-2,2.8) Y28(-2,9.4) Y30(-2,10.5) Y32(-2,11.3)
  round 0.406 smd: AA6(-1,-8.7) AA7(-1,-8) AA8(-1,-7.2) AA9(-1,-6.4) AA10(-1,-5.6) AA11(-1,-4.8) AA12(-1,-4) AA21(-1,4) AA22(-1,4.8) AA23(-1,5.6) AA24(-1,6.4) AA25(-1,7.2) AA26(-1,8) AA27(-1,8.7) AC6(0,-8.7) AC7(0,-8) AC8(0,-7.2) AC9(0,-6.4) AC10(0,-5.6) AC11(0,-4.8) AC12(0,-4) AC21(0,4) AC22(0,4.8) AC23(0,5.6) AC24(0,6.4) AC25(0,7.2) AC26(0,8) AC27(0,8.7) AD6(1,-8.7) AD7(1,-8) AD8(1,-7.2) AD9(1,-6.4) AD10(1,-5.6) AD11(1,-4.8) AD12(1,-4) AD21(1,4) AD22(1,4.8) AD23(1,5.6) AD24(1,6.4) AD25(1,7.2) AD26(1,8) AD27(1,8.7) AE6(2,-8.7) AE7(2,-8) AE8(2,-7.2) AE9(2,-6.4) AE10(2,-5.6) AE11(2,-4.8) AE12(2,-4) AE21(2,4) AE22(2,4.8) AE23(2,5.6) AE24(2,6.4) AE25(2,7.2) AE26(2,8) AE27(2,8.7) AF6(3,-8.7) AF7(3,-8) AF8(3,-7.2) AF9(3,-6.4) AF10(3,-5.6) AF11(3,-4.8) AF12(3,-4) AF21(3,4) AF22(3,4.8) AF23(3,5.6) AF24(3,6.4) AF25(3,7.2) AF26(3,8) AF27(3,8.7) AG6(4,-8.7) AG7(4,-8) AG8(4,-7.2) AG9(4,-6.4) AG10(4,-5.6) AG11(4,-4.8) AG12(4,-4) AG21(4,4) AG22(4,4.8) AG23(4,5.6) AG24(4,6.4) AG25(4,7.2) AG26(4,8) AG27(4,8.7) AJ6(5,-8.7) AJ7(5,-8) AJ8(5,-7.2) AJ9(5,-6.4) AJ10(5,-5.6) AJ11(5,-4.8) AJ12(5,-4) AJ21(5,4) AJ22(5,4.8) AJ23(5,5.6) AJ24(5,6.4) AJ25(5,7.2) AJ26(5,8) AJ27(5,8.7) AK6(6,-8.7) AK7(6,-8) AK8(6,-7.2) AK9(6,-6.4) AK10(6,-5.6) AK11(6,-4.8) AK12(6,-4) AK21(6,4) AK22(6,4.8) AK23(6,5.6) AK24(6,6.4) AK25(6,7.2) AK26(6,8) AK27(6,8.7) AL6(7,-8.7) AL7(7,-8) AL8(7,-7.2) AL9(7,-6.4) AL10(7,-5.6) AL11(7,-4.8) AL12(7,-4) AL21(7,4) AL22(7,4.8) AL23(7,5.6) AL24(7,6.4) AL25(7,7.2) AL26(7,8) AL27(7,8.7) AM6(8,-8.7) AM7(8,-8) AM8(8,-7.2) AM9(8,-6.4) AM10(8,-5.6) AM11(8,-4.8) AM12(8,-4) AM21(8,4) AM22(8,4.8) AM23(8,5.6) AM24(8,6.4) AM25(8,7.2) AM26(8,8) AM27(8,8.7) AN6(9,-8.7) AN7(9,-8) AN8(9,-7.2) AN9(9,-6.4) AN10(9,-5.6) AN11(9,-4.8) AN12(9,-4) AN13(9,-3) AN14(9,-2) AN15(9,-1) AN16(9,0) AN18(9,1) AN19(9,2) AN20(9,3) AN21(9,4) AN22(9,4.8) AN23(9,5.6) AN24(9,6.4) AN25(9,7.2) AN26(9,8) AN27(9,8.7) AP6(10,-8.7) AP7(10,-8) AP8(10,-7.2) AP9(10,-6.4) AP10(10,-5.6) AP12(9.8,-4) AP13(9.8,-3) AP14(9.8,-2) AP15(9.8,-1) AP16(9.8,0) AP18(9.8,1) AP19(9.8,2) AP20(9.8,3) AP21(9.8,4) AP23(10,5.6) AP24(10,6.4) AP25(10,7.2) AP26(10,8) AP27(10,8.7) AR6(11,-8.7) AR7(11,-8) AR8(11,-7.2) AR11(10.6,-5) AR12(10.6,-4) AR13(10.6,-3) AR14(10.6,-2) AR15(10.6,-1) AR16(10.6,0) AR18(10.6,1) AR19(10.6,2) AR20(10.6,3) AR21(10.6,4) AR22(10.6,5) AR25(11,7.2) AR26(11,8) AR27(11,8.7) AT10(11.1,-6.1) AT11(11.4,-5) AT12(11.4,-4) AT13(11.4,-3) AT14(11.4,-2) AT15(11.4,-1) AT16(11.4,0) AT18(11.4,1) AT19(11.4,2) AT20(11.4,3) AT21(11.4,4) AT22(11.4,5) AT23(11.1,6.1) AU6(12,-8.7) AU7(12,-8) AU8(12,-7) AU10(12.2,-6) AU11(12.2,-5) AU12(12.2,-4) AU13(12.2,-3) AU14(12.2,-2) AU15(12.2,-1) AU16(12.2,0) AU18(12.2,1) AU19(12.2,2) AU20(12.2,3) AU21(12.2,4) AU22(12.2,5) AU23(12.2,6) AU25(12,7) AU26(12,8) AU27(12,8.7) AV6(13,-8.7) AV7(13,-8) AV8(13,-7) AV10(13,-6) AV11(13,-5) AV12(13,-4) AV13(13,-3) AV14(13,-2) AV15(13,-1) AV16(13,0) AV18(13,1) AV19(13,2) AV20(13,3) AV21(13,4) AV22(13,5) AV23(13,6) AV25(13,7) AV26(13,8) AV27(13,8.7) AW7(13.7,-8) AW8(13.7,-7) AW10(13.7,-6) AW11(13.7,-5) AW12(13.7,-4) AW13(13.7,-3) AW14(13.7,-2) AW15(13.7,-1) AW16(13.7,0) AW18(13.7,1) AW19(13.7,2) AW20(13.7,3) AW21(13.7,4) AW22(13.7,5) AW23(13.7,6) AW25(13.7,7) AW26(13.7,8) F7(-13.7,-8) F8(-13.7,-7) F10(-13.7,-6) F11(-13.7,-5) F12(-13.7,-4) F13(-13.7,-3) F14(-13.7,-2) F15(-13.7,-1) F16(-13.7,0) F18(-13.7,1) F19(-13.7,2) F20(-13.7,3) F21(-13.7,4) F22(-13.7,5) F23(-13.7,6) F25(-13.7,7) F26(-13.7,8) G6(-13,-8.7) G7(-13,-8) G8(-13,-7) G10(-13,-6) G11(-13,-5) G12(-13,-4) G13(-13,-3) G14(-13,-2) G15(-13,-1) G16(-13,0) G18(-13,1) G19(-13,2) G20(-13,3) G21(-13,4) G22(-13,5) G23(-13,6) G25(-13,7) G26(-13,8) G27(-13,8.7) H6(-12,-8.7) H7(-12,-8) H8(-12,-7) H10(-12.2,-6) H11(-12.2,-5) H12(-12.2,-4) H13(-12.2,-3) H14(-12.2,-2) H15(-12.2,-1) H16(-12.2,0) H18(-12.2,1) H19(-12.2,2) H20(-12.2,3) H21(-12.2,4) H22(-12.2,5) H23(-12.2,6) H25(-12,7) H26(-12,8) H27(-12,8.7) J10(-11.1,-6.1) J11(-11.4,-5) J12(-11.4,-4) J13(-11.4,-3) J14(-11.4,-2) J15(-11.4,-1) J16(-11.4,0) J18(-11.4,1) J19(-11.4,2) J20(-11.4,3) J21(-11.4,4) J22(-11.4,5) J23(-11.1,6.1) K6(-11,-8.7) K7(-11,-8) K8(-11,-7.2) K11(-10.6,-5) K12(-10.6,-4) K13(-10.6,-3) K14(-10.6,-2) K15(-10.6,-1) K16(-10.6,0) K18(-10.6,1) K19(-10.6,2) K20(-10.6,3) K21(-10.6,4) K22(-10.6,5) K25(-11,7.2) K26(-11,8) K27(-11,8.7) L6(-10,-8.7) L7(-10,-8) L8(-10,-7.2) L9(-10,-6.4) L10(-10,-5.6) L12(-9.8,-4) L13(-9.8,-3) L14(-9.8,-2) L15(-9.8,-1) L16(-9.8,0) L18(-9.8,1) L19(-9.8,2) L20(-9.8,3) L21(-9.8,4) L23(-10,5.6) L24(-10,6.4) L25(-10,7.2) L26(-10,8) L27(-10,8.7) M6(-9,-8.7) M7(-9,-8) M8(-9,-7.2) M9(-9,-6.4) M10(-9,-5.6) M11(-9,-4.8) M12(-9,-4) M13(-9,-3) M14(-9,-2) M15(-9,-1) M16(-9,0) M18(-9,1) M19(-9,2) M20(-9,3) M21(-9,4) M22(-9,4.8) M23(-9,5.6) M24(-9,6.4) M25(-9,7.2) M26(-9,8) M27(-9,8.7) N6(-8,-8.7) N7(-8,-8) N8(-8,-7.2) N9(-8,-6.4) N10(-8,-5.6) N11(-8,-4.8) N12(-8,-4) N21(-8,4) N22(-8,4.8) N23(-8,5.6) N24(-8,6.4) N25(-8,7.2) N26(-8,8) N27(-8,8.7) P6(-7,-8.7) P7(-7,-8) P8(-7,-7.2) P9(-7,-6.4) P10(-7,-5.6) P11(-7,-4.8) P12(-7,-4) P21(-7,4) P22(-7,4.8) P23(-7,5.6) P24(-7,6.4) P25(-7,7.2) P26(-7,8) P27(-7,8.7) R6(-6,-8.7) R7(-6,-8) R8(-6,-7.2) R9(-6,-6.4) R10(-6,-5.6) R11(-6,-4.8) R12(-6,-4) R21(-6,4) R22(-6,4.8) R23(-6,5.6) R24(-6,6.4) R25(-6,7.2) R26(-6,8) R27(-6,8.7) T6(-5,-8.7) T7(-5,-8) T8(-5,-7.2) T9(-5,-6.4) T10(-5,-5.6) T11(-5,-4.8) T12(-5,-4) T21(-5,4) T22(-5,4.8) T23(-5,5.6) T24(-5,6.4) T25(-5,7.2) T26(-5,8) T27(-5,8.7) V6(-4,-8.7) V7(-4,-8) V8(-4,-7.2) V9(-4,-6.4) V10(-4,-5.6) V11(-4,-4.8) V12(-4,-4) V21(-4,4) V22(-4,4.8) V23(-4,5.6) V24(-4,6.4) V25(-4,7.2) V26(-4,8) V27(-4,8.7) W6(-3,-8.7) W7(-3,-8) W8(-3,-7.2) W9(-3,-6.4) W10(-3,-5.6) W11(-3,-4.8) W12(-3,-4) W21(-3,4) W22(-3,4.8) W23(-3,5.6) W24(-3,6.4) W25(-3,7.2) W26(-3,8) W27(-3,8.7) Y6(-2,-8.7) Y7(-2,-8) Y8(-2,-7.2) Y9(-2,-6.4) Y10(-2,-5.6) Y11(-2,-4.8) Y12(-2,-4) Y21(-2,4) Y22(-2,4.8) Y23(-2,5.6) Y24(-2,6.4) Y25(-2,7.2) Y26(-2,8) Y27(-2,8.7)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
C1808
  rect 1.041x2.311 smd: 1(-2.175,0) 2(2.175,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CF34302D0RA-05-NH-30P-L
  rect 0.305x1.295 smd: 1(-7.25,5.65) 2(-6.75,5.65) 3(-6.25,5.65) 4(-5.75,5.65) 5(-5.25,5.65) 6(-4.75,5.65) 7(-4.25,5.65) 8(-3.75,5.65) 9(-3.25,5.65) 10(-2.75,5.65) 11(-2.25,5.65) 12(-1.75,5.65) 13(-1.25,5.65) 14(-0.75,5.65) 15(-0.25,5.65) 16(0.25,5.65) 17(0.75,5.65) 18(1.25,5.65) 19(1.75,5.65) 20(2.25,5.65) 21(2.75,5.65) 22(3.25,5.65) 23(3.75,5.65) 24(4.25,5.65) 25(4.75,5.65) 26(5.25,5.65) 27(5.75,5.65) 28(6.25,5.65) 29(6.75,5.65) 30(7.25,5.65)
  rect 1.803x2.21 smd: 31(-9.4,0) 32(9.4,0)
D-0_6X0_3-0_32H-SMT
  custom 0.051x0.051 smd: 1(-0.242,0) 2(0.242,0)
D-1_2X0_8-0_7H
  rect 0.61x0.787 smd: 1(-0.85,0) 2(0.85,0)
D-1_85X1_25-2P-0_95H
  rect 0.787x0.889 smd: 1(-1.07,0) 2(1.07,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-SOD323-1_7X1_25-PMEG4005AEA
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-SOD323-1_85X1_25-0_95H
  rect 0.559x0.813 smd: 1(-1.15,0) 2(1.15,0)
DCJK-30706-00042-001-3P-SMT
  oval 1.6x2.489 hole 0.991x1.905: 1(0,8.15)
  oval 1.092x2.108 hole 0.508x1.499: 2(2.15,7.5) 3(-2.15,7.5)
  oval 1.194x3.607 hole 0.508x2.997: 4(-4.25,0) 5(4.25,0)
DDR4-D4AS0-26001-1P40-STD-SMT
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DFN6-1_4X1-5
  rect 0.533x0.254 smd: 1(0.362,-0.5) 2(0.362,0) 3(0.362,0.5) 4(-0.362,0.5) 5(-0.362,0) 6(-0.362,-0.5)
DFN6-1_4X1_2-4
  rect 0.508x0.203 smd: 1(0.5,-0.4) 2(0.5,0) 3(0.5,0.4) 4(-0.5,0.4) 5(-0.5,0) 6(-0.5,-0.4)
DFN8-2X2-5-9P-MAX8902B
  rect 0.305x0.889 smd: 1(-0.75,-1.15) 2(-0.25,-1.15) 3(0.25,-1.15) 4(0.75,-1.15) 5(0.75,1.15) 6(0.25,1.15) 7(-0.25,1.15) 8(-0.75,1.15)
  rect 1.295x0.711 smd: 9(0,0)
DFN14-3X2-4-11P-0_8H
  custom 0.125x0.125 smd: 1(-1.2,-0.9) 6(0.8,-0.9) 8(1.2,0.9) 13(-0.8,0.9)
  rect 0.203x0.508 smd: 3(-0.4,-0.9) 4(0,-0.9) 5(0.4,-0.9) 10(0.4,0.9) 11(0,0.9) 12(-0.4,0.9)
  rect 2.591x0.889 smd: 15(0,0)
ESD10-2_5X1-5-9P-AZ1143
  rect 0.254x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.381x1.549 smd: 3(0,0)
ESD10-4_1X2-8-11P
  rect 0.203x0.508 smd: 1(-1.8,-0.95) 2(-1,-0.95) 3(-0.2,-0.95) 4(0.6,-0.95) 5(1.4,-0.95) 6(1.8,0.95) 7(1,0.95) 8(0.2,0.95) 9(-0.6,0.95) 10(-1.4,0.95)
  rect 1.397x0.787 smd: 11(-0.4,0)
ESD-1X0_6-2P
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
H-C75D75N
  round 1.905 hole 1.905 unplated: (0,0)
H-C256I186D102P2
  custom 1.625x1.625 hole 2.591: 1(0,0)
H-DAVIDOFF-1
  round 5.994 hole 3.2: 1(0,0)
H-DAVIDOFF-1-1
  custom 2.15x2.15 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(0,2.921) 3(2.066,2.066) 4(2.921,0) 5(2.066,-2.066) 6(0,-2.921) 7(-2.066,-2.066) 8(-2.921,0) 9(-2.066,2.066)
H-S157D157N
  rect 3.988x3.988 hole 3.988 unplated: (0,0)
H-TC154IC154BC237D154PT-1
  round 3.912 hole 3.912: 1(0,0)
HDMI-10591-19001-19P
  round 0.813 hole 0.559: 1(-4.5,6.65) 2(-4,8.2) 3(-3.5,6.65) 4(-3,8.2) 5(-2.5,6.65) 6(-2,8.2) 7(-1.5,6.65) 8(-1,8.2) 9(-0.5,6.65) 10(0,8.2) 11(0.5,6.65) 12(1,8.2) 13(1.5,6.65) 14(2,8.2) 15(2.5,6.65) 16(3,8.2) 17(3.5,6.65) 18(4,8.2) 19(4.5,6.65)
  oval 1.803x2.794 hole 0.787x1.803: 20(-9.25,0) 22(9.25,0)
  oval 1.803x3.607 hole 0.787x2.591: 21(-7.25,7.6) 23(7.25,7.6)
HG-C276D126P2
  round 7.01 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(2.235,0) 3(1.581,1.581) 4(0,2.235) 5(-1.581,1.581) 6(-2.235,0) 7(-1.581,-1.581) 8(0,-2.235) 9(1.581,-1.581)
HG-C354I158D118P2
  round 8.992 hole 2.997: 1(0,0)
  round 0.61 hole 0.356: 2(0,3.048) 3(2.155,2.155) 4(3.048,0) 5(2.155,-2.155) 6(0,-3.048) 7(-2.155,-2.155) 8(-3.048,0) 9(-2.155,2.155)
HG-O335X315D252X232P2
  oval 8.509x8.001 hole 6.401x5.893: 1(0,0)
  round 0.61 hole 0.356: 2(0,3.556) 3(2.514,2.514) 4(3.683,0) 5(2.514,-2.514) 6(0,-3.556) 7(-2.514,-2.514) 8(-3.683,0) 9(-2.514,2.514)
HG-Z8E-EDADOC-1
  round 2.489 hole 2.489 unplated: (-6.37,0)
  custom 2.25x2.25 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(2.235,0) 3(1.581,1.581) 4(0,2.235) 5(-1.581,1.581) 6(-2.235,0) 7(-1.581,-1.581) 8(0,-2.235) 9(1.581,-1.581)
HG-Z8E-EDADOC-3
  custom 2x2 hole 5.613: 1(0,0)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L2_5X2-1_2
  rect 0.787x2.007 smd: 1(-1,0) 2(1,0)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L6_6X6_6-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
LGA16-3X3-5
  rect 0.305x0.94 smd: 1(-1,-1.525) 2(-0.5,-1.525) 3(0,-1.525) 4(0.5,-1.525) 5(1,-1.525) 9(1,1.525) 10(0.5,1.525) 11(0,1.525) 12(-0.5,1.525) 13(-1,1.525)
  rect 0.94x0.305 smd: 6(1.525,-0.5) 7(1.525,0) 8(1.525,0.5) 14(-1.525,0.5) 15(-1.525,0) 16(-1.525,-0.5)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
MSOP8-4_9-65-G547
  rect 0.356x1.397 smd: 1(-0.975,-2.5) 2(-0.325,-2.5) 3(0.325,-2.5) 4(0.975,-2.5) 5(0.975,2.5) 6(0.325,2.5) 7(-0.325,2.5) 8(-0.975,2.5)
NGFF-NASE0-S6701-TS40-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASM0-S6701-TSH4-KM-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
POWER-3X3-65-5P-ADNR21357
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(0,0)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5_67X4_8-1_27-5P
  rect 0.94x0.61 smd: 1(2.875,-1.905) 2(2.875,-0.635) 3(2.875,0.635) 4(2.875,1.905)
  custom 1.138x1.138 smd: 5(0,0)
POWER-5X6-1_27-7P-0_8H
  rect 0.66x0.635 smd: 1(-1.905,-2.84) 5(1.905,2.84) 6(0.635,2.84) 7(-0.635,2.84) 8(-1.905,2.84)
  custom 0.488x0.488 smd: 2(0,-2.18)
  rect 3.988x2.667 smd: 9(0,0.795)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
PWQFN20-4X4-5-26P-0_8H
  rect 0.279x0.991 smd: 1(-1,-1.9) 2(-0.5,-1.9) 3(0,-1.9) 4(0.5,-1.9) 5(1,-1.9) 11(1,1.9) 12(0.5,1.9) 13(0,1.9) 14(-0.5,1.9) 15(-1,1.9)
  rect 0.991x0.279 smd: 6(1.9,-1) 7(1.9,-0.5) 8(1.9,0) 9(1.9,0.5) 10(1.9,1) 16(-1.9,1) 17(-1.9,0.5) 18(-1.9,0) 19(-1.9,-0.5) 20(-1.9,-1)
  rect 2.159x2.159 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.75,-0.75) 23(0.75,-0.75) 24(0.75,0.75) 25(-0.75,0.75) 26(0,0)
QFN12-1_25X2_1-4
  rect 0.203x0.889 smd: 1(-0.8,-0.775) 2(-0.4,-0.775) 3(0,-0.775) 4(0.4,-0.775) 5(0.8,-0.775) 7(0.8,0.775) 8(0.4,0.775) 9(0,0.775) 10(-0.4,0.775) 11(-0.8,0.775)
  rect 1.194x0.254 smd: 6(1.05,0) 12(-1.05,0)
QFN12-3X3-45-0_6H
  rect 0.229x0.787 smd: 1(-0.619,-1.5) 6(-0.619,1.5)
  rect 0.229x1.346 smd: 2(0.101,-1.225) 3(1.001,-1.225)
  rect 0.229x2.286 smd: 4(0.551,0.76)
  rect 0.229x2.261 smd: 5(-0.169,0.76)
  rect 0.787x0.229 smd: 7(-1.5,1.125) 8(-1.5,0.675) 9(-1.5,0.225) 10(-1.5,-0.225) 11(-1.5,-0.675) 12(-1.5,-1.125)
QFN16-3X3-5-17P-TPS2546RTER
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN18-3X3-5
  custom 0.145x0.145 smd: 1(-1.25,-1.24) 6(1.25,-1.24) 10(1.25,1.24) 15(-1.25,1.24)
  custom 0.062x0.062 smd: 2(-0.75,-1.4) 3(-0.25,-1.4) 4(0.25,-1.4) 5(0.75,-1.4) 11(0.75,1.4) 12(0.25,1.4) 13(-0.25,1.4) 14(-0.75,1.4)
  custom 0.05x0.05 smd: 7(0.58,-0.45) 8(1.349,0) 9(0.58,0.45) 16(-1.405,0.65) 17(-0.583,0) 18(-1.405,-0.65)
QFN23-4X4-5-25P
  rect 0.254x0.787 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 12(1.25,2) 13(0.75,2) 14(0.25,2) 15(-0.25,2) 16(-0.75,2) 17(-1.25,2)
  rect 0.787x0.254 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.75) 11(2,1.25) 18(-2,1.25) 19(-2,0.75) 20(-2,0.25) 21(-2,-0.25) 22(-2,-0.75) 23(-2,-1.25)
  rect 2.591x1.295 smd: 24(0,-0.65)
  rect 2.591x0.889 smd: 25(0,0.85)
QFN24-4X4-5-25P-RT9921CGQV
  rect 0.305x0.991 smd: 1(-1.25,-2.1) 2(-0.75,-2.1) 3(-0.25,-2.1) 4(0.25,-2.1) 5(0.75,-2.1) 6(1.25,-2.1) 13(1.25,2.1) 14(0.75,2.1) 15(0.25,2.1) 16(-0.25,2.1) 17(-0.75,2.1) 18(-1.25,2.1)
  rect 0.991x0.305 smd: 7(2.1,-1.25) 8(2.1,-0.75) 9(2.1,-0.25) 10(2.1,0.25) 11(2.1,0.75) 12(2.1,1.25) 19(-2.1,1.25) 20(-2.1,0.75) 21(-2.1,0.25) 22(-2.1,-0.25) 23(-2.1,-0.75) 24(-2.1,-1.25)
  rect 2.515x2.515 smd: 25(0,0)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-5X5-5-33P-0_85H
  rect 0.305x0.991 smd: 1(-1.75,-2.6) 2(-1.25,-2.6) 3(-0.75,-2.6) 4(-0.25,-2.6) 5(0.25,-2.6) 6(0.75,-2.6) 7(1.25,-2.6) 8(1.75,-2.6) 17(1.75,2.6) 18(1.25,2.6) 19(0.75,2.6) 20(0.25,2.6) 21(-0.25,2.6) 22(-0.75,2.6) 23(-1.25,2.6) 24(-1.75,2.6)
  rect 0.991x0.305 smd: 9(2.6,-1.75) 10(2.6,-1.25) 11(2.6,-0.75) 12(2.6,-0.25) 13(2.6,0.25) 14(2.6,0.75) 15(2.6,1.25) 16(2.6,1.75) 25(-2.6,1.75) 26(-2.6,1.25) 27(-2.6,0.75) 28(-2.6,0.25) 29(-2.6,-0.25) 30(-2.6,-0.75) 31(-2.6,-1.25) 32(-2.6,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN40-5X5-4-41P-RT3662AC
  rect 0.203x0.838 smd: 1(-1.8,-2.475) 2(-1.4,-2.475) 3(-1,-2.475) 4(-0.6,-2.475) 5(-0.2,-2.475) 6(0.2,-2.475) 7(0.6,-2.475) 8(1,-2.475) 9(1.4,-2.475) 10(1.8,-2.475) 21(1.8,2.475) 22(1.4,2.475) 23(1,2.475) 24(0.6,2.475) 25(0.2,2.475) 26(-0.2,2.475) 27(-0.6,2.475) 28(-1,2.475) 29(-1.4,2.475) 30(-1.8,2.475)
  rect 0.838x0.203 smd: 11(2.475,-1.8) 12(2.475,-1.4) 13(2.475,-1) 14(2.475,-0.6) 15(2.475,-0.2) 16(2.475,0.2) 17(2.475,0.6) 18(2.475,1) 19(2.475,1.4) 20(2.475,1.8) 31(-2.475,1.8) 32(-2.475,1.4) 33(-2.475,1) 34(-2.475,0.6) 35(-2.475,0.2) 36(-2.475,-0.2) 37(-2.475,-0.6) 38(-2.475,-1) 39(-2.475,-1.4) 40(-2.475,-1.8)
  rect 3.404x3.404 smd: 41(0,0)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
QFN48-6X6-4-49P-PS8409
  custom 0.05x0.05 smd: 1(-2.2,-2.975) 2(-1.8,-2.975) 3(-1.4,-2.975) 4(-1,-2.975) 5(-0.6,-2.975) 6(-0.2,-2.975) 7(0.2,-2.975) 8(0.6,-2.975) 9(1,-2.975) 10(1.4,-2.975) 11(1.8,-2.975) 12(2.2,-2.975) 13(2.975,-2.2) 14(2.975,-1.8) 15(2.975,-1.4) 16(2.975,-1) 17(2.975,-0.6) 18(2.975,-0.2) 19(2.975,0.2) 20(2.975,0.6) 21(2.975,1) 22(2.975,1.4) 23(2.975,1.8) 24(2.975,2.2) 25(2.2,2.975) 26(1.8,2.975) 27(1.4,2.975) 28(1,2.975) 29(0.6,2.975) 30(0.2,2.975) 31(-0.2,2.975) 32(-0.6,2.975) 33(-1,2.975) 34(-1.4,2.975) 35(-1.8,2.975) 36(-2.2,2.975) 37(-2.975,2.2) 38(-2.975,1.8) 39(-2.975,1.4) 40(-2.975,1) 41(-2.975,0.6) 42(-2.975,0.2) 43(-2.975,-0.2) 44(-2.975,-0.6) 45(-2.975,-1) 46(-2.975,-1.4) 47(-2.975,-1.8) 48(-2.975,-2.2)
  rect 4.496x4.496 smd: 49(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RJ45-2RJ1622-001111F-8P
  round 1.295 hole 0.889: 1(3.57,2.3) 2(2.55,3.4) 3(1.53,2.3) 4(0.51,3.4) 5(-0.51,2.3) 6(-1.53,3.4) 7(-2.55,2.3) 8(-3.57,3.4)
  oval 1.803x2.616 hole 0.787x1.6: 9(8.4,-7.8) 10(8.4,0) 11(-8.4,-7.8) 12(-8.4,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
S1206
  rect 2.032x1.626 smd: 1(1.4,0) 2(-1.4,0)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SC70-2_1-65-6P-0_95H
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SOIC8-6-1_27-PM25LV010A
  rect 0.533x1.727 smd: 1(-1.905,-2.733) 2(-0.635,-2.733) 3(0.635,-2.733) 4(1.905,-2.733) 5(1.905,2.733) 6(0.635,2.733) 7(-0.635,2.733) 8(-1.905,2.733)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SON10-2_5X1-5-0_55H
  rect 0.305x0.559 smd: 1(-1,-0.385) 2(-0.5,-0.385) 4(0.5,-0.385) 5(1,-0.385) 6(1,0.385) 7(0.5,0.385) 9(-0.5,0.385) 10(-1,0.385)
  rect 0.33x0.559 smd: 3(0,-0.385) 8(0,0.385)
SOP8-6-1_27-9P-G5795F11U
  rect 0.406x1.981 smd: 1(-1.905,-3.15) 2(-0.635,-3.15) 3(0.635,-3.15) 4(1.905,-3.15) 5(1.905,3.15) 6(0.635,3.15) 7(-0.635,3.15) 8(-1.905,3.15)
  rect 3.607x2.438 smd: 9(0,0)
SOT23-1_7-65-3P
  rect 0.711x0.432 smd: 1(0.85,0.65) 2(0.85,-0.65) 3(-0.85,0)
SOT23-1_38-5-3P
  rect 0.533x0.381 smd: 1(0.69,0.5) 2(0.69,-0.5) 3(-0.69,0)
SOT23-2-95-3P
  rect 0.711x0.559 smd: 1(1,0.95) 2(1,-0.95) 3(-1,0)
SOT23-2_8-95-5P-G518A1TO1U
  rect 1.194x0.508 smd: 1(1.45,-0.95) 2(1.45,0) 3(1.45,0.95) 4(-1.45,0.95) 5(-1.45,-0.95)
SOT23-2_8-95-5P-LP2985-50DBVT
  rect 1.041x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,-0.95)
SOT23-2_8-95-6P-1_1H
  rect 1.092x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,0) 6(-1.35,-0.95)
SOT23-2_38-95-3P
  rect 0.787x0.533 smd: 1(1.19,0.95) 2(1.19,-0.95) 3(-1.19,0)
SOT23-2_85-95-5P
  rect 0.787x0.559 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SPAD-A3A5-EDADOC-1
  custom 1.275x1.275 smd: 1(0,0)
SPAD-C354NP
  round 8.992 smd: 1(0,0)
SPAD-RE3_5X5_0
  rect 3.5x5 smd: 1(0,0)
SPAD-RE5_98X2_0
  rect 5.98x2 smd: 1(0,0)
SPAD-RE209X315NP
  rect 5.309x8.001 smd: 1(0,0)
SW-NDT016-G1A-KKKT-4P
  round 1.041 hole 1.041 unplated: (0,-1.5)
  oval 0.838x0.94 hole 0.838x0.94 unplated: (0,1)
  rect 0.787x1.194 smd: 1(-2.15,-1.2) 2(-2.15,1.2) 3(2.15,-1.2) 4(2.15,1.2)
SW-T3AL-23-Q-TR-4P
  rect 0.66x0.711 smd: 1(-1.475,0.95) 2(1.475,0.95) 3(-1.475,-0.95) 4(1.475,-0.95)
SW-TME-532-V-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2050
  round 0.508 smd: 1(0,0)
TP2075
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TRF-N1010G-25P
  rect 0.635x1.778 smd: 1(-5.5,-4.54) 2(-4.5,-4.54) 3(-3.5,-4.54) 4(-2.5,-4.54) 5(-1.5,-4.54) 6(-0.5,-4.54) 7(0.5,-4.54) 8(1.5,-4.54) 9(2.5,-4.54) 10(3.5,-4.54) 11(4.5,-4.54) 12(5.5,-4.54) 13(5.5,4.45) 14(4.5,4.45) 15(3.5,4.45) 16(2.5,4.45) 17(1.5,4.45) 18(0.5,4.45) 19(-0.5,4.45) 20(-1.5,4.45) 21(-2.5,4.45) 22(-3.5,4.45) 23(-4.5,4.45) 24(-5.5,4.45)
  rect 0.889x0.787 smd: 25(-6.82,0)
UB3-USB-097-1R09HG-9P
  round 1.295 hole 0.813: 1(3.5,7.2) 2(1,7.2) 3(-1,7.2) 4(-3.5,7.2) 5(-4,5.7) 6(-2,5.7) 7(0,5.7) 8(2,5.7) 9(4,5.7)
  oval 1.295x2.896 hole 0.711x2.311: 10(6.4,6.45) 11(-6.4,6.45)
  oval 1.295x2.108 hole 0.711x1.499: 12(-7.85,0) 13(7.85,-3)
UB31-UCF3M-01N01-0P53-24P
  round 0.813 hole 0.813 unplated: (-3.45,0)
  oval 0.813x0.762 hole 0.813x0.762 unplated: (3.45,0)
  oval 0.991x1.6 hole 0.508x1.092: 5(-4.475,0.4) 6(4.475,0.4)
  oval 0.991x2.007 hole 0.508x1.499: 7(-6.075,-1.935) 8(6.075,-1.935) 9(-6.075,-5.8) 10(6.075,-5.8)
  custom 0.064x0.064 smd: A1(-2.75,-0.06) A12(2.75,-0.06)
  rect 0.254x0.61 smd: A2(-2.25,-0.06) A3(-1.75,-0.06) A4(-1.25,-0.06) A5(-0.75,-0.06) A6(-0.25,-0.06) A7(0.25,-0.06) A8(0.75,-0.06) A9(1.25,-0.06) A10(1.75,-0.06) A11(2.25,-0.06)
  oval 1.143x0.66 hole 0.889x0.406: B1(3.2,-1.135) B12(-3.2,-1.135)
  round 0.61 hole 0.457: B2(2.5,-2.035) B3(1.7,-2.035) B4(1.3,-1.135) B5(0.85,-2.035) B6(0.4,-1.135) B7(-0.4,-1.135) B8(-0.85,-2.035) B9(-1.3,-1.135) B10(-1.7,-2.035) B11(-2.5,-2.035)
unnamed
  round 1.016 smd: 1(0,0)
WTB-50278-00401-V01-4P-L
  rect 0.787x1.905 smd: 1(-1.875,4.925) 2(-0.625,4.925) 3(0.625,4.925) 4(1.875,4.925)
  rect 1.295x3.353 smd: 5(-4.725,0) 6(4.725,0)
WTB-50458-00801-V02-8P-L
  rect 0.559x1.295 smd: 1(-7,5.025) 2(-5,5.025) 3(-3,5.025) 4(-1,5.025) 5(1,5.025) 6(3,5.025) 7(5,5.025) 8(7,5.025)
  rect 1.295x2.057 smd: 9(-10.1,0) 10(10.1,0)
XTL-2_05X1_65-1_4X1_1-0_6H
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-3_2X1_5-2_5-SMT
  rect 0.991x1.6 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_6-0_9H
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTL-3_2X2_5-2_2X1_8-4P
  rect 1.397x1.194 smd: 1(-1.1,-0.9) 2(1.1,-0.9) 3(1.1,0.9) 4(-1.1,0.9)

## Nets
+0.75V: C186.1 C226.1 C231.1 C232.1 C243.1 C578.1 C583.1 C584.1 C585.1 C586.1 C588.1 R544.2 R545.2 U30.M15 U30.M16 U30.M18
+0.75V_S5: C359.1 C368.1 C383.1 C385.1 R280.2 R288.2 U30.AL11 U30.AL12 U30.AM12
+0.95V_SENSE_REMOTE: PR314.1 PR315.1
+0.95VS5_SENSE_REMOTE: PC248.2 PR305.1 PR306.1 PR313.1
+1.2V: C183.2 C184.2 C192.2 C195.2 C201.2 C204.2 C207.2 C208.2 C209.2 C210.2 C214.2 C216.1 PQ26.1(S) PR226.1 U28.6 U28.11 U28.15(VDDTX12#2) U28.18 U28.30 U28.43 U28.46
+1.2VSUS: C150.1 C151.2 C152.2 C165.1 C170.1 C180.1 C189.2 C190.2 C194.2 C200.1 C212.2 C213.2 C215.1 C218.1 C219.1 C220.2 C221.1 C223.2 C224.2 C228.2 C229.1 C230.1 C233.1 C234.1 C235.1 C236.1 C237.2 C238.1 C239.1 C240.1 C241.1 C242.1 C244.1 C248.1 C255.1 C257.2 C258.1 C259.2 C260.2 C265.1 C271.2 C272.1 C280.1 C281.1 C282.1 C283.2 C284.1 C287.1 C291.1 C293.2 C296.1 C297.1 C299.2 C300.1 C305.1 C310.1 C312.1 C314.1 C315.1 C317.1 C318.1 C319.2 C320.2 C321.2 C322.1 C323.1 C324.1 C326.1 C328.2 C330.1 C331.1 C333.2 C334.1 C340.2 C352.2 C355.2 C356.1 C358.1 C361.1 C376.1 C377.2 C378.1 C379.1 CN5.111 CN5.112 CN5.117 CN5.118 CN5.123 CN5.124 CN5.129 CN5.130 CN5.135 CN5.136 CN5.141 CN5.142 CN5.147 CN5.148 CN5.153 CN5.154 CN5.159 CN5.160 CN5.163 PC9.1 PC135.1 PC136.1 PC137.1 PC138.1 PC140.1 PL2.2 PQ26.3 PR6.1 PR7.1 R160.2 R173.1 R178.2 R182.2 R183.1 R578.2 R736.1 U5.A1 U5.A9 U5.B3 U5.B9 U5.C1 U5.D1 U5.D9 U5.F2 U5.F8 U5.G1 U5.G7 U5.G9 U5.J1 U5.J2 U5.J8 U5.J9 U5.L1 U5.L9 U5.R1 U5.T9 U6.A1 U6.A9 U6.B3 U6.B9 U6.C1 U6.D1 U6.D9 U6.F2 U6.F8 U6.G1 U6.G7 U6.G9 U6.J1 U6.J2 U6.J8 U6.J9 U6.L1 U6.L9 U6.R1 U6.T9 U9.A1 U9.A9 U9.B3 U9.B9 U9.C1 U9.D1 U9.D9 U9.F2 U9.F8 U9.G1 U9.G7 U9.G9 U9.J1 U9.J2 U9.J8 U9.J9 U9.L1 U9.L9 U9.R1 U9.T9 U12.A1 U12.A9 U12.B3 U12.B9 U12.C1 U12.D1 U12.D9 U12.F2 U12.F8 U12.G1 U12.G7 U12.G9 U12.J1 U12.J2 U12.J8 U12.J9 U12.L1 U12.L9 U12.R1 U12.T9 U30.AC20 U30.AC28 U30.AD23 U30.AD26 U30.AD28 U30.AD32 U30.AE20 U30.AE22 U30.AE25 U30.AE28 U30.AF23 U30.AF26 U30.AF28 U30.AF32 U30.AG20 U30.AG22 U30.AG25 U30.AG28 U30.AJ20 U30.AJ23 U30.AJ26 U30.AJ28 U30.AJ32 U30.AK22 U30.AK25 U30.AK28 U30.AL23 U30.AL26 U30.AL28 U30.AL32 U30.AM22 U30.AM25 U30.AM28 U30.AN21 U30.AN28 U30.AN32 U30.AP28 U30.AR32
+1.5V: PC129.1 PC130.1 PC131.1 PL5.2 PR104.2 R370.1
+1.05V_LAN: C48.2 C65.2 C70.2 C71.1 C72.2 C96.2 R66.2 U2.3 U2.8 U2.22 U2.30
+1.05V_LAN_REGOUT: C35.2 R66.1 U2.24
+1.8V: PQ8.1(S) PR213.1 PR256.1 PR258.1 R151.2 R163.2 R167.2 R168.2 R203.2 R206.2 R292.2 R312.2 R354.1 R356.1 R531.2 R532.2 R537.2 R538.2 R556.1 R653.1 R660.2 R665.1 R666.1 R695.2 R699.1
+1.8V_GFX: C101.1 C102.2 C115.1 C116.1 C117.1 C125.2 C134.2 C540.1 C541.1 FB1.2 PR25.1 PR131.1 PR137.2 PR224.2 R1.1 R10.1 R20.1 R23.1 R452.1 R453.1 R454.1 R471.1 R472.1 R473.1 R476.1 R477.1 R478.2 R498.1 R499.1 R507.1 R512.1 R522.1 R523.1 U25.AM13 U25.AM15 U25.AP15 U25.AR15
+1.8V_GFX_PG: PR17.2 PR135.1 PR216.1
+1.8V_S5: C313.1 C343.2 C632.1 CN7.1 CN7.19 PJ7.1 PQ8.3 R194.2 R197.2 R215.1 R220.2 R223.1 R240.1 R264.1 R278.2 R297.1 R320.2 R323.2 R343.1 R353.2 R549.1 R550.1 R551.1 R595.1 R597.1 R598.2 R623.2 R625.2 R637.2 R650.1 R667.1 R675.1 R720.1 TP76.1 U8.6(VCCB) U11.5 U34.8
+1.8V_S5_1V8: R649.2 R650.2 R653.2
+1.8V_SW: C671.2 C672.2 C673.2 EC3.1 R695.1 R710.2 R714.2 R720.2 U39.3(VDD(1V8))
+1.35V_GFX: C3.1 C4.1 C5.1 C6.1 C7.1 C8.1 C15.1 C18.1 C22.1 C23.1 C30.1 C36.1 C42.1 C45.1 C47.1 C49.1 C50.2 C57.1 C60.1 C63.1 C64.1 C68.1 C69.1 C75.1 C79.1 C82.1 C84.1 C85.2 C86.1 C87.1 C88.1 C95.2 C97.1 C106.1 C118.1 C119.1 C120.1 C121.1 C122.1 C123.1 C124.1 C126.1 C127.2 C131.1 C132.1 C133.1 C136.1 C137.1 C139.1 C140.1 C148.1 C154.1 C156.1 C158.1 C159.1 C160.1 C161.1 C163.1 C164.1 C166.1 C168.1 C169.1 C171.1 C172.1 C175.1 C176.1 C177.1 C178.1 C179.1 C542.1 C562.2 C566.2 PJ3.1 PR26.1 R47.1 R48.1 R49.1 R51.1 R90.1 R102.1 R125.1 R127.1 R495.1 R521.1 R526.1 R547.1 R554.1 U25.AC10 U25.AG10 U25.K11 U25.K13 U25.K19 U25.K23 U25.K27 U25.K31 U25.L10 U25.N10 U25.W10 VRAM1.B1 VRAM1.B3 VRAM1.B12 VRAM1.B14 VRAM1.C5 VRAM1.C10 VRAM1.D1 VRAM1.D3 VRAM1.D11 VRAM1.D12 VRAM1.D14 VRAM1.E5 VRAM1.E10 VRAM1.F1 VRAM1.F3 VRAM1.F12 VRAM1.F14 VRAM1.G1 VRAM1.G2 VRAM1.G4 VRAM1.G11 VRAM1.G13 VRAM1.G14 VRAM1.H3 VRAM1.H12 VRAM1.K3 VRAM1.K12 VRAM1.L1 VRAM1.L2 VRAM1.L4 VRAM1.L11 VRAM1.L13 VRAM1.L14 VRAM1.M1 VRAM1.M3 VRAM1.M12 VRAM1.M14 VRAM1.N5 VRAM1.N10 VRAM1.P1 VRAM1.P3 VRAM1.P11 VRAM1.P12 VRAM1.P14 VRAM1.R5 VRAM1.R10 VRAM1.T1 VRAM1.T3 VRAM1.T12 VRAM1.T14 VRAM2.B1 VRAM2.B3 VRAM2.B12 VRAM2.B14 VRAM2.C5 VRAM2.C10 VRAM2.D1 VRAM2.D3 VRAM2.D11 VRAM2.D12 VRAM2.D14 VRAM2.E5 VRAM2.E10 VRAM2.F1 VRAM2.F3 VRAM2.F12 VRAM2.F14 VRAM2.G1 VRAM2.G2 VRAM2.G4 VRAM2.G11 VRAM2.G13 VRAM2.G14 VRAM2.H3 VRAM2.H12 VRAM2.K3 VRAM2.K12 VRAM2.L1 VRAM2.L2 VRAM2.L4 VRAM2.L11 VRAM2.L13 VRAM2.L14 VRAM2.M1 VRAM2.M3 VRAM2.M12 VRAM2.M14 VRAM2.N5 VRAM2.N10 VRAM2.P1 VRAM2.P3 VRAM2.P11 VRAM2.P12 VRAM2.P14 VRAM2.R5 VRAM2.R10 VRAM2.T1 VRAM2.T3 VRAM2.T12 VRAM2.T14
+1V8_TPM_VSB: C442.1 C445.2 R343.2 R356.2 U16.1(VSB)
+1V8TPM: C417.2 C419.1 C432.1 C440.1 R312.1 R316.2 R323.1 R350.2 U16.8 U16.22
+1V_S5_ON: TP28.1 U15.95
+2.5V_SUS: C157.2 C191.2 C198.2 C225.2 C279.2 C329.2 C335.2 C381.2 C393.2 C397.1 C402.2 C405.2 C406.1 CN5.257 CN5.259 PR125.2 U5.B1 U5.R9 U6.B1 U6.R9 U9.B1 U9.R9 U12.B1 U12.R9
+3V: C129.2 C135.2 C559.2 C570.1 C623.1 CN5.255 PC199.2 PQ27.1(S) PR57.1 PR75.1 PR95.2 PR96.1 PR133.1 PR219.1 PR237.1 PR238.1 PR296.1 Q5.2 Q6.2 Q6.5 Q7.2 Q7.5 Q28.2 R43.1 R68.1 R73.1 R76.2 R78.2 R80.2 R92.2 R93.2 R116.1 R128.1 R129.1 R131.2 R133.1 R135.2 R137.1 R142.1 R164.1 R170.2 R202.1 R221.2 R224.2 R227.2 R230.2 R232.2 R236.2 R241.2 R242.1 R263.2 R276.1 R285.2 R286.1 R287.1 R295.1 R298.1 R300.2 R315.2 R329.1 R336.1 R340.1 R344.1 R347.1 R367.2 R375.2 R385.1 R426.1 R493.1 R508.1 R510.2 R525.1 R541.2 R542.1 R562.2 R615.2 R618.2 R641.2 R643.2 R661.2 R672.2 R673.2 R689.2 R690.1 U26.5 U32.1(VCC)
+3V_CCD_PWR1_C: CN2.32 CN2.33 Q43.1(S) R508.2 R509.1
+3V_DMIC: CN1.4 R493.2
+3V_EC: C412.1 R298.2 R305.2 U15.11
+3V_GFX: C1.1 C38.1 C130.1 C539.1 PC192.1 PQ27.3 PR19.1 PR129.1 PR193.1 PR217.2 PR218.1 PR246.1 R2.1 R5.1 R9.1 R11.1 R12.1 R14.2 R16.1 R19.1 R26.1 R31.1 R39.1 R41.1 R436.1 R438.1 R440.1 R441.1 R446.2 R447.2 R450.1 R451.1 R464.1 R466.2 R467.1 R468.1 R469.1 R470.1 U1.3(WP#) U1.7 U1.8 U3.5(VCC) U23.5(VCC) U25.AM31
+3V_HDMI: C174.2 C211.2 C575.2 C595.1 R136.1 R138.2 R534.1 R536.1 R539.1 R540.1 R542.2 R569.1 U28.1 U28.24
+3V_LAN: C11.1 C12.2 C13.2 C14.2 C51.1 C56.2 C107.2 C111.1 Q1.3 R54.1 R100.2 U2.11 U2.23(VDDREG) U2.32
+3V_LDO_EC: D14.1(CATHODE) PR63.1 R245.1 R247.2 R250.2 R255.2 R270.2 R331.2
+3V_RTC: C375.1 D7.3(CATHODE) R222.2 R261.2
+3V_RTC_0: CN20.1 R277.1
+3V_RTC_1: D7.1 R277.2
+3V_RTC_2: D7.2 R289.1 R290.2
+3V_S5: C308.2 C503.1 C518.1 C663.2 CN12.1 PC28.1 PC29.1 PR76.1 PR97.1 PU2.3(VIN) Q20.2 Q20.5 Q27.1(S) Q31.2 Q32.2 Q42.3 Q43.3 R54.2 R226.2 R228.2 R259.2 R260.2 R265.2 R267.2 R279.2 R281.2 R291.1 R293.2 R294.2 R305.1 R313.1 R346.1 R348.2 R349.2 R368.1 R404.1 R413.1 R417.1 R422.2 R430.2 R509.2 R519.1 R571.2 R572.2 R576.2 R589.2 R591.2 R593.2 R594.2 R601.2 R602.1 R671.1 R674.1 R678.1 R681.2 R686.2 R708.1 R734.2 R735.2 R748.2 U8.1 U14.5(VCC) U20.5 U33.5
+3V_SSD: C528.2 C529.1 C530.1 C531.1 C532.1 C533.1 C534.1 CN19.2 CN19.4 CN19.12 CN19.14 CN19.16 CN19.18 CN19.70 CN19.72 CN19.74 Q27.3 R425.2 R426.2 R427.1 R432.2 R434.2 U21.3
+3V_WLAN_P: C644.2 C645.1 C648.1 C707.2 C708.1 C709.2 C712.2 C713.1 C714.2 CN11.2 CN11.4 CN11.72 CN11.74 Q24.2 Q44.2 R276.2 R310.2 R397.2 R409.2 R704.1 U20.1(OUT)
+3VLCD_CON: C567.1 C568.1 C569.1 R82.1 U26.1(OUT)
+3VLCD_CON_R: C61.2 C66.1 CN2.34 CN2.35 CN2.36 R82.2
+3VPCU: C46.2 C404.1 C415.2 CN8.23 PC98.1 PC99.1 PC101.1 PJ6.1 PR68.1 PR84.2 PR91.2 PR110.2 PR225.2 PR332.2 PR334.2 PU4.1 PU4.6 Q1.1(S) R55.1 R62.1 R83.2 R246.2 R290.1 R332.2 R448.1 R630.2 R711.1
+3VPCU_EC: C364.1 C365.1 C374.1 C407.1 C408.1 C454.1 C510.1 L3.2 L7.1 R245.2 U15.26 U15.50 U15.92 U15.114 U15.121
+3VPCU_ECPLL: C363.1 L3.1 U15.127
+5V: C108.2 C114.1 C394.2 C409.1 C699.2 FAN1.1 L4.1 L14.1 PR204.1 PR333.2 Q41.1(S) R81.1 R382.1 R400.1 R684.1 R703.1 U4.3
+5V_HDD: C479.2 C480.1 C482.1 C497.1 HD1.2 HD1.3 HD1.4 Q23.3 R400.2 R701.1 R718.1
+5V_HDMIC: C579.1 CN4.18 R121.2 R122.2 RV6.1 U4.1(OUT)
+5V_KB: C710.2 C711.2 CN18.2 CN18.4 Q41.3
