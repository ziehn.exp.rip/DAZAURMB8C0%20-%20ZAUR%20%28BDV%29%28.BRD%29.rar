# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ57: length 55.1
  IN1 w0.089: v2(89.04,42.9) 89.11,42.83 89.11,41.91 87.53,40.34 87.53,39.32 87.1,38.89 87.1,38.76 85.28,36.94 85.13,36.94 83.48,35.29 82.23,35.29 81.2,36.32 76.35,36.32 72.67,32.64 69.28,32.64 69.19,32.55 69.19,32.02 69.1,31.93 68.92,31.93 68.83,32.02 68.83,32.55 68.74,32.64 68.57,32.64 68.48,32.55 68.48,32.02 68.39,31.93 68.21,31.93 68.12,32.02 68.12,32.55 68.03,32.64 67.86,32.64 67.77,32.55 67.77,32.02 67.68,31.93 67.5,31.93 67.41,32.02 67.41,32.55 67.32,32.64 67.14,32.64 67.06,32.55 67.06,32.02 66.97,31.93 66.79,31.93 66.7,32.02 66.7,32.55 66.61,32.64 66.43,32.64 66.34,32.55 66.34,32.02 66.26,31.93 66.08,31.93 65.99,32.02 65.99,32.55 65.9,32.64 65.72,32.64 65.63,32.55 65.63,32.02 65.54,31.93 65.37,31.93 65.28,32.02 65.28,32.55 65.19,32.64 65.01,32.64 64.92,32.55 64.92,32.02 64.83,31.93 64.66,31.93 64.57,32.02 64.57,32.55 64.48,32.64 64.16,32.64 63.45,31.93 62.15,31.93 59.38,34.7 55.92,34.7 v1(55.14,33.92)
  BOTTOM w0.102: U30.AW18 89.41,43.29 89.04,42.91 v2(89.04,42.9) ; CN5.237 57.42,35.21 57.29,35.08 56.28,35.08 55.14,33.94 v1(55.14,33.92)
M_A_DQ58: length 56.1
  IN1 w0.089: v1(53.56,32.23) 54.17,31.62 59.48,31.62 61.29,29.82 72.58,29.82 77.13,34.38 80.05,34.38 81.75,32.68 88.05,32.68 89.6,34.23 89.6,38.59 90.08,39.07 90.08,40.27 90.55,40.74 90.55,44.76 v2(90.99,45.2)
  BOTTOM w0.102: v1(53.56,32.23) 52.84,32.96 CN5.246 ; v2(90.99,45.2) 90.91,45.2 U30.AU16
M_A_DQ59: length 55.7
  IN1 w0.089: v2(90.99,42.95) 90.99,39.96 90.49,39.46 90.49,38.85 89.98,38.34 89.98,34.15 88.17,32.35 81.62,32.35 79.91,34.06 77.27,34.06 72.64,29.44 60.27,29.44 59.66,30.05 59.53,30.05 59.34,29.86 59.22,29.86 59.09,29.98 59.09,30.11 59.28,30.3 59.28,30.43 59.16,30.55 59.03,30.55 58.84,30.36 58.71,30.36 58.59,30.49 58.59,30.61 58.78,30.81 58.78,30.93 58.55,31.16 56.84,31.31 53.91,31.31 53.48,31.74 52.74,31.74 v1(52.18,32.29)
  BOTTOM w0.102: v1(52.18,32.29) 51.75,31.86 51.31,31.86 51.21,31.96 CN5.250 ; v2(90.99,42.95) 90.65,43.29 U30.AW16
M_A_DQ60: length 55.9
  IN1 w0.089: v1(53.51,35.93) 54.08,36.5 55.37,36.5 56.22,35.65 59.78,35.65 62.55,32.88 63.05,32.88 63.18,33.01 63.18,34.66 63.35,34.83 63.89,34.83 63.98,34.74 63.98,34.49 64.07,34.4 64.25,34.4 64.34,34.49 64.34,34.74 64.43,34.83 64.6,34.83 64.69,34.74 64.69,34.49 64.78,34.4 64.96,34.4 65.05,34.49 65.05,34.74 65.14,34.83 65.31,34.83 65.4,34.74 65.4,34.49 65.49,34.4 65.67,34.4 65.76,34.49 65.76,34.74 65.85,34.83 66.03,34.83 66.11,34.74 66.11,34.49 66.2,34.4 66.38,34.4 66.47,34.49 66.47,34.74 66.56,34.83 66.74,34.83 66.83,34.74 66.83,34.49 66.91,34.4 67.09,34.4 67.18,34.49 67.18,34.74 67.27,34.83 67.45,34.83 67.54,34.74 67.54,34.49 67.63,34.4 67.8,34.4 67.89,34.49 67.89,34.74 67.98,34.83 68.16,34.83 68.25,34.74 68.25,34.49 68.34,34.4 68.51,34.4 68.6,34.49 68.6,34.74 68.69,34.83 68.87,34.83 68.96,34.74 68.96,34.49 69.05,34.4 69.23,34.4 69.32,34.49 69.32,34.74 69.4,34.83 69.58,34.83 69.67,34.74 69.67,34.49 69.76,34.4 69.94,34.4 70.03,34.49 70.03,34.74 70.12,34.83 70.29,34.83 70.38,34.74 70.38,34.49 70.47,34.4 70.65,34.4 70.74,34.49 70.74,34.74 70.83,34.83 71,34.83 71.09,34.74 71.09,34.49 71.18,34.4 71.36,34.4 71.45,34.49 71.45,34.74 71.54,34.83 71.72,34.83 71.8,34.74 71.8,34.49 71.89,34.4 72.07,34.4 72.16,34.49 72.16,34.74 72.25,34.83 72.43,34.83 72.52,34.74 72.52,34.49 72.6,34.4 72.78,34.4 72.87,34.49 72.87,34.74 72.96,34.83 73.51,34.83 75.96,37.27 81.8,37.27 82,37.07 82.87,37.07 85.28,39.48 86.55,39.48 86.79,39.73 86.79,40.74 87.94,41.88 87.94,43.54 88.06,43.66 v2(88.07,43.66)
  BOTTOM w0.102: CN5.232 52.98,36.46 v1(53.51,35.93) ; U30.AW19 88.44,43.29 88.07,43.65 v2(88.07,43.66)
M_A_DQ61: length 56
  IN1 w0.089: v2(88.05,44.4) 88.45,44 88.45,42.02 87.05,40.61 87.05,39.6 85.48,38.04 85.23,38.04 83.25,36.05 82.48,36.05 81.58,36.96 76.09,36.96 73.22,34.09 72.77,34.09 72.69,34 72.69,33.73 72.6,33.64 72.42,33.64 72.33,33.73 72.33,34 72.24,34.09 72.06,34.09 71.97,34 71.97,33.73 71.89,33.64 71.71,33.64 71.62,33.73 71.62,34 71.53,34.09 71.35,34.09 71.26,34 71.26,33.73 71.17,33.64 71,33.64 70.91,33.73 70.91,34 70.82,34.09 70.64,34.09 70.55,34 70.55,33.73 70.46,33.64 70.28,33.64 70.2,33.73 70.2,34 70.11,34.09 69.93,34.09 69.84,34 69.84,33.73 69.75,33.64 69.57,33.64 69.48,33.73 69.48,34 69.4,34.09 69.22,34.09 69.13,34 69.13,33.73 69.04,33.64 68.86,33.64 68.77,33.73 68.77,34 68.68,34.09 68.51,34.09 68.42,34 68.42,33.73 68.33,33.64 68.15,33.64 68.06,33.73 68.06,34 67.97,34.09 67.8,34.09 67.71,34 67.71,33.73 67.62,33.64 67.44,33.64 67.35,33.73 67.35,34 67.26,34.09 67.08,34.09 67,34 67,33.73 66.91,33.64 66.73,33.64 66.64,33.73 66.64,34 66.55,34.09 66.37,34.09 66.28,34 66.28,33.73 66.2,33.64 66.02,33.64 65.93,33.73 65.93,34 65.84,34.09 65.66,34.09 65.57,34 65.57,33.73 65.48,33.64 65.31,33.64 65.22,33.73 65.22,34 65.13,34.09 64.95,34.09 64.86,34 64.86,33.73 64.77,33.64 64.6,33.64 64.51,33.73 64.51,34 64.42,34.09 63.63,34.09 63.5,33.96 63.5,32.87 63.19,32.56 62.41,32.56 59.65,35.33 55.44,35.33 v1(54.9,35.88)
  BOTTOM w0.102: CN5.233 57.55,36.21 57.06,35.72 55.06,35.72 v1(54.9,35.88) ; v2(88.05,44.4) 88.44,44.79 U30.AU19
M_A_DQ62: length 55.3
  IN1 w0.089: v2(91.01,47.4) 90.1,46.48 90.1,41.38 89.47,40.75 89.47,39.48 88.91,38.92 88.91,34.45 87.95,33.49 82,33.49 80.48,35.01 76.87,35.01 72.44,30.58 61.54,30.58 59.46,32.66 58.83,32.66 58.74,32.57 58.74,32.35 58.65,32.26 58.47,32.26 58.38,32.35 58.38,32.57 58.29,32.66 58.12,32.66 58.03,32.57 58.03,32.35 57.94,32.26 57.76,32.26 57.67,32.35 57.67,32.57 57.58,32.66 57.41,32.66 57.32,32.57 57.32,32.35 57.23,32.26 57.05,32.26 56.96,32.35 56.96,32.57 56.87,32.66 56.55,32.66 v1(56.24,32.35)
  BOTTOM w0.102: CN5.245 57.28,33.21 56.43,32.35 v1(56.24,32.35) ; v2(91.01,47.4) 90.71,47.4 U30.AP16
M_A_DQ63: length 55.6
  IN1 w0.089: v2(90.97,46.14) 90.3,45.46 90.3,41.07 89.72,40.5 89.72,39.23 89.24,38.75 89.24,34.33 88.02,33.11 81.88,33.11 80.29,34.7 77,34.7 72.51,30.2 61.42,30.2 59.67,31.94 55.33,31.94 v1(54.95,32.32)
  BOTTOM w0.102: U30.AT16 90.97,46.06 v2(90.97,46.14) ; CN5.249 57.36,32.21 56.64,31.48 55.79,31.48 v1(54.95,32.32)
M_A_DQSN0: length 47.6
  IN1 w0.089: v1(56.33,93.84) 56.09,93.84 55.95,93.7 55.95,93.49 56.09,93.35 56.88,93.35 57.17,93.64 57.67,93.64 58.74,92.57 61.02,92.57 61.52,92.07 61.52,91.39 61.75,91.16 62.43,91.16 63,90.59 63,89.9 76.29,76.62 77.1,76.62 79.18,74.54 79.18,73.52 79.56,73.14 79.56,69.33 81.08,67.81 81.08,67.3 81.25,67.13 83.22,67.13 83.42,66.93 83.42,66.8 v2(83.7,66.52)
  BOTTOM w0.102: CN5.11 57.5,93.71 57.21,93.41 56.18,93.41 56.06,93.53 56.06,93.71 56.19,93.84 v1(56.33,93.84) ; U30.M24 84.1,66.09 83.7,66.49 v2(83.7,66.52)
M_A_DQSN1: length 53.1
  IN1 w0.089: v1(52.37,88.92) 52.51,89.06 52.51,89.39 52.8,89.67 53.88,89.67 55.05,88.51 57.53,88.51 63.05,82.98 63.05,79.49 73.69,68.85 75.02,68.85 78.81,65.05 79.01,65.05 80.63,63.43 81.97,63.43 82.07,63.54 82.95,63.54 83.53,64.12 84.01,64.12 84.06,64.07 85.43,64.07 85.56,64.2 85.56,64.78 85.86,65.08 86.43,65.08 v2(87.02,64.49)
  BOTTOM w0.102: v2(87.02,64.49) 86.52,63.99 U30.P21 ; CN5.32 51.17,88.46 51.37,88.25 52.25,88.25 52.55,88.55 52.55,88.73 v1(52.37,88.92)
M_A_DQSN2: length 45.6
  TOP w0.102: v2(84.51,62.56) 84.51,62.52 84.12,62.14 82.31,62.14 81.6,62.85 80.07,62.85 79.44,63.49 78.29,63.49 77.79,63.99 77.79,64.63 72.2,70.22 71.31,70.22 67.38,74.15 67.08,74.15 66.79,73.86 66.65,73.86 66.36,74.15 66.36,74.29 66.65,74.58 66.65,74.88 66.25,75.28 65.95,75.28 65.66,74.99 65.52,74.99 65.23,75.28 65.23,75.42 65.52,75.71 65.52,76.01 58.29,83.23 55.9,83.23 55.53,82.86 55.53,82.52 55.42,82.41 v1(55.13,82.41)
  BOTTOM w0.102: v1(55.13,82.41) 55.19,82.41 55.81,83.04 57.38,83.04 57.55,83.21 CN5.53 ; v2(84.51,62.56) 84.51,62.59 U30.R24
M_A_DQSN3: length 46.8
  IN1 w0.089: v2(86.16,58.51) 85.94,58.51 85.86,58.59 85.86,58.75 85.44,59.17 83.58,59.17 83.11,59.64 80.62,59.64 79.65,60.6 77.9,60.6 74.64,63.87 71.18,63.87 57.41,77.63 55.49,77.63 54.22,76.36 52.84,76.36 52.67,76.54 52.67,76.75 52.88,76.96 v1(53.08,76.96)
  BOTTOM w0.102: v2(86.16,58.51) 86.16,58.64 U30.Y21 ; v1(53.08,76.96) 52.77,77.27 52.77,77.46 52.43,77.8 51.32,77.8 51.16,77.96 CN5.74
M_A_DQSN4: length 38.6
  IN1 w0.089: v1(56.28,50.36) 56.01,50.36 55.94,50.29 55.94,50.22 55.85,50.12 55.85,49.77 55.7,49.63 55.7,49.38 55.94,49.14 56.25,49.14 56.5,49.39 57.08,49.39 61.15,45.33 63.56,45.33 65.31,43.57 68.72,43.57 69.05,43.24 71.67,43.24 72,43.57 75.6,43.57 75.91,43.27 78.91,43.27 80.13,44.49 80.76,44.49 81.04,44.76 81.04,45.05 82.02,46.03 83.7,46.03 83.83,46.16 83.83,46.37 83.72,46.48 v2(83.54,46.48)
  BOTTOM w0.102: U30.AP24 84.1,46.89 83.7,46.48 v2(83.54,46.48) ; CN5.177 57.53,50.21 57.22,49.9 56.08,49.9 55.94,50.04 55.94,50.26 56.07,50.39 56.26,50.39 v1(56.28,50.36)
M_A_DQSN5: length 41.9
  TOP w0.102: v1(52.26,45.1) 52.38,45.21 52.38,45.62 52.59,45.83 57.61,45.83 58.56,44.88 58.93,44.88 62.48,41.32 74.94,41.32 75.45,40.82 79.1,40.82 79.23,40.94 80.66,40.94 81.42,40.18 82.15,40.18 83.99,42.02 84.25,42.02 84.41,42.18 84.41,43.82 v2(85.02,44.42)
  BOTTOM w0.102: U30.AV22 85.45,43.99 v2(85.02,44.42) ; CN5.198 51.1,44.96 51.41,44.65 52.33,44.65 52.45,44.77 52.45,44.91 v1(52.26,45.1)
M_A_DQSN6: length 46.8
  IN1 w0.089: v1(55.69,39.05) 55.9,39.26 55.9,39.51 56.24,39.84 57.09,39.84 57.9,39.03 58.29,39.03 58.38,39.11 58.38,40.04 58.57,40.23 59.14,40.23 59.33,40.04 59.33,39.11 59.42,39.03 60.22,39.03 60.31,39.11 60.31,39.98 60.5,40.17 61.07,40.17 61.26,39.98 61.26,39.11 61.35,39.03 62.06,39.03 63.5,37.58 72.2,37.58 74.18,39.56 81.16,39.56 81.72,40.12 82.11,40.12 82.61,40.63 83.02,40.63 83.96,41.57 84.7,41.57 85.41,42.27 85.41,44.56 85.69,44.84 86.07,44.84 86.29,45.07 86.29,46.34 86.5,46.54 86.88,46.54 87.05,46.71 v2(87.05,46.84)
  BOTTOM w0.102: CN5.219 57.37,39.71 57.28,39.8 56.21,39.8 55.97,39.56 55.97,39.32 v1(55.69,39.05) ; U30.AR20 87.37,46.39 87.05,46.71 v2(87.05,46.84)
M_A_DQSN7: length 56.1
  IN1 w0.089: v2(89,45.2) 89,45.46 89.22,45.68 89.37,45.68 89.67,45.39 89.67,41.71 88.96,41 88.96,39.86 87.9,38.79 87.9,35.16 86.81,34.07 82.31,34.07 80.78,35.6 76.65,35.6 72.26,31.22 61.85,31.22 59.83,33.23 53.47,33.23 53.12,33.58 53.12,33.8 53.2,33.88 v1(53.63,33.88)
  BOTTOM w0.102: v2(89,45.2) 89.39,45.59 U30.AT18 ; v1(53.63,33.88) 53.29,33.88 53.02,34.15 53.02,34.28 52.77,34.53 51.62,34.53 51.39,34.29 51.25,34.29 51.09,34.46 CN5.240
M_A_DQSP0: length 47.6
  IN1 w0.089: v1(55.56,93.84) 55.77,93.64 55.77,93.42 56.01,93.17 56.96,93.17 57.24,93.46 57.6,93.46 58.66,92.39 60.95,92.39 61.34,92 61.34,91.31 61.67,90.98 62.36,90.98 62.83,90.51 62.83,89.83 76.22,76.44 77.03,76.44 79.01,74.46 79.01,73.45 79.39,73.06 79.39,69.26 80.91,67.74 80.91,67.22 81.18,66.95 83.15,66.95 83.25,66.86 83.25,66.62 83.16,66.54 v2(82.93,66.54)
  BOTTOM w0.102: v2(82.93,66.54) 83.31,66.17 U30.M25 ; v1(55.56,93.84) 55.87,93.54 55.87,93.45 56.1,93.22 57.45,93.22 57.47,93.21 CN5.13
M_A_DQSP1: length 53.2
  IN1 w0.089: v1(53.02,88.92) 52.93,88.92 52.69,89.16 52.69,89.32 52.87,89.5 53.81,89.5 54.98,88.33 57.46,88.33 62.88,82.91 62.88,79.41 73.62,68.67 74.94,68.67 78.74,64.87 78.94,64.87 80.56,63.25 82.04,63.25 82.15,63.36 83.02,63.36 83.61,63.94 83.94,63.94 83.99,63.89 85.51,63.89 85.74,64.12 85.74,64.71 85.93,64.9 86.36,64.9 86.58,64.69 86.58,64.58 86.49,64.49 v2(86.14,64.49)
  BOTTOM w0.102: v2(86.14,64.49) 86.14,64.42 U30.P22 ; v1(53.02,88.92) 52.74,88.64 52.74,88.48 52.33,88.06 51.29,88.06 51.28,88.07 51.17,87.96 CN5.34
M_A_DQSP2: length 45.8
  TOP w0.102: v1(56.4,82.41) 55.82,82.41 55.72,82.52 55.72,82.78 55.98,83.04 58.21,83.04 65.33,75.93 65.33,75.79 65.04,75.5 65.04,75.2 65.44,74.8 65.74,74.8 66.03,75.09 66.17,75.09 66.46,74.8 66.46,74.66 66.17,74.37 66.17,74.07 66.57,73.67 66.87,73.67 67.16,73.95 67.3,73.95 71.23,70.03 72.12,70.03 77.6,64.55 77.6,63.92 78.21,63.3 79.36,63.3 79.99,62.66 81.52,62.66 82.23,61.95 84.1,61.95 v2(84.51,61.54)
  BOTTOM w0.102: v1(56.4,82.41) 56.37,82.39 55.77,82.39 55.67,82.49 55.67,82.63 55.89,82.85 57.4,82.85 57.55,82.71 CN5.55 ; U30.T24 84.51,61.59 v2(84.51,61.54)
M_A_DQSP3: length 47
  IN1 w0.089: v1(52.32,76.96) 52.49,76.79 52.49,76.47 52.77,76.19 54.29,76.19 55.56,77.46 57.34,77.46 71.11,63.69 74.57,63.69 77.83,60.43 79.58,60.43 80.54,59.46 83.03,59.46 83.5,58.99 85.36,58.99 85.68,58.67 85.68,58.06 v2(86.12,57.62)
  BOTTOM w0.102: v1(52.32,76.96) 52.58,77.22 52.58,77.38 52.35,77.61 51.29,77.61 51.14,77.46 CN5.76 ; U30.AA21 86.48,57.99 v2(86.12,57.62)
M_A_DQSP4: length 38.8
  IN1 w0.089: v1(55.52,50.36) 55.67,50.22 55.67,49.85 55.52,49.7 55.52,49.3 55.87,48.96 56.32,48.96 56.57,49.21 57.01,49.21 61.07,45.15 63.49,45.15 65.24,43.39 68.64,43.39 68.97,43.06 71.74,43.06 72.07,43.39 75.53,43.39 75.83,43.09 78.98,43.09 80.2,44.31 80.83,44.31 81.21,44.69 81.21,44.97 82.1,45.85 83.77,45.85 84.01,46.09 84.01,46.24 v2(84.2,46.43)
  BOTTOM w0.102: CN5.179 56,49.71 55.75,49.96 55.75,50.13 v1(55.52,50.36) ; v2(84.2,46.43) 84.2,46.46 84.74,46.99 U30.AP23
M_A_DQSP5: length 41.8
  TOP w0.102: v2(85.02,43.72) 84.87,43.87 84.73,43.87 84.6,43.74 84.6,42.1 84.33,41.83 84.07,41.83 82.23,39.99 81.34,39.99 80.58,40.75 79.31,40.75 79.18,40.63 75.37,40.63 74.86,41.13 62.4,41.13 58.85,44.69 58.48,44.69 57.53,45.64 52.67,45.64 52.57,45.54 52.57,45.42 v1(52.89,45.1)
  BOTTOM w0.102: CN5.200 52.41,44.46 52.64,44.69 52.64,44.84 v1(52.89,45.1) ; v2(85.02,43.72) 85.45,43.29 U30.AW22
M_A_DQSP6: length 46.5
  IN1 w0.089: v1(56.41,39.03) 56.18,39.03 56.08,39.14 56.08,39.44 56.31,39.67 57.01,39.67 57.83,38.85 58.36,38.85 58.56,39.04 58.56,39.97 58.65,40.05 59.06,40.05 59.15,39.97 59.15,39.04 59.35,38.85 60.29,38.85 60.49,39.04 60.49,39.9 60.58,39.99 60.99,39.99 61.08,39.9 61.08,39.04 61.28,38.85 61.98,38.85 63.43,37.4 72.27,37.4 74.26,39.38 81.24,39.38 81.8,39.94 82.18,39.94 82.69,40.45 83.09,40.45 84.03,41.39 84.77,41.39 85.58,42.2 85.58,44.49 85.76,44.66 86.14,44.66 86.47,44.99 86.47,46.27 86.57,46.37 86.74,46.37 86.87,46.24 v2(86.87,45.99)
  BOTTOM w0.102: v2(86.87,45.99) 87.1,45.99 87.5,45.59 U30.AT20 ; CN5.221 57.6,39.21 57.2,39.61 56.28,39.61 56.16,39.48 56.16,39.28 v1(56.41,39.03)
M_A_DQSP7: length 55.8
  IN1 w0.089: v2(89,46) 89.14,45.86 89.45,45.86 89.84,45.46 89.84,41.63 89.14,40.93 89.14,39.79 88.07,38.72 88.07,35.09 86.88,33.9 82.23,33.9 80.71,35.42 76.72,35.42 72.34,31.04 61.77,31.04 59.75,33.06 53.4,33.06 52.94,33.51 52.94,33.77 52.83,33.89 v1(52.56,33.89)
  BOTTOM w0.102: U30.AR18 89.39,46.39 v2(89,46) ; v1(52.56,33.89) 52.82,34.14 52.82,34.21 52.69,34.34 51.7,34.34 51.47,34.1 51.27,34.1 51.12,33.96 CN5.242
M_A_EVENT#: length 49.7
  TOP w0.102: v2(84.51,50.49) 83.97,51.03 81.97,51.03 81.84,51.16 81.22,51.16 80.69,50.62 80.24,50.62 79.92,50.94 74.46,50.94 74.1,51.29 72.32,51.29 66.64,56.98 66.64,57.46 64.78,59.31 57.87,59.31 57.21,58.66 55.18,58.66 54.67,58.15 54.67,57.77 54.29,57.39 51.75,57.39 50.84,58.3 50.84,62.37 50.35,62.85 48.7,62.85 48.58,62.98 R178.1 48.29,63.51 v2(48.37,63.59)
  BOTTOM w0.102: CN5.134 49.01,62.96 v2(48.37,63.59) ; U30.AK23 84.51,50.59 v2(84.51,50.49)
M_A_ODT0: length 39.1
  IN1 w0.102: v2(83.75,48.49) 83.35,48.88 81.34,48.88 80.71,48.25 80.2,48.25
  IN1 w0.14: 80.2,48.25 79.75,48.25 78.68,47.18 73.06,47.18 69.2,51.04 68.67,51.04 68.55,50.92 68.55,50.67 68.41,50.53 68.13,50.53 67.99,50.67 67.99,50.93 67.85,51.07 67.57,51.07 67.43,50.93 67.43,50.67 67.29,50.53 67.01,50.53 66.87,50.67 66.87,50.94 66.74,51.07 64.8,51.07 62.82,53.05 59.68,53.05 57.62,55.1 55.38,55.1 55.18,55.31 v2(55.18,55.96)
  BOTTOM w0.165: U30.AM24 83.75,48.63 v2(83.75,48.49) ; v2(55.18,55.96) 55.65,55.49 57.34,55.49 57.56,55.71 CN5.155
M_A_ODT1: length 39.1
  IN1 w0.14: v2(82.22,48.49) 81.33,48.49 80.71,47.87 80.05,47.87 78.98,46.8 72.92,46.8 70.58,49.14 69.76,49.14 69.62,49.27 69.62,50.01 69.4,50.23 69.2,50.23 69.06,50.09 69.06,49.27 68.92,49.14 68.64,49.14 68.5,49.27 68.5,50.01 68.36,50.15 68.08,50.15 67.94,50.01 67.94,49.4 67.8,49.26 67.52,49.26 67.38,49.4 67.38,50.01 67.24,50.15 66.96,50.15 66.82,50.01 66.82,49.66 66.68,49.52 66.4,49.52 66.26,49.66 66.26,50.47 66.05,50.68 64.66,50.68 62.67,52.68 59.52,52.68 58.24,53.96 56.2,53.96 v2(55.69,54.47)
  BOTTOM w0.165: U30.AM27 81.81,48.91 v2(82.22,48.49) ; CN5.161 57.48,54.21 57.24,53.96 56.2,53.96 v2(55.69,54.47)
M_A_PARITY: length 38.2
  IN1 w0.102: 75.54,48.84 79.78,48.84 80.44,49.5 80.83,49.5 81.35,50.02 83.25,50.02 v2(83.7,50.47)
  IN1 w0.14: 75.54,48.84 74.97,49.41 71.87,49.41 69.45,51.83 65.08,51.83 63.09,53.82 61.91,53.82 60.55,55.18 59.29,55.18 56.83,57.64 55.46,57.64 55.31,57.8 55.31,58.13 v2(55.39,58.22)
  BOTTOM w0.165: U30.AK24 83.7,50.58 v2(83.7,50.47) ; v2(55.39,58.22) 55.39,58.6 57.5,60.71 CN5.143
M_A_RAS#: length 42.5
  TOP w0.102: 77.79,46.73 79.2,46.73 80.96,48.5 81.69,48.5 82.08,48.88 84.38,48.88 84.51,49.01 v2(84.51,49.61)
  TOP w0.165: v2(52.22,55.94) 52.22,55.52 52.39,55.36 53.53,55.36 53.91,54.98 55.05,54.98 55.26,54.77 55.26,54.32 55.61,53.96 56.36,53.96 56.73,53.59 58.22,53.59 59.31,52.5 65.15,52.5 65.47,52.82 65.47,53.66 65.64,53.83 65.95,53.83 73.05,46.73 77.79,46.73
  BOTTOM w0.165: v2(52.22,55.94) 51.7,56.46 CN5.152 ; U30.AL24 84.13,49.99 v2(84.51,49.61)
M_A_RST#: length 38.8
  IN1 w0.089: v1(51.67,69.46) 52.43,70.22 57.07,70.22 61.52,65.77 63.43,65.77 64.6,64.6 65.5,64.6 70.49,59.61 72.11,59.61 72.79,58.93 76.15,58.93 77.94,57.14
  IN1 w0.102: 77.94,57.14 78.57,56.5 79.94,56.5 80.35,56.09 81.7,56.09 v2(82.1,56.5)
  BOTTOM w0.102: v2(82.1,56.5) 82.1,56.29 U30.AD27 ; CN5.108 v1(51.67,69.46)
M_A_WE#: length 42.3
  TOP w0.102: v2(86.02,48.5) 86.02,48.78 85.79,49.01 85.79,49.77 85.53,50.02 83.63,50.02 83.32,49.72 83.32,49.26 83.15,49.08 82.71,49.08 82.51,49.29 82.51,49.76 82.38,49.89 81.21,49.89 81.03,49.71 80.22,49.71
  TOP w0.165: 80.22,49.71 79.26,48.75 78.27,48.75 77.58,49.44 72.01,49.44 65,56.45 64.63,56.45 64.45,56.27 64.45,55.4 64.29,55.23 63.96,55.23 63.79,55.4 63.79,55.83 63.63,55.99 63.3,55.99 63.13,55.83 63.13,55.4 62.97,55.23 62.63,55.23 62.47,55.4 62.47,55.94 62.29,56.12 62.04,56.12 61.4,55.49 56.62,55.49 56.45,55.65 v2(56.45,55.96)
  BOTTOM w0.165: CN5.151 57.04,56.71 56.45,56.12 v2(56.45,55.96) ; v2(86.02,48.5) U30.AM21
M_B1_UZQ0: length 3.5
  TOP w0.102: R157.2 44.26,78.09 v1(44.13,78.22) 44.13,79.3 U5.E9
M_B1_UZQ1: length 4.3
  TOP w0.102: U6.E9 43.7,68.35 v1(43.7,67.04) 43.7,65.99 43.6,65.89 R177.2
M_B1_UZQ2: length 2.6
  TOP w0.102: R218.2 43.14,44.03 42.86,44.31 42.86,45.46 U9.E9
M_B1_UZQ3: length 4.1
  TOP w0.102: R274.2 41.11,31.97 42.74,33.6 42.74,33.97 U12.E9
M_B1_ZQ0: length 1.8
  TOP w0.102: U5.F9 43.11,79.52 R152.1
M_B1_ZQ1: length 3.4
  TOP w0.102: U6.F9 42.35,68.9 42.35,66.92 v1(42.1,66.66) R176.1
M_B1_ZQ2: length 3.2
  TOP w0.102: U9.F9 42.21,45.44 v1(42.21,43.25) 42.01,43.04 R217.1
M_B1_ZQ3: length 4.2
  TOP w0.102: R273.1 v1(40.42,31.66) 42.31,33.55 42.31,33.97 U12.F9
M_B_A0: length 154.9
  TOP w0.102: v1(34.31,84.51) 33.52,84.51 32.07,85.96 32.07,86.85 30.92,88 R118.2
  TOP w0.165: U9.P3 34.28,48.88 v2(34.2,48.88) ; U12.P3 35.14,38.37 v1(35.14,38.34) ; U6.P3 34.28,72.48 v1(33.65,72.48) ; U5.P3 34.93,84.51 v1(34.31,84.51)
  IN1 w0.089: v1(35.14,38.34) 35.14,38.44 34.61,38.98 34.61,40.5 34.99,40.88 34.99,46.34 34.1,47.23 33.17,47.23 33.08,47.32 33.08,47.65 33.17,47.74 33.5,47.74 33.59,47.83 33.59,48.16 33.5,48.25 33.17,48.25 33.08,48.33 33.08,48.67 33.17,48.75 34.07,48.75 v2(34.2,48.88) 33.84,49.24 33.84,51.8 34.22,52.18 34.73,52.18 35.75,53.2 35.75,54.09 35.88,54.22 36.51,54.22 36.64,54.34 36.64,54.6 36.51,54.72 35.88,54.72 35.75,54.85 35.75,55.1 35.88,55.23 36.51,55.23 36.64,55.36 36.64,55.61 36.51,55.74 35.84,55.74 35.75,55.83 35.75,64.25 34.99,65.01 34.99,69.71 33.84,70.85 33.46,70.85 33.21,71.11 33.21,72.04 v1(33.65,72.48) 33.84,72.68 33.84,74.38 33.21,75.02 33.21,75.3 33.84,75.93 33.84,79.74 33.97,79.87 34.61,79.87 34.73,80 34.73,80.25 34.61,80.38 34.1,80.38 33.97,80.5 33.97,84.17 v1(34.31,84.51)
  IN3 w0.133: v1(35.14,38.34) 35.14,38.54 33.98,39.7 33.98,40.4 31.53,42.85 31.53,43.93 30.79,44.67 30.79,47.75 30.41,48.13 30.41,52.72 31.05,53.36 31.05,54.09 32.99,56.03 32.99,57.6 33.89,58.49 37.87,60.14 49.54,60.14 51.09,61.69 57.83,61.69 59.47,60.05 63.42,60.05 63.83,59.64 65.26,59.64 67.19,57.7 67.19,57.54 66.91,57.26 66.91,57.09 67.03,56.97 67.19,56.97 67.48,57.26 67.64,57.26 67.76,57.14 67.76,56.97 67.48,56.69 67.48,56.52 67.59,56.41 67.76,56.41 68.04,56.69 68.21,56.69 68.33,56.57 68.33,56.41 68.04,56.12 68.04,55.96 68.16,55.84 68.33,55.84 68.73,56.25 68.92,56.25 69.04,56.12 69.04,54.99 69.16,54.88 69.32,54.88 69.44,54.99 69.44,56 69.56,56.12 v2(69.91,56.12)
  BOTTOM w0.089: 78.85,49.9 79.06,49.69 79.35,49.69 79.49,49.83 79.72,49.83 80.05,49.49 U30.AM29
  BOTTOM w0.102: 78.85,49.9 78.82,49.92 78.01,49.92 76.99,50.95 74.7,50.95
  BOTTOM w0.165: 74.7,50.95 74.48,51.17 72.43,51.17 68.77,54.82 68.77,55.99 68.9,56.12 v2(69.91,56.12)
M_B_A1: length 151.5
  TOP w0.102: v1(35.49,83.17) 35.11,83.55 33.34,83.55 31.18,85.71 R124.2
  TOP w0.165: U12.P7 35.14,36.34 v1(35.14,36.82) ; v1(35.49,83.17) 35.73,82.94 U5.P7 ; U6.P7 35.68,70.73 35.24,71.16 35.24,71.54 35.7,72 v1(35.72,72) ; U9.P7 35.73,47.69 v2(35.77,47.74)
  IN2 w0.089: v1(35.49,83.17) 35.62,83.04 35.62,77.46 35.24,77.08 35.24,73.14 35.11,73.01 34.73,73.01 34.61,72.88 34.61,72.63 34.73,72.5 36.26,72.5 36.38,72.38 36.38,72.12 36.26,72 v1(35.72,72) 35.24,72 35.11,71.87 35.11,70.98 35.37,70.73 35.37,67.13 35.11,66.88 35.11,66.03 35.24,65.9 35.75,65.9 35.88,65.77 35.88,65.52 35.75,65.39 35.24,65.39 35.11,65.26 35.11,64.76 35.88,63.99 35.88,57.64 37.27,56.25 37.27,53.2 37.02,52.95 37.02,52.56 36.51,52.06 35.11,52.06 34.98,51.92 34.98,48.53 v2(35.77,47.74) 35.77,47.38 35.37,46.98 35.37,40.88 35.88,40.37 35.88,38.83 35.79,38.74 34.86,38.74 34.73,38.61 34.73,36.27 34.82,36.18 35.15,36.18 35.24,36.27 35.24,36.71 v1(35.14,36.82)
  IN3 w0.133: v1(35.14,36.82) 35.11,36.82 33.89,38.04 32.24,38.04 30.22,40.06 29.61,41.51 29.61,43.28 28.95,43.94 28.95,44.49 28.35,45.1 28.35,53.15 30.01,57.17 32.87,60.03 37.51,61.95 38.43,61.95 38.55,62.06 38.55,62.3 38.67,62.42 38.83,62.42 38.95,62.3 38.95,62.06 39.07,61.95 39.23,61.95 39.35,62.06 39.35,62.3 39.47,62.42 39.63,62.42 39.75,62.3 39.75,62.06 39.87,61.95 40.03,61.95 40.15,62.06 40.15,62.35 40.24,62.44 48.93,62.44 49.99,63.5 51.75,63.5 52.23,63.98 57.25,63.98 57.59,63.64 58.62,63.64 60.29,62.95 61.26,61.98 64.33,61.98 65.41,61.54 68.78,58.16 71.47,58.16 73.95,55.69 73.95,53.61 74.1,53.45 v1(74.48,53.45)
  BOTTOM w0.089: U30.AH31 79.6,52.49 79,52.49 78.84,52.65 77.83,52.65 77.71,52.77 77.61,52.77
  BOTTOM w0.102: v1(74.48,53.45) 74.99,52.95 75.88,52.95 76.06,52.77 77.61,52.77
M_B_A2: length 152.5
  TOP w0.102: R117.2 31.05,88.76 32.32,87.49 32.32,86.39 v1(33.57,85.14) 33.75,84.96 34.58,84.96 U5.R3
  TOP w0.165: v1(34.5,73.5) U6.R3 ; v1(34.56,49.93) 34.56,49.96 U9.R3 ; v1(34.2,38.34) 34.31,38.34 U12.R3
  IN2 w0.089: v1(34.2,38.34) 34.09,38.45 34.09,38.84 34.22,38.98 34.61,38.98 34.73,39.1 34.73,39.36 34.61,39.48 33.97,39.48 33.84,39.61 33.84,39.86 33.97,39.99 34.61,39.99 34.73,40.12 34.73,40.37 35.11,40.75 35.11,47.1 35.24,47.23 35.24,47.87 34.73,48.37 34.73,49.76 v1(34.56,49.93) 33.97,50.52 33.97,51.68 35.62,53.33 36.9,53.33 37.03,53.45 37.03,53.69 36.89,53.83 36,53.83 35.88,53.96 35.88,54.22 36,54.34 36.9,54.34 37.03,54.47 37.03,56.11 35.62,57.52 35.62,63.87 34.86,64.63 34.86,67.04 35.11,67.3 35.11,70.6 34.35,71.36 34.35,73.35 v1(34.5,73.5) 34.99,73.99 34.99,77.2 35.37,77.58 35.37,82.54 34.86,83.04 34.86,85.22 34.77,85.31 34.35,85.31 34.08,85.58 33.72,85.58 33.57,85.44 v1(33.57,85.14)
  IN3 w0.133: v1(34.2,38.34) 34.12,38.42 32.37,38.42 30.54,40.25 29.98,41.6 29.98,43.43 29.32,44.09 29.32,44.64 28.71,45.25 28.71,53.08 30.32,56.97 33.07,59.72 37.58,61.58 40.32,61.58 40.81,62.08 49.08,62.08 50.14,63.13 58.45,63.13 59.97,61.62 64.26,61.62 65.21,61.23 68.71,57.72 v2(70.04,57.72)
  BOTTOM w0.089: U30.AJ30 79.94,52.06 79.56,52.06 79.33,52.29 78.91,52.29 78.76,52.45 77.66,52.45 77.61,52.5 77.53,52.5
  BOTTOM w0.102: 77.53,52.5 75.15,52.5 74.68,52.97 73.98,52.97
  BOTTOM w0.165: v2(70.04,57.72) 68.85,57.72 68.64,57.52 68.64,56.76 68.77,56.63 69.12,56.63 69.27,56.77 69.27,57.12 69.41,57.26 69.62,57.26 69.76,57.12 69.76,56.77 69.91,56.63 70.11,56.63 70.26,56.77 70.26,57.12 70.4,57.26 70.61,57.26 70.75,57.12 70.75,56.77 70.9,56.63 71.05,56.63 71.18,56.5 71.18,56.12 70.31,55.24 70.31,53.84 71.09,53.06 72.83,53.06 72.92,52.97 73.98,52.97
M_B_A3: length 155.9
  TOP w0.102: v1(35.49,83.81) 33.46,83.81 31.56,85.71 31.56,86.09 31.18,86.47 R123.2
  TOP w0.165: v1(35.72,71.36) 35.89,71.36 U6.N7 ; v1(35.49,83.81) 36.13,83.17 36.13,82.5 U5.N7 ; v1(35.98,36.82) 36,36.79 36,36.28 U12.N7 ; v1(35.77,48.37) 36.38,47.76 36.38,47.27 U9.N7
  IN2 w0.089: v1(35.98,36.82) 35.54,37.25 35.54,37.88 35.88,38.21 36.55,38.21 36.64,38.3 36.64,38.59 36.51,38.72 36.26,38.72 36.13,38.85 36.13,39.1 36.26,39.23 36.51,39.23 36.64,39.36 36.64,39.99 35.62,41.01 35.62,46.85 36.15,47.38 36.15,48 v1(35.77,48.37) 35.75,48.37 35.22,48.9 35.22,49.62 35.37,49.77 36.13,49.77 36.26,49.9 36.26,50.15 36.13,50.28 35.37,50.28 35.24,50.41 35.24,50.66 35.37,50.79 36.38,50.79 36.51,50.91 36.51,51.17 36.38,51.29 35.62,51.29 35.49,51.42 35.49,51.68 35.62,51.8 36.63,51.8 37.27,52.45 37.27,52.69 37.53,52.95 37.53,56.37 36.13,57.77 36.13,67.68 35.62,68.19 35.62,71.26 v1(35.72,71.36) 36,71.36 36.64,72 36.64,73.14 36.51,73.27 36.38,73.27 35.49,74.15 35.49,76.95 35.9,77.35 35.9,83.65 35.75,83.81 v1(35.49,83.81)
  IN3 w0.133: v1(35.98,36.82) 35.47,36.31 34.86,36.31 34.7,36.47 34.7,36.75 33.79,37.65 32.11,37.65 29.7,40.06 27.99,44.2 27.99,53.23 29.7,57.38 32.7,60.37 38.59,62.8 46.29,62.8 46.41,62.92 46.41,63.17 46.53,63.28 46.69,63.28 46.81,63.17 46.81,62.92 46.93,62.8 47.09,62.8 47.21,62.92 47.21,63.17 47.33,63.28 47.49,63.28 47.61,63.17 47.61,62.92 47.73,62.8 48.78,62.8 49.84,63.86 51.6,63.86 52.08,64.34 57.4,64.34 57.74,64 58.75,64 60.46,63.29 61.41,62.34 64.4,62.34 65.62,61.84 68.93,58.53 71.59,58.53 71.69,58.48 74.33,55.84 74.33,54.24 74.61,53.96 75.5,53.96 75.76,53.7 v1(75.76,53.46)
  BOTTOM w0.089: U30.AH29 80.05,52.49 79.73,52.81 79.45,52.81 79.33,52.69 79.08,52.69 78.92,52.85 78.17,52.85
  BOTTOM w0.102: 78.17,52.85 78.01,52.85 77.84,53.02 76.19,53.02 v1(75.76,53.46)
M_B_A4: length 154.4
  TOP w0.102: v1(35.49,84.44) 35.11,84.06 33.59,84.06 31.81,85.84 31.81,86.47 31.05,87.24 R119.2
  TOP w0.165: U12.N3 35.28,37.71 v1(35.14,37.71) ; U6.N3 35.86,73.27 v1(35.72,73.27) ; U9.N3 35.62,49.42 35.62,49.21 v2(35.6,49.19) ; U5.N3 35.66,84.44 v1(35.49,84.44)
  IN1 w0.089: v1(35.49,84.44) 35.24,84.7 35.24,85.1 35.35,85.2 35.88,85.2 36,85.08 36,77.2 35.37,76.57 35.37,75.29 36,74.66 36,73.54 v1(35.72,73.27) 35.72,72.99 34.99,72.25 34.99,70.85 35.75,70.09 35.75,68.57 36.76,67.55 36.76,58.28 36.89,58.15 38.07,58.15 38.16,58.06 38.16,56.76 38.03,56.63 37.49,56.63 37.4,56.54 37.4,55.7 37.49,55.61 38.07,55.61 38.16,55.52 38.16,53.33 37.4,52.56 37.4,52.18 37.27,52.06 36.64,52.06 35.62,51.04 35.62,49.21 v2(35.6,49.19) 35.11,48.7 35.11,47.36 35.75,46.72 35.75,41.01 36.51,40.25 36.51,37.65 36.17,37.3 35.54,37.3 v1(35.14,37.71)
  IN3 w0.133: v2(73.47,53.83) 73.47,54.72 71.94,56.25 71.05,56.25 70.55,56.76 68.65,56.76 65.41,60 64,60 63.47,60.53 59.5,60.53 57.98,62.05 50.94,62.05 49.39,60.5 37.8,60.5 33.69,58.8 32.63,57.75 32.63,56.18 30.69,54.24 30.69,53.51 30.05,52.87 30.05,47.98 30.43,47.6 30.43,44.52 31.16,43.78 31.16,42.7 33.62,40.25 33.62,39.55 34.71,38.46 34.71,38.14 v1(35.14,37.71)
  BOTTOM w0.089: 78.17,53.08 79.11,53.08 U30.AG32
  BOTTOM w0.102: 78.17,53.08 78.12,53.08 77.91,53.29 76.81,53.29 76.13,53.96 74.81,53.96
  BOTTOM w0.165: 74.81,53.96 74.36,53.96 73.76,53.36 73.09,53.36 73,53.45 71.25,53.45 70.7,54.01 70.7,55.08 70.9,55.28 71.16,55.28 71.31,55.13 71.31,54.09 71.51,53.88 71.74,53.88 71.89,54.03 71.89,54.32 72.03,54.47 72.24,54.47 72.38,54.32 72.38,54.03 72.53,53.88 73.42,53.88 v2(73.47,53.83)
M_B_A5: length 155.3
  TOP w0.102: R130.2 31.3,84.19 31.81,83.68 31.81,82.99 32.78,82.03 v1(33.46,82.03)
  TOP w0.165: U5.P8 35.33,81.71 33.79,81.71 v1(33.46,82.03) ; v1(33.75,46.75) 33.75,46.75 35.3,46.75 U9.P8 ; v1(35.3,35.35) 35.33,35.35 U12.P8 ; v1(33.65,70.35) 35.3,70.35 U6.P8
  IN1 w0.089: v1(35.3,35.35) 34.61,36.05 34.61,38.59 34.35,38.85 34.35,40.63 34.73,41.01 34.73,44.31 34.61,44.44 33.97,44.44 33.84,44.56 33.84,44.82 33.97,44.94 34.61,44.94 34.73,45.07 34.73,45.33 34.61,45.45 34.24,45.45 34.15,45.54 34.15,46.35 v1(33.75,46.75) 33.18,46.75 32.83,47.1 32.83,48.88 33.59,49.64 33.59,52.31 33.72,52.44 34.61,52.44 34.73,52.56 34.73,52.82 34.61,52.95 33.72,52.95 33.59,53.07 33.59,53.33 33.72,53.45 35.24,53.45 35.49,53.71 35.49,64.12 34.73,64.88 34.73,68.69 34.1,69.33 34.1,69.9 v1(33.65,70.35) 33.58,70.35 32.95,70.98 32.95,72.5 33.59,73.14 33.59,74.28 32.95,74.92 32.95,75.81 33.08,75.93 33.46,75.93 33.59,76.06 33.59,76.31 33.46,76.44 33.08,76.44 32.95,76.57 32.95,76.82 33.08,76.95 33.46,76.95 33.59,77.08 33.59,81.9 v1(33.46,82.03)
  IN3 w0.133: v1(35.3,35.35) 34.34,36.31 34.34,36.65 33.74,37.25 32,37.25 29.4,39.85 27.62,44.13 27.62,53.3 29.4,57.58 32.5,60.68 38.52,63.17 44.92,63.17 45.4,63.65 47.85,63.65 48.42,64.22 51.45,64.22 51.91,64.68 57.58,64.68 57.89,64.36 58.82,64.36 60.66,63.6 61.54,62.72 64.49,62.72 65.78,62.19 69.08,58.89 71.68,58.89 71.89,58.8 74.71,55.97 74.71,55.13 74.86,54.98 76.62,54.98 76.74,54.86 76.74,54.62 76.59,54.47 v1(75.75,54.47)
  BOTTOM w0.089: 78.17,53.33 78.2,53.29 79.33,53.29 79.61,53.02 79.98,53.02 U30.AG30
  BOTTOM w0.102: 78.17,53.33 77.92,53.57 76.91,53.57 76.26,54.22 76.01,54.22 v1(75.75,54.47)
M_B_A6: length 151.5
  TOP w0.102: R105.2 32.57,89.01 34.24,87.34 v1(34.54,87.34) 34.98,87.34 35.35,86.97 35.35,86.48 U5.P2
  TOP w0.165: U6.P2 35.34,75.11 v1(34.54,75.11) ; v1(35.31,40.17) U12.P2 ; v1(34.56,51.52) 35.33,51.52 U9.P2
  IN1 w0.089: v1(35.31,40.17) 35.31,39.92 35.49,39.74 36.13,39.74 36.26,39.86 36.26,40.12 35.49,40.88 35.49,46.6 34.86,47.23 34.86,49.14 35.37,49.64 35.37,50.72 v1(34.56,51.52) 35.72,51.52 37.91,53.71 37.91,55.23 37.78,55.36 37.27,55.36 37.15,55.49 37.15,56.76 37.27,56.88 37.78,56.88 37.91,57.01 37.91,57.77 37.78,57.9 36.64,57.9 36.51,58.03 36.51,67.42 35.49,68.44 35.49,69.96 34.73,70.73 34.73,72.38 35.14,72.78 35.14,74.51 v1(34.54,75.11) 34.35,75.3 34.35,75.93 35.75,77.33 35.75,82.28 34.99,83.04 34.99,85.97 35.24,86.22 35.41,86.22 35.49,86.31 35.49,86.64 35.41,86.73 35.15,86.73 v1(34.54,87.34)
  IN3 w0.133: v1(35.31,40.17) 35.31,39.94 35.11,39.74 34.98,39.74 34.7,40.01 34.7,41.03 34.08,41.64 33.76,41.64 32.25,43.15 32.25,44.23 31.51,44.97 31.51,48.05 31.14,48.43 31.14,52.42 33.9,55.19 33.9,55.6 34.25,55.95 34.25,57.05 34.42,57.22 34.42,57.38 34.2,57.6 34.2,57.77 34.31,57.88 34.48,57.88 34.7,57.66 34.86,57.66 35.63,58.43 38.01,59.41 49.84,59.41 50.85,60.42 58.07,60.42 59.17,59.33 63.07,59.33 63.28,59.12 63.28,58.85 63.41,58.72 63.87,58.72 64.07,58.91 64.96,58.91 66.03,57.85 66.03,56.92 68.81,54.14 71.94,54.14 72.1,54.29 72.1,54.77 72.18,54.85 v2(72.58,54.85)
  BOTTOM w0.089: U30.AG31 78.33,53.49 78.32,53.51
  BOTTOM w0.102: 74.46,54.88 75.98,54.88 77.04,53.82 78,53.82 78.32,53.51
  BOTTOM w0.165: 74.46,54.88 74.1,55.23 74.1,57.47 73.96,57.61 73.74,57.61 73.59,57.47 73.59,54.85 73.47,54.72 73.21,54.72 73.09,54.85 73.09,57.95 72.91,58.13 72.32,58.13 72.21,58.01 72.21,55.75 72.58,55.38 v2(72.58,54.85)
M_B_A7: length 151.3
  TOP w0.102: R140.2 30.8,81.14 31.02,80.91 34.52,80.91 v1(34.52,80.9)
  TOP w0.165: U5.R8 v1(34.52,80.9) ; U6.R8 v1(34.55,69.55) ; v1(34.55,35.36) 34.55,35.33 U12.R8 ; U9.R8 v1(34.55,45.95)
  IN2 w0.089: v1(34.55,35.36) 33.97,35.93 33.97,36.18 34.1,36.31 34.35,36.31 34.48,36.44 34.48,36.69 34.35,36.82 33.81,36.82 33.72,36.9 33.72,37.24 33.81,37.32 34.35,37.32 34.48,37.45 34.48,37.71 34.35,37.83 33.97,37.83 33.59,38.21 33.59,40.12 33.72,40.25 34.22,40.25 34.86,40.88 34.86,45.64 v1(34.55,45.95) 34.73,46.13 34.73,47.8 33.72,48.81 33.72,52.44 33.84,52.56 34.48,52.56 34.61,52.69 34.61,52.95 34.48,53.07 33.84,53.07 33.72,53.2 33.72,53.45 33.84,53.58 35.49,53.58 35.62,53.71 35.62,54.47 35.75,54.6 36.38,54.6 36.51,54.72 36.51,54.98 36.38,55.1 35.75,55.1 35.62,55.23 35.62,57.14 35.37,57.39 35.37,63.74 34.61,64.5 34.61,69.49 v1(34.55,69.55) 34.55,69.89 34.1,70.34 34.1,73.95 33.08,74.96 33.08,75.68 35.11,77.71 35.11,81.14 34.99,81.27 34.61,81.27 34.48,81.14 34.48,80.95 v1(34.52,80.9)
  IN3 w0.133: v1(75.75,55.61) 76.54,55.61 76.69,55.76 76.69,55.99 76.44,56.25 74.95,56.25 72.08,59.12 71.77,59.25 69.23,59.25 65.98,62.5 64.51,63.11 61.67,63.11 60.87,63.91 58.89,64.72 58.1,64.72 57.81,65.01 51.73,65.01 51.3,64.58 48.15,64.58 47.58,64.01 41.49,64.01 41.37,63.89 41.37,63.73 41.26,63.61 41.09,63.61 40.97,63.73 40.97,63.89 40.86,64.01 40.69,64.01 40.57,63.89 40.57,63.73 40.46,63.61 40.29,63.61 40.17,63.73 40.17,63.89 40.06,64.01 39.7,64.01 39.22,63.53 38.45,63.53 32.29,60.99 29.09,57.79 27.26,53.37 27.26,44.06 29.09,39.65 31.87,36.87 33.64,36.87 33.95,36.56 33.95,35.7 34.29,35.36 v1(34.55,35.36)
  BOTTOM w0.089: U30.AF30 79.92,54.08 79.56,54.08 79.34,54.29 78.91,54.29 78.75,54.46 78.29,54.46
  BOTTOM w0.102: v1(75.75,55.61) 75.97,55.61 77.22,54.36 78.18,54.36 78.29,54.46
M_B_A8: length 149.4
  TOP w0.102: R106.2 v1(33.34,89.52)
  TOP w0.165: U9.R2 34.56,50.76 v1(34.56,50.73) ; v1(34.53,85.71) 34.92,86.11 U5.R2 ; U6.R2 34.54,74.34 v1(34.54,74.33) ; U12.R2 35.32,39.36 v1(35.32,39.36)
  IN1 w0.089: v1(35.32,39.36) 35.37,39.36 35.55,39.18 35.55,39.03 35.37,38.85 35.09,38.85 34.86,39.08 34.86,40.37 35.24,40.75 35.24,46.47 34.61,47.1 34.61,49.26 35.11,49.77 35.11,50.55 34.94,50.73 v1(34.56,50.73) 34.1,51.19 34.1,51.68 34.35,51.93 34.86,51.93 36.89,53.96 36.89,56.5 36.76,56.63 36.38,56.63 36.26,56.76 36.26,57.01 36.38,57.14 37.53,57.14 37.65,57.26 37.65,57.52 37.53,57.64 36.38,57.64 36.26,57.77 36.26,67.3 35.23,68.32 35.23,69.85 34.48,70.6 34.48,72.5 34.9,72.92 34.9,73.97 v1(34.54,74.33) 34.43,74.33 34.1,74.66 34.1,76.95 34.22,77.08 34.86,77.08 34.99,77.2 34.99,77.46 34.86,77.58 34.22,77.58 34.1,77.71 34.1,77.96 34.22,78.09 34.86,78.09 34.99,78.22 34.99,82.66 34.73,82.92 34.73,85.5 v1(34.53,85.71)
  IN3 w0.089: v1(33.34,89.52) 33.72,89.14 33.72,86.52 v1(34.53,85.71)
  IN3 w0.133: v1(35.32,39.36) 34.85,39.36 34.34,39.86 34.34,40.55 31.89,43 31.89,44.08 31.15,44.82 31.15,47.9 30.77,48.28 30.77,52.57 32.25,54.05 32.25,54.21 32.07,54.39 32.07,54.58 32.16,54.67 32.36,54.67 32.53,54.5 32.69,54.5 33.54,55.34 33.54,55.94 33.36,56.12 33.36,57.44 34.1,58.19 37.94,59.77 49.69,59.77 51.24,61.32 57.68,61.32 59.32,59.69 63.24,59.69 63.66,59.28 65.11,59.28 66.39,58 66.39,57.07 68.96,54.5 69.83,54.5 69.95,54.62 69.95,55.49 70.07,55.61 70.23,55.61 70.35,55.49 70.35,54.62 70.47,54.5 70.63,54.5 70.75,54.62 70.75,55.49 70.87,55.61 71.03,55.61 71.15,55.49 71.15,54.62 71.27,54.5 71.52,54.5 71.66,54.65 71.66,55.71 v2(71.69,55.74)
  BOTTOM w0.089: U30.AG29 80.04,53.49 79.74,53.79 79.43,53.79 79.33,53.69 78.44,53.69
  BOTTOM w0.102: 74.67,55.29 74.86,55.1 76.12,55.1 77.14,54.08 78.05,54.08 78.44,53.69
  BOTTOM w0.165: v2(71.69,55.74) 71.82,55.87 71.82,58.39 71.94,58.52 73.61,58.52 74.48,57.64 74.48,55.49 74.67,55.29
M_B_A9: length 152.3
  TOP w0.102: R126.2 31.56,84.95 33.21,83.3 33.73,83.3 v1(34.52,82.51)
  TOP w0.165: v1(33.65,71.49) 34.17,71.49 U6.R7 ; U9.R7 34.31,47.74 v1(34.2,47.74) ; U12.R7 34.25,36.44 v1(33.46,36.44) ; v1(34.52,82.51) U5.R7
  IN2 w0.089: v1(34.52,82.51) 34.76,82.51 34.86,82.41 34.86,81.65 34.73,81.52 34.19,81.52 34.1,81.43 34.1,80.59 34.19,80.5 34.77,80.5 34.86,80.41 34.86,77.84 32.83,75.81 32.83,74.88 33.46,74.24 33.46,73.15 33.08,72.76 33.08,72.06 v1(33.65,71.49) 33.08,70.92 33.08,69.46 34.35,68.19 34.35,64.38 35.11,63.61 35.11,57.26 35.37,57.01 35.37,54.98 35.24,54.85 34.22,54.85 34.1,54.72 34.1,54.47 34.22,54.34 35.24,54.34 35.37,54.22 35.37,53.96 35.24,53.83 33.59,53.83 33.46,53.71 33.46,48.47 v1(34.2,47.74) 33.84,47.38 33.62,47.38 33.21,46.98 33.21,45.41 33.3,45.33 34.52,45.33 34.61,45.24 34.61,41.01 34.1,40.5 33.46,40.5 33.34,40.37 33.34,36.56 v1(33.46,36.44)
  IN3 w0.133: v1(33.46,36.44) 33.44,36.46 31.76,36.46 28.78,39.44 26.9,43.99 26.9,53.44 28.78,57.99 32.09,61.3 38.37,63.89 39.07,63.89 39.55,64.37 47.43,64.37 48.02,64.96 50.53,64.96 51.39,65.82 57.19,65.82 61.07,64.22 61.8,63.49 64.54,63.49 66.19,62.81 69.38,59.61 71.85,59.61 72.27,59.44 73.09,58.62 73.39,58.62 73.56,58.62 73.7,58.77 73.87,58.77 74.02,58.62 74.02,58.45 73.88,58.31 73.88,58.14 74.09,57.92 74.26,57.92 74.4,58.07 74.57,58.07 74.78,57.85 74.78,57.69 74.64,57.54 74.64,57.38 75.26,56.76 v2(75.88,56.76)
  BOTTOM w0.089: 78.17,54.88 78.89,54.88 79.08,54.69 79.33,54.69 79.48,54.84 79.68,54.84 80.03,54.49 U30.AF29
  BOTTOM w0.102: v2(75.88,56.76) 76.41,56.22 76.41,55.89 77.43,54.88 78.17,54.88
M_B_A10: length 151.5
  TOP w0.102: R109.2 v1(35.62,89.52)
  TOP w0.165: U9.M3 36.85,49.85 v1(36.82,49.85) ; U12.M3 36.08,37.71 v1(35.98,37.71) ; v1(36.93,73.47) 36.93,73.53 U6.M3 ; v1(36.93,84.91) U5.M3
  IN2 w0.089: v1(35.98,37.71) 36.51,37.71 36.89,38.09 36.89,42.91 36.76,43.04 35.97,43.04 35.88,43.13 35.88,46.72 36.39,47.24 36.39,49.42 v1(36.82,49.85) 36.83,49.86 36.83,49.91 37.53,50.61 37.53,52.56 37.78,52.82 37.78,53.33 37.91,53.45 38.42,53.45 38.54,53.58 38.54,53.83 38.42,53.96 37.91,53.96 37.78,54.09 37.78,54.34 37.91,54.47 38.42,54.47 38.54,54.6 38.54,54.85 38.42,54.98 37.91,54.98 37.78,55.1 37.78,55.36 37.91,55.49 38.42,55.49 38.54,55.61 38.54,56.63 38.42,56.76 37.53,56.76 36.38,57.9 36.38,67.8 35.88,68.31 35.88,70.85 37.02,71.99 37.02,73.38 v1(36.93,73.47) 36.83,73.47 36.13,74.17 36.13,75.42 36.64,75.93 36.64,77.06 36.14,77.55 36.14,84.33 36.26,84.44 37.4,84.44 37.53,84.57 37.53,84.81 37.42,84.91 v1(36.93,84.91)
  IN3 w0.089: v1(35.62,89.52) 35.62,86.22 v1(36.93,84.91)
  IN3 w0.133: v1(35.98,37.71) 35.75,37.93 35.75,40.33 35.15,40.93 35.15,41.09 34.23,42.01 33.93,42.01 32.61,43.32 32.61,44.38 31.88,45.12 31.88,48.2 31.5,48.58 31.5,52.27 34.26,55.04 34.26,55.45 34.61,55.8 34.61,56.9 35.83,58.12 38.08,59.05 49.99,59.05 51,60.06 57.92,60.06 58.51,59.48 59.02,58.96 62.79,58.96 62.9,58.86 62.9,58.46 63,58.36 64.98,58.36 65.34,58 v1(65.34,57.9)
  BOTTOM w0.089: 78.8,49.29 79.36,49.29 79.53,49.12 79.87,49.12 U30.AM30
  BOTTOM w0.102: 78.8,49.29 78.58,49.52 77.66,49.52 76.77,50.41 75.75,50.41 75.63,50.28 73.98,50.28
  BOTTOM w0.165: 73.98,50.28 72.2,50.28 70.5,51.98 69.83,51.98 69.69,52.12 69.69,52.67 69.54,52.82 69.34,52.82 69.19,52.67 69.19,52.12 69.05,51.98 68.84,51.98 68.7,52.12 68.7,53.69 68.55,53.83 68.35,53.83 68.2,53.69 68.2,52.12 68.06,51.98 67.85,51.98 67.71,52.12 67.71,53.69 67.56,53.83 67.36,53.83 67.21,53.69 67.21,52.12 67.07,51.98 66.84,51.98 66.71,52.11 66.71,56.5 65.34,57.87 v1(65.34,57.9)
M_B_A11: length 151.4
  TOP w0.102: v1(33.29,86.79) 32.83,87.26 32.83,87.74 31.81,88.76 R104.2
  TOP w0.165: U12.T2 32.84,39.75 v1(32.8,39.74) ; v1(32.66,50.67) 33.12,51.13 U9.T2 ; U5.T2 33.44,86.79 v1(33.29,86.79) ; U6.T2 33.3,73.9 v1(32.68,73.9)
  IN1 w0.089: v1(33.29,86.79) 32.92,86.79 32.83,86.7 32.83,82.41 32.19,81.77 32.19,80.25 32.57,79.87 32.57,77.71 32.19,77.33 32.19,74.38 v1(32.68,73.9) 32.19,73.42 32.19,66.28 34.73,63.74 34.73,58.91 34.61,58.79 33.34,58.79 33.21,58.66 33.21,58.41 33.34,58.28 34.61,58.28 34.73,58.15 34.73,57.9 34.61,57.77 32.95,57.77 32.83,57.64 32.83,50.84 v1(32.66,50.67) 32.07,50.07 32.07,46.21 32.19,46.09 32.7,46.09 32.83,45.96 32.83,45.71 32.7,45.58 32.19,45.58 32.07,45.45 32.07,45.2 32.19,45.07 32.7,45.07 32.83,44.94 32.83,44.69 32.7,44.56 32.32,44.56 32.19,44.44 32.19,44.18 32.32,44.06 32.7,44.06 32.83,43.93 32.83,43.04 32.88,42.99 32.88,42.33 32.83,42.28 32.83,39.76 v1(32.8,39.74)
  IN3 w0.133: v1(32.8,39.74) 32.8,40.04 30.44,42.4 30.44,43.48 29.68,44.24 29.68,44.79 29.07,45.4 29.07,53.01 30.63,56.77 33.28,59.42 37.65,61.22 40.47,61.22 40.96,61.72 49.23,61.72 50.29,62.77 58.3,62.77 59.82,61.26 64.19,61.26 65,60.92 68.79,57.14 70.68,57.14 71.21,56.61 71.56,56.61 71.56,56.63 71.82,56.88 71.82,57.21 v2(71.31,57.72)
  BOTTOM w0.089: 78.17,54.67 78.81,54.67 78.99,54.49 79.6,54.49 U30.AF31
  BOTTOM w0.102: 78.17,54.67 78.16,54.67 78.1,54.61 77.35,54.61 75.84,56.12 75.63,56.12
  BOTTOM w0.165: v2(71.31,57.72) 70.83,58.2 67.96,58.2 67.75,58.41 67.75,58.76 67.91,58.91 73.85,58.91 74.86,57.9 74.86,56.88 75.63,56.12
M_B_A12: length 157.9
  TOP w0.102: R108.2 v1(34.86,89.52)
  TOP w0.165: v1(36.92,47.52) 36.93,47.52 U9.M7 ; U12.M7 36.92,36.16 v1(36.87,36.16) ; v1(36.92,71.29) 36.92,71.14 U6.M7 ; U5.M7 36.62,82.81 36.62,83.53 v1(37.09,84)
  IN2 w0.089: v1(36.87,36.16) 37.15,36.43 37.15,43.17 37.02,43.29 36.26,43.29 36.13,43.42 36.13,43.67 36.26,43.8 36.89,43.8 37.02,43.93 37.02,44.18 36.89,44.31 36.26,44.31 36.13,44.44 36.13,46.59 36.92,47.38 v1(36.92,47.52) 36.92,49.25 37.22,49.56 37.22,49.97 37.78,50.52 37.78,52.44 38.8,53.45 38.8,56.88 38.67,57.01 37.65,57.01 37.53,57.14 37.53,57.39 37.65,57.52 38.67,57.52 38.8,57.64 38.8,57.9 38.67,58.03 36.76,58.03 36.64,58.15 36.64,67.89 36.13,68.4 36.13,70.5 v1(36.92,71.29) 36.92,71.55 37.29,71.93 37.29,73.28 37.33,73.32 37.33,73.64 37.07,73.9 36.74,73.9 36.48,74.16 36.48,75.39 36.89,75.81 36.89,77.15 36.38,77.66 36.38,83.29 v1(37.09,84)
  IN3 w0.089: v1(34.86,89.52) 35.11,89.27 35.11,85.97 v1(37.09,84)
  IN3 w0.133: v1(36.87,36.16) 37.32,35.72 37.32,35.08 36.76,34.53 34.61,34.53 33.04,36.1 31.62,36.1 28.47,39.24 26.54,43.92 26.54,53.51 28.47,58.19 31.88,61.6 39.24,64.64 40.14,65.54 49.69,65.54 51.24,66.18 57.55,66.18 63.14,63.87 64.61,63.87 66.37,63.14 67.82,61.7 74.14,59.08 76.87,56.35 77.1,56.35 77.52,55.92 v2(77.52,55.35)
  BOTTOM w0.089: 78.17,55.08 79.11,55.08 U30.AE32
  BOTTOM w0.102: v2(77.52,55.35) 77.79,55.08 78.17,55.08
M_B_A13: length 151.8
  TOP w0.102: v1(32.93,81.39) 32.42,81.9 R139.2
  TOP w0.165: U5.T8 33.02,81.31 v1(32.93,81.39) ; U9.T8 v1(33.75,45.95) ; v1(33.32,35.03) 33.39,34.95 U12.T8 ; v1(33.65,69.55) 33.75,69.55 U6.T8
  IN1 w0.089: v1(33.32,35.03) 33.32,34.39 33.43,34.28 33.72,34.28 33.84,34.4 33.84,35.67 34.1,35.93 34.1,37.45 33.46,38.09 33.46,40.5 34.22,41.26 34.22,42.79 33.34,43.67 33.34,45.54 v1(33.75,45.95) 33.6,45.95 32.57,46.98 32.57,49.01 33.34,49.77 33.34,53.58 33.46,53.71 34.61,53.71 34.73,53.83 34.73,54.09 34.61,54.22 33.46,54.22 33.34,54.34 33.34,54.6 33.46,54.72 35.11,54.72 35.24,54.85 35.24,63.99 34.48,64.76 34.48,68.57 33.65,69.4 v1(33.65,69.55) 32.7,70.5 32.7,72.59 33.34,73.23 33.34,74.18 32.7,74.81 32.7,77.08 32.83,77.2 33.21,77.2 33.34,77.33 33.34,81.52 33.21,81.65 33.02,81.65 32.93,81.56 v1(32.93,81.39)
  IN3 w0.133: v1(33.32,35.03) 34.21,34.13 37.02,34.13 37.2,33.95 37.2,32.57 37.4,32.37 42.35,32.37 42.48,32.5 42.48,33.13 42.35,33.26 39.94,33.26 39.66,33.54 39.66,34.36 39.3,34.72 38.73,34.72 37.91,35.55 37.91,36.07 37.48,36.5 37.48,36.9 37.74,37.15 38.21,37.15 38.38,37.33 38.38,37.73 37.25,38.87 37.25,43.07 36.08,44.24 36.08,46.77 35.32,47.53 35.32,48.86 35.11,49.06 35.11,49.36 36.02,50.27 36.02,51.83 36.98,52.78 36.98,54.55 38.88,56.46 51,56.46 51.36,56.83 54.98,56.83 55.12,56.69 57.7,56.69 57.97,56.43 58.34,56.43 58.78,55.99 61.17,55.99 61.88,55.28 65.62,55.28 68.21,52.69 72.31,52.69 74.64,50.37 74.64,49.62 75.06,49.2 75.06,48.47 v2(75.21,48.31)
  BOTTOM w0.089: U30.AP30 79.83,47.17 79.48,47.17 79.35,47.29 78.93,47.29 78.86,47.23 78.8,47.23
  BOTTOM w0.102: 78.8,47.23 76.29,47.23 v2(75.21,48.31)
M_B_ACT#: length 154.4
  TOP w0.102: R112.2 v1(37.91,89.52)
  TOP w0.165: v1(38.53,39.36) 38.53,39.36 U12.L3 ; U6.L3 38.53,74.33 v1(38.56,74.33) ; v1(39.07,84.65) 38.78,84.65 U5.L3 ; U9.L3 38.5,50.7 v1(39.33,50.7)
  IN2 w0.089: v1(39.07,84.65) 39.28,84.44 39.69,84.44 39.81,84.31 39.81,84.06 39.69,83.93 39.05,83.93 38.92,83.81 38.92,83.55 39.05,83.43 39.69,83.43 39.81,83.3 39.81,76.82 39.43,76.44 38.12,76.44 38.03,76.35 38.03,74.84 38.55,74.33 v1(38.56,74.33) 38.56,74.32 39.05,73.83 39.05,72.25 38.67,71.87 38.67,68.44 37.65,67.42 37.65,63.19 37.74,63.11 39.72,63.11 39.81,63.02 39.81,62.72 39.69,62.6 38.76,62.6 38.67,62.51 38.67,62.18 38.76,62.09 39.69,62.09 39.81,61.96 39.81,52.82 38.8,51.8 38.8,51.22 39.31,50.7 v1(39.33,50.7) 39.83,50.7 39.95,50.57 39.95,49.02 39.18,48.25 38.42,48.25 38.16,47.99 38.16,46.98 38.92,46.21 38.92,43.42 38.67,43.17 38.42,43.17 38.13,42.88 38.13,39.76 v1(38.53,39.36)
  IN3 w0.089: v1(37.91,89.52) 38.15,89.28 38.15,85.51 39.01,84.65 v1(39.07,84.65)
  IN3 w0.133: v1(38.53,39.36) 37.97,39.92 37.97,44.12 38.56,44.71 38.56,46.32 38.31,46.57 38.31,51.83 39.07,52.59 39.07,52.8 38.92,52.95 38.55,52.95 38.42,53.08 38.42,53.24 40.55,55.38 50.84,55.38 51.05,55.16 52.95,55.16 53.01,55.22 58.01,55.22 58.33,54.9 60.72,54.9 61.43,54.19 65.17,54.19 68.48,50.89 70,50.89 73,47.89 78.32,47.89 78.45,48.02 78.45,49.05 76.38,51.12 76.38,51.4 76.01,51.77 76.01,52.54 76.65,53.18 78.52,53.18 79.67,54.33 79.67,57.12 80.09,57.54 80.09,60.91 79.91,61.09 79.68,61.09 79.52,60.93 79.52,57.72 78.81,57.01 77.89,57.01 77.24,57.66 v2(76.66,57.66)
  BOTTOM w0.102: v2(76.66,57.66) 77.3,57.66 77.96,57 78.41,57 79.07,56.34 79.31,56.34 79.48,56.16 79.83,56.16 U30.AD30
M_B_ALERT#: length 164
  TOP w0.102: R160.1 33.05,78.57 33.72,79.23 v1(34.35,79.23)
  TOP w0.165: v1(35.49,33.64) 35.73,33.87 U12.P9 ; U6.P9 34,67.4 v1(33.84,67.4) ; v1(30.54,62.22) 45.27,62.22 48.42,65.37 48.42,69.3 51.69,72.57 60.77,72.57 68.13,65.21 TP17.1 68.13,64.55 71.74,60.95 72.66,60.95 73.32,60.29 73.62,60.29 v2(73.72,60.18) ; v1(33.84,43.8) 34,43.8 U9.P9 ; v1(34.35,79.23) 34.45,79.23 U5.P9
  IN1 w0.089: v1(35.49,33.64) 35.24,33.9 34.61,33.9 34.48,34.02 34.48,34.28 34.61,34.4 35.37,34.4 35.49,34.53 35.49,34.82 35.41,34.91 34.19,34.91 34.1,35 34.1,35.55 34.35,35.8 34.35,37.58 33.72,38.21 33.72,40.37 34.48,41.13 34.48,43.17 v1(33.84,43.8)
  IN1 w0.133: v1(30.54,62.22) 31.94,60.82 31.94,52.11 31.3,51.47 31.3,42.53 32.07,41.77 32.07,34.4 32.83,33.64 v1(35.49,33.64)
  IN2 w0.089: v1(34.35,79.23) 33.84,79.23 33.72,79.11 33.72,77.08 32.57,75.93 32.57,74.79 33.21,74.15 33.21,73.24 32.83,72.86 32.83,67.8 33.23,67.4 v1(33.84,67.4) 34.11,67.14 34.11,64.24 34.86,63.49 34.86,57.52 34.22,56.88 33.34,56.88 33.21,56.76 33.21,55.74 33.34,55.61 34.99,55.61 35.11,55.49 35.11,55.23 34.99,55.1 33.34,55.1 33.21,54.98 33.21,49.52 32.95,49.27 32.95,44.69 v1(33.84,43.8)
  BOTTOM w0.089: 78.17,55.31 78.19,55.29 79.36,55.29 79.56,55.09 79.9,55.09 U30.AE30
  BOTTOM w0.102: 78.17,55.31 77.45,56.03
  BOTTOM w0.112: 77.45,56.03 77.4,56.03 74.94,58.49 74.92,58.49 73.98,59.43
  BOTTOM w0.165: v2(73.72,60.18) 73.72,59.68 73.98,59.43
M_B_BG#0: length 147.3
  TOP w0.102: U5.M2 36.95,86.48 36.95,88.32 36.38,88.89 R110.2
  TOP w0.165: v1(36.93,50.73) U9.M2 ; U6.M2 36.93,74.33 v1(36.88,74.33) ; U5.M2 v1(36.91,85.69) ; v1(36.31,41.69) 36.91,41.1 36.91,40.17 U12.M2
  IN1 w0.089: v1(36.91,85.69) 36.91,86.33 36.83,86.42 36.6,86.42 36.51,86.33 36.51,75.68 36.64,75.55 37.27,75.55 37.4,75.42 37.4,74.85 v1(36.88,74.33) 36.64,74.08 36.51,73.95 36.51,72.76 36.26,72.5 36.26,68.81 37.27,67.79 37.27,60.78 37.36,60.69 38.58,60.69 38.67,60.6 38.67,60.27 38.58,60.18 37.36,60.18 37.27,60.1 37.27,59.76 37.36,59.68 38.58,59.68 38.67,59.59 38.67,53.07 37.91,52.31 37.91,51.48 37.15,50.73 v1(36.93,50.73) 36.93,50.88 36.77,51.04 36.38,51.04 36.13,50.79 36.13,49.56 36.26,49.43 36.26,45.59 36.35,45.51 37.22,45.51 37.4,45.33 37.4,44.44 37.27,44.31 37.27,41.01 37.15,40.88 36.89,40.88 36.76,41.01 36.76,41.85 36.67,41.94 36.4,41.94 36.31,41.85 v1(36.31,41.69)
  IN3 w0.133: v2(78.04,56.32) 78.36,56.65 79.16,56.65 79.31,56.5 79.31,55.75 79.18,55.61 78.17,55.61 78.04,55.48 78.04,55.24 78.17,55.1 79.18,55.1 79.31,54.97 79.31,54.72 79.18,54.6 78.29,54.6 78.12,54.42 78.12,53.66 78,53.54 77.75,53.54 77.63,53.66 77.63,54.72 77.5,54.85 77.25,54.85 77.11,54.71 77.11,53.72 76.95,53.55 76.49,53.55 75.96,53.02 73.52,53.02 72.76,53.78 68.66,53.78 66.06,56.38 65.77,56.38 65.64,56.51 65.64,57.31 65.54,57.42 65.33,57.42 65.22,57.3 65.22,56.49 65.1,56.37 64.93,56.37 64.82,56.49 64.82,57.32 64.7,57.44 64.53,57.44 64.42,57.32 64.42,56.49 64.3,56.37 64.13,56.37 64.02,56.49 64.02,56.89 63.9,57.01 62.57,57.01 61.7,57.88 58.57,57.88 57.47,58.97 51.45,58.97 50.44,57.96 38.3,57.96 36.45,57.2 35.7,56.45 35.7,55.34 35.35,55 35.35,54.59 33.08,52.32 33.08,52.06 33.25,51.89 33.25,51.7 33.13,51.58 32.82,51.58 32.7,51.46 32.7,51.3 32.82,51.18 33.13,51.18 33.25,51.06 33.25,49.68 32.7,49.14 32.7,48.91 32.96,48.65 32.96,45.57 34.35,44.18 34.35,43.42 34.61,43.17 35.1,43.17 35.75,42.52 35.75,42.03 36.08,41.69 v1(36.31,41.69)
  BOTTOM w0.089: 78.24,55.87 78.42,55.69 79.35,55.69 79.52,55.85 79.68,55.85 80.05,55.49 U30.AD29
  BOTTOM w0.102: 78.24,55.87 78.04,56.07 v2(78.04,56.32)
M_B_BG#1: length 152.8
  TOP w0.165: v1(34.35,78.6) 34.07,78.32 R161.2 ; R248.1 36.72,32.73 v1(36.62,32.83) ; R153.1 38.01,79.18 v1(38.16,79.34) ; R213.1 v1(38.44,43.67) ; R175.1 v1(38.44,67.3)
  IN1 w0.089: v1(38.16,79.34) 37.91,79.08 37.91,78.73 39.56,77.08 39.56,73.27 37.8,71.51 37.8,70.71 38.8,69.71 38.8,67.65 v1(38.44,67.3) 39.56,67.3 39.69,67.17 39.69,66.92 39.56,66.79 39.05,66.79 38.92,66.66 38.92,66.41 39.05,66.28 39.56,66.28 39.69,66.15 39.69,65.9 39.56,65.77 38.67,65.77 38.54,65.65 38.54,65.39 38.67,65.26 39.56,65.26 39.69,65.14 39.69,52.56 38.92,51.8 38.92,49.14 37.8,48.01 37.8,46.83 38.42,46.21 38.42,43.7 v1(38.44,43.67) 38.29,43.52 38.29,40.5 37.78,39.99 37.78,38.71 38.33,38.16 38.33,37.41 37.99,37.07 37.77,37.07 37.53,36.83 37.53,36.01 38.93,34.62 38.93,33.56 38.71,33.35 v1(36.62,32.83)
  IN3 w0.089: v1(34.35,78.6) 37.43,78.6 v1(38.16,79.34)
  IN3 w0.133: v1(36.62,32.83) 35.72,33.02 34.12,33.73 31.98,35.2 28.18,39 26.18,43.84 26.18,53.59 28.16,58.4 31.68,61.91 36.58,63.93 37.35,64.7 38.21,65.28 39.71,65.9 47.04,65.9 50.28,66.54 57.67,66.54 63.25,64.23 64.73,64.23 66.59,63.46 68.03,62.02 74.35,59.4 76.89,56.86 77.21,56.73 v2(77.48,56.73)
  BOTTOM w0.089: U30.AD31 78.73,55.49
  BOTTOM w0.102: 78.73,55.49 78.31,55.49 77.73,56.08 77.48,56.67 v2(77.48,56.73)
M_B_BG#1_R: length 2.6
  TOP w0.165: R159.1 R153.2 37.56,80.28 U5.M9
M_B_BG#2_R: length 2.4
  TOP w0.165: R174.1 R175.2 37.43,69.02 U6.M9
M_B_BG#3_R: length 2.5
  TOP w0.165: U9.M9 37.43,45.42 R213.2 R212.1
M_B_BG#4_R: length 2.5
  TOP w0.165: R249.1 R248.2 37.17,33.01 37.27,33.1 37.27,34.1 U12.M9
