# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ACCEL_INT2_R: length 3.3
  TOP w0.102: U17.9 66.16,21.13 66.35,21.31 D11.2 66.35,22.88 v1(66.33,22.9)
ACCEL_INTA: length 63.5
  TOP w0.102: v2(96.93,44.42) 96.96,44.39 96.96,43.8 97.47,43.29 97.47,41.39 97.98,40.88 97.98,39.86 99.38,38.47 R230.1 ; v1(64.58,23.74) 64.58,23.22 64.42,23.06 C423.2 64.42,22.77 64.27,22.62 63.79,22.62 63.46,22.95 v1(63.26,22.95) 62.67,22.36 D10.1
  IN1 w0.089: v2(96.93,44.42) 96.45,43.95 96.45,40.88 96.2,40.63 96.2,35.55 96.39,35.36 96.39,33.29 95.87,32.77 95.87,27.42 94.26,25.81 94.26,25.32 93.79,24.85 92.67,24.85 91.55,25.97 87.44,25.97 87.18,25.72 82.21,25.72 81.1,24.61 81.08,24.61 80.55,24.08 75.51,24.08 75.42,23.99 73.72,23.99 73.47,24.24 65.09,24.24 v1(64.58,23.74)
  BOTTOM w0.102: U30.AU10 96.56,44.79 v2(96.93,44.42)
ACCEL_INTA_R: length 4.2
  TOP w0.102: U17.11 65.16,20.95 64.97,21.14 D10.2 64.97,23.41 v1(65.26,23.71)
ACIN: length 68
  TOP w0.102: v1(178.24,24.5) 178.24,23.99 177.61,23.35 177.48,23.35 177.1,22.97 177.1,20.42 177.63,19.89 177.63,19.12 177.9,18.86 180.2,18.86 180.5,18.56 U15.72
  TOP w0.254: v1(135.98,36.1) 135.9,36.1 v1(135.42,35.62) 135.07,35.27 PR65.2 134.29,35.09 PR69.1
  IN3 w0.089: v1(135.98,36.1) 135.98,35.16 137.25,33.9 137.25,30.69 137.82,30.12 139.85,30.12 142.43,27.55 142.43,26.78 143.18,26.03 154.17,26.03 154.65,25.54 158.55,25.54 159.33,26.32 159.33,27.42 159.91,28 168.12,28 169.35,26.77 169.35,26.41 169.42,26.33 169.42,24.99 169.86,24.55 171.54,24.55 172.53,25.54 177.2,25.54 v1(178.24,24.5)
  BOTTOM w0.203: v1(135.98,36.1) 135.77,35.89 PR317.1
ACP_WOV_CLK: length 32.3
  TOP w0.102: U8.4 118.94,48.87 119.31,48.5 v1(119.82,48.5)
  IN2 w0.089: v2(99.62,51.46) 100.04,51.04 100.81,51.04 101.95,49.9 107.25,49.9 108.75,51.4 110.45,51.4 111.06,50.79 111.06,47.99 111.49,47.56 112.53,47.56 113.32,48.35 113.32,50 114.9,51.57 117.13,51.57 119.82,48.88 v1(119.82,48.5)
  BOTTOM w0.102: v2(99.62,51.46) 99.57,51.51 99.57,52.62 U30.AG6
ACP_WOV_DAT: length 22.7
  TOP w0.102: v1(113.37,52.06) 113.37,48.96 v1(113.96,48.37) 114.05,48.27 R195.1 R196.2
  IN2 w0.089: v1(113.37,52.06) 113.35,52.06 112.71,52.69 111.82,52.69 110.98,51.85 108.44,51.85 107.43,50.84 103.77,50.84 103.44,51.17 102.04,51.17 100.37,52.84 99.25,52.84 v2(98.86,52.45)
  BOTTOM w0.102: v2(98.86,52.45) 98.51,52.81 U30.AG7
ACZ_BCLK_R: length 11.2
  TOP w0.102: v2(106.36,46.98) 105.45,46.98 103.55,48.88 101.41,48.88 101.14,49.15 99.55,49.15 v2(98.89,48.49)
  BOTTOM w0.102: R588.2 107.79,46.98 v2(106.36,46.98) ; U30.AN6 99.21,48.17 v2(98.89,48.49)
ACZ_RST#_R: length 10.5
  TOP w0.102: v2(99.55,49.53) 99.95,49.94 101.1,49.94 101.53,49.5 104.39,49.5 106.28,47.61 v2(106.36,47.61)
  BOTTOM w0.102: v2(106.36,47.61) v1(107.5,47.61) 107.91,47.61 R587.2 ; v2(99.55,49.53) 99.21,49.19 U30.AM6
ACZ_SDOUT_R: length 10.6
  TOP w0.102: v2(99.49,50.44) 99.52,50.42 101.37,50.42 101.83,49.96 102.39,49.96 v2(102.78,50.35)
  BOTTOM w0.102: U30.AK6 99.21,50.73 v2(99.49,50.44) ; R585.2 105.07,48.07 v2(102.78,50.35)
ACZ_SPKR: length 128.9
  IN2 w0.089: v1(185.05,31.13) 185.05,30.99 184.78,30.72 183.7,30.72 182.6,29.62 172.66,29.62 171.43,30.85 170.42,30.85 170.1,31.17 170.1,31.79 169.32,32.57 169.32,33.04 168.57,33.79 166.53,33.79 165.7,34.63 165.11,34.63 164.43,33.95 159.96,33.95 159.81,34.11 159.19,34.11 158.91,33.83 157.75,33.83 157.02,34.56 155.28,34.56 153.24,36.6 151.11,36.6 150.38,37.32 149.03,37.32 147.38,35.67 146.04,35.67 143.95,33.58 141.35,33.58 139.38,31.61 137.87,31.61 135.52,29.26 133.24,29.26 132.83,28.85 129.89,28.85 129.6,28.56 129.03,28.56 128.37,29.22 120.81,29.22 118.68,31.36 111.57,31.36 110.55,30.34 110.55,30.09 110.04,29.58 106.36,29.58 105.85,30.09 102.8,30.09 101.79,31.1 101.79,31.36 99.63,33.51 98.61,33.51 98.11,33.01 95.57,33.01 94.09,34.48 94.09,35.34 94.19,35.44 94.19,37.04 95.57,38.42 95.57,41.9 95.39,42.07 95.39,45.38 95,45.76 v2(95,46.08)
  BOTTOM w0.102: v2(95,46.08) 95.31,46.39 U30.AR11 ; D32.2 194.67,31.25 194.19,31.74 193.71,31.74 v1(192.87,32.57) 191.02,32.57 189.04,30.59 186.12,30.59 185.58,31.13 v1(185.05,31.13)
ACZ_SYNC_R: length 13
  TOP w0.102: v2(99.55,48.51) 99.93,48.9 100.28,48.9 102.07,47.1 104.64,47.1 105.27,46.47 106.61,46.47 v2(107.25,45.83)
  BOTTOM w0.102: R590.2 v2(107.25,45.83) ; v2(99.55,48.51) 99.58,48.48 99.58,47.75 99.39,47.56 98.13,47.56 U30.AN8
ADBIA0: length 25.1
  TOP w0.102: 123.52,103.3 123.01,103.3 122.63,103.68 120.44,103.68 v1(119.87,103.11)
  TOP w0.127: 123.52,103.3 124.06,102.75 130.62,102.75 131.43,103.57 136.41,103.57 138.85,106.01 138.85,106.65 139.98,107.78 v1(140,107.78)
  BOTTOM w0.102: U25.H21 119.01,103.72 119.62,103.11 v1(119.87,103.11)
  BOTTOM w0.127: VRAM1.J4 140,107.81 v1(140,107.78)
ADBIA1: length 28.8
  TOP w0.102: v1(119.3,102.13) 119.49,102.13 119.93,101.69 120.44,101.69 120.72,101.4 122.42,101.4 123.68,100.14 124.73,100.14
  TOP w0.127: v1(140.78,90.99) 140.78,91.8 139.82,92.77 139.82,94.5 135.07,99.25 127.99,99.25 127.87,99.36 125.5,99.36 124.73,100.14
  BOTTOM w0.102: U25.H19 v1(119.3,102.13)
  BOTTOM w0.127: VRAM2.J4 v1(140.78,90.99)
ADOGND: length 27.3
  TOP w0.381: v1(206.08,22.72) 206.16,22.64 R328.1 205.09,21.83 v1(204.82,22.1) ; R299.1 209.22,25.77 v1(208.47,25.77) ; v1(200.09,31.1) 199.97,31.22 R268.1
  BOTTOM w0.203: U35.25 206.6,28.86 206.82,29.07 206.82,29.83 206.69,29.96 v1(206.69,30.09) ; C670.1 205.87,22.09 205.47,22.49 205.45,22.49 204.94,23.01 U35.38 ; C642.1 207.74,32.09 207.47,32.35 C367.2
  BOTTOM w0.305: v1(215.2,41.77) 214.33,40.9 CN8.5 ; v1(208.09,38.59) C620.1 ; v1(212.15,37.58) 212.33,37.4 CN8.12 ; v1(214.41,42.73) 214.25,42.9 CN8.1 ; CN8.3 v1(214.43,41.9)
  BOTTOM w0.381: C640.2 203.53,32.63 203.9,33.01 v1(203.9,33.26) ; C629.1 R613.2 211.02,36.81 v1(210.88,36.94) ; v1(208.09,38.59) 207.71,38.21 R606.2 ; C367.2 207.07,32.88 v1(206.82,33.13) ; v1(203.26,34.02) 203.13,34.15 C628.1 ; v1(204.82,22.1) 204.79,22.07 C674.2 ; C621.1 210.49,39.16 v1(210.31,39.34) ; v1(209.23,26.91) 209.11,27.03 C651.1 R657.1 C646.2 209.11,30.46 v1(208.72,30.85) ; C670.1 206.11,22.32 206.11,22.7 v1(206.08,22.72) ; C637.1 211.02,32.89 v1(210.75,32.63)
  vias: v1(203.26,33.26) v1(204.02,34.02) v1(205.93,39.1) v1(207.2,39.86) v1(208.47,40.75) v1(208.72,31.48) v1(209.74,41.64) v1(209.76,38.77) v1(210.12,32.63) v1(210.88,42.53)
ADP_ID: length 203.9
  TOP w0.102: v1(137.28,36.09) 137.66,36.47 PQ7.2 ; v1(137.28,36.09) 137.28,36.2 136.12,37.36 v1(134.12,37.36) PR60.2 ; v1(137.28,36.09) 137.28,35.98 136.59,35.29 PR67.1
  IN1 w0.089: v1(137.28,36.09) 137.28,37.65 135.8,39.13 131.83,39.13 130.8,40.16 130.8,40.7 130.32,41.18 130.07,41.18 125.69,45.55 125.69,70.74 124.03,72.4 114.84,72.4 110.88,76.36 110.88,79.44 108.52,81.8 108.52,85.48 107.38,86.63 107.38,88.51 105.85,90.03 v1(105.85,90.28)
  IN2 w0.089: v1(105.85,90.28) 105.85,89.9 105.22,89.27 104.07,89.27 102.39,90.96 99.59,90.96 98.23,92.32 93.66,92.32 93.17,92.81 93.17,92.96 92.21,93.92 88.45,93.92 85.65,91.12 82.56,91.12 81.11,92.57 75.02,92.57 67.69,99.9 67.69,101.01 66.51,102.2 66.51,103.77 64.7,105.57 64.7,107.17 63.54,108.34 63.54,110.53 60.79,113.27 59.62,113.27 56.32,116.57 56.32,119.37 55.36,120.33 51.76,120.33 50.48,121.61 48.53,121.61 43.6,116.67 41.77,116.67 41.39,116.29 40.78,116.29 40.55,116.52 37.98,116.52 36.56,115.1 11.42,115.1 10.77,114.45 PJ11.3
AGPIO30: length 5.9
  BOTTOM w0.089: U30.BC9 97.01,40.48 97.19,40.3 97.19,39.3
  BOTTOM w0.102: TP69.1 98.99,37.07 98.99,37.74 98.17,38.57 97.92,38.57 97.19,39.3
AGPIO31: length 5.9
  BOTTOM w0.089: 96.64,40.98 96.81,40.82 96.81,40.38 96.99,40.19 96.99,39.2
  BOTTOM w0.099: U30.BB10 96.64,41.35 96.64,40.98
  BOTTOM w0.102: TP68.1 98.39,36.97 97.88,37.48 97.88,38.28 96.99,39.17 96.99,39.2
AGPIO68: length 11
  TOP w0.102: v2(93.98,44.42) 94.05,44.42 94.55,43.93 94.55,42.25 95.16,41.64 95.16,39.38 95.85,38.7 95.85,35.77 TP24.1
  BOTTOM w0.102: v2(93.98,44.42) 94.35,44.79 U30.AU12
AGPIO76: length 5.8
  BOTTOM w0.089: 95.68,40.96 95.81,40.84 95.81,40.56
  BOTTOM w0.099: 95.68,40.96 95.68,41.31 U30.BB11 ; 95.81,40.56 95.78,40.54
  BOTTOM w0.102: TP67.1 97.12,36.82 97.17,36.87 97.17,37.98 95.78,39.37 95.78,40.54
AMP_MUTE#: length 38.3
  TOP w0.102: v1(200.49,16.85) 201.3,16.85 202.42,15.73 D15.1 202.32,15.37 v1(202.32,14.89) ; U15.108 175.22,28.96 175.07,28.82 175.07,26.66 175.83,25.89 176.08,25.89 v1(176.59,26.4)
  IN2 w0.089: v1(200.49,16.85) 199.96,17.39 199.83,17.39 199.09,18.13 196.76,18.13 194.03,20.85 192.19,20.85 191.13,21.91 191.13,23.56 189.46,25.23 186.65,25.23 186.12,25.77 186.12,26.15 185.46,26.81 177,26.81 v1(176.59,26.4)
ANALOGIO: length 9.7
  BOTTOM w0.102: U25.AY38 101.5,113.07 101.16,112.73 100.94,112.73 100.82,112.85 99.83,112.85 98.51,114.16 98.51,114.34 98.13,114.72 98.13,117.18 97.21,118.1 R492.2 v1(96.35,118.48)
APU_ALERT#: length 13.6
  BOTTOM w0.089: 85.81,73.13 85.81,73.54
  BOTTOM w0.102: 85.81,73.13 85.61,72.93 85.61,72.59 U30.C22 ; R541.1 89.09,82.16 90.13,81.11 v1(90.13,79.34) 90.03,79.23 90.03,76.47 89.72,76.16 87.4,76.16 85.76,74.52 85.76,73.59 85.81,73.54
APU_BT_OFF: length 112.9
  TOP w0.102: D8.1 187.03,31.03 v1(187.46,30.59) 187.46,30.42 v1(187.01,29.96)
  IN2 w0.089: v2(103.28,47.57) 103.95,48.25 109.66,48.25 110.11,47.8 110.11,47.45 110.91,46.65 113.14,46.65 114.29,47.79 114.29,49.44 115.61,50.76 116.42,50.76 117.66,49.52 117.66,41.26 119.44,39.48 123.89,39.48 124.39,38.98 124.39,36.94 125.03,36.31 127.06,36.31 127.75,35.62 130.82,35.62 132.65,37.45 137.65,37.45 139.4,39.2 149.66,39.2 151.07,37.79 152.89,37.79 155.55,35.13 157.26,35.13 157.99,34.4 158.67,34.4 158.95,34.68 160.04,34.68 160.2,34.52 164.17,34.52 164.87,35.23 166.37,35.23 166.55,35.05 168.68,35.05 170.52,33.21 170.52,32.57 171.1,31.99 173.08,31.99 174.53,30.54 180.48,30.54 180.91,30.97 183.05,30.97 183.88,31.8 185.42,31.8 187.01,30.21 v1(187.01,29.96)
  BOTTOM w0.102: U30.AM2 101.57,49.33 102.35,49.33 103.28,48.39 v2(103.28,47.57)
APU_DBREQ#: length 19.2
  TOP w0.102: v1(118.71,42.43) 118.35,42.43 118.24,42.54 C339.1 117.29,42.54 117.13,42.38 R220.1 R219.2 115.92,42.38 115.7,42.6 115.45,42.6 115.21,42.84 115.21,43.21 114.74,43.67 112.96,43.67 112.46,44.18 109.03,44.18 108.39,44.82 106.87,44.82 106.3,45.39 104.75,45.39 v2(104.52,45.16)
  BOTTOM w0.102: U30.AT2 101.48,45.57 101.95,45.57 102.22,45.3 104.35,45.3 104.49,45.16 v2(104.52,45.16)
APU_DIGITAL_CLK: length 143.4
  TOP w0.102: R189.1 118.52,50.88 118.58,50.94 121.17,50.94 122.06,51.83 122.06,54.65 121.22,55.49 121.22,63.74 119.95,65.01 117.23,65.01 112.96,69.28 112.96,73.01 108.32,77.66 108.32,80.35 107.25,81.42 107.25,82.54 v1(107.5,82.79)
  IN2 w0.089: v1(96.96,91.28) 96.84,91.4 93.94,91.4 92.64,92.7 92.64,92.94 92.04,93.54 88.78,93.54 85.96,90.73 82.41,90.73 80.97,92.16 74.85,92.16 67.31,99.7 67.31,100.86 66.09,102.08 66.09,103.63 64.32,105.4 64.32,106.66 63.12,107.86 63.12,110.4 60.69,112.83 59.42,112.83 55.88,116.37 55.88,118.91 54.89,119.9 51.65,119.9 50.33,121.23 48.69,121.23 43.69,116.23 42.05,116.23 41.7,115.87 v1(39.69,115.87)
  IN3 w0.089: v1(107.5,82.79) 106.56,83.73 106.56,84.14 98.77,91.93 97.62,91.93 v1(96.96,91.28)
  BOTTOM w0.102: v1(39.69,115.87) 39.3,116.26 L8.2 38.85,116.45 37.78,115.38 35.58,115.38 35.5,115.45 CN1.3
APU_DIGITAL_D1: length 149.5
  TOP w0.102: R195.2 114.74,50.04 115.87,51.17 121.07,51.17 121.83,51.92 121.83,54.55 120.99,55.39 120.99,63.65 119.86,64.78 117.14,64.78 112.74,69.18 112.74,72.92 108.09,77.56 108.09,80.26 106.87,81.48 v1(106.87,82.79)
  IN2 w0.089: v1(97.6,91.27) 97.06,91.81 93.84,91.81 92.9,92.75 92.9,92.95 92.12,93.73 88.53,93.73 85.72,90.92 82.48,90.92 81.04,92.37 74.92,92.37 67.5,99.78 67.5,100.94 66.31,102.13 66.31,103.69 64.51,105.49 64.51,106.74 63.31,107.94 63.31,110.48 60.77,113.02 59.5,113.02 56.07,116.45 56.07,118.99 54.96,120.09 51.73,120.09 50.41,121.42 48.61,121.42 43.61,116.42 41.97,116.42 41.64,116.09 40.71,116.09 40.47,116.33 39.37,116.33 v1(38.9,115.86)
  IN3 w0.089: v1(97.6,91.27) 98,91.68 98.74,91.68 106.36,84.06 106.36,83.3 v1(106.87,82.79)
  BOTTOM w0.102: v1(38.9,115.86) 38.9,115.7 39.22,115.38 L9.2 39.22,114.82 39.09,114.69 v1(38.39,114.69) 37.93,115.15 35.14,115.15 34.7,115.59 CN1.2
APU_DISP_ON: length 9.1
  BOTTOM w0.102: U30.D23 85,72.43 85.32,72.75 85.32,73.02 85.18,73.17 85.18,73.55 85.32,73.69 85.32,74.96 87.26,76.9 88.03,76.9 v1(88.14,77) 88.14,78.28 88.3,78.44 R560.1 R557.1
APU_DPST_PWM: length 8.6
  BOTTOM w0.102: R552.1 v1(86.8,78.98) 86.8,78.85 86.55,78.6 R566.1 86.29,78.32 86.17,78.19 86.17,77.58 86.03,77.44 86.03,76.96 84.11,75.04 84.11,73.25 84.51,72.85 U30.C23
APU_LVDS_BLON: length 8.9
  BOTTOM w0.102: R558.1 R561.1 89.55,78.44 89.77,78.21 89.77,77.05 v1(89.6,76.87) 89.29,76.57 87.31,76.57 85.55,74.81 85.55,73.33
  BOTTOM w0.112: U30.A22 85.55,73.33
APU_OC1#: length 18.9
  IN3 w0.089: v2(102.29,59.79) 101.65,59.79 101.28,59.42 101.28,56.37 100.9,55.99 98.87,55.99 97.94,55.07 97.72,55.07 v2(97.13,54.48)
  BOTTOM w0.102: v2(102.29,59.79) 102.81,60.31 103.19,60.31 103.44,60.06 104.05,60.06 104.58,59.52 108.42,59.52 v1(108.67,59.78) 108.67,60.11 108.01,60.77 R571.1 ; U30.AE10 96.61,54.48 v2(97.13,54.48)
APU_PWRGD_D: length 14.8
  TOP w0.102: v2(109.41,42.4) 109.1,42.4 108.9,42.2 108.9,38.42 109.31,38.01 v1(110.69,38.01) 111.05,37.65 114.54,37.65 115.05,37.15 117.61,37.15 117.81,37.34 U11.3
  BOTTOM w0.102: R596.1 v2(109.41,42.4)
APU_PWRGD_SVID_REG: length 83.2
  TOP w0.102: v1(118.83,36.46) 118.6,36.23 113.93,36.23 113.24,35.55 111.26,35.55 111.09,35.72 v1(111.09,36.79) 110.27,37.6 109.13,37.6 108.49,38.24 108.49,42.38 109.05,42.94 109.38,42.94 109.41,42.96 v2(109.41,42.99)
  TOP w0.203: PR42.1 150.95,55.83 v1(150.98,55.86)
  IN1 w0.089: v1(134.71,36.08) 135.24,35.55 144.33,35.55 146,37.21 146,41.3 145.49,41.81 145.49,43.2 144.09,44.6 144.09,46.18 144.88,46.96 145.56,46.96 147.25,48.66 147.25,49.26 147.89,49.9 147.89,50.66 148.78,51.55 148.78,54.21 150.43,55.86 v1(150.98,55.86)
  IN3 w0.089: v1(118.83,36.46) 120.13,35.17 120.69,35.17 123.11,32.74 129.49,32.74 131.34,34.59 133.22,34.59 v1(134.71,36.08)
  BOTTOM w0.102: PR258.2 151.06,55.95 v1(150.98,55.86) ; v2(109.41,42.99) 109.22,43.17 R596.2 108.4,43.55 107.38,43.55 107.28,43.45 R595.2 107.12,43.17 106.74,43.55 C612.2 105.94,43.98 105.01,43.98 104.96,43.93 103.57,43.93 103.16,44.34 101.72,44.34 101.41,44.02 101.41,43.95 100.95,43.49 U30.AW4
APU_PWROK_BUF: length 16.4
  TOP w0.102: v1(116.11,45.81) 116.5,45.81 116.9,46.21 R206.1 117.57,45.85 117.68,45.73 118.43,45.73 118.88,46.19 120.09,46.19 120.38,45.9 120.38,42.1 120.18,41.9 120.18,40.69 120.31,40.56 120.31,39.97 119.76,39.42 118.69,39.42 v1(118.63,39.36) 118.37,39.36 118.24,39.49 U11.4
  BOTTOM w0.102: 113.85,46.09 115.4,46.09 115.68,45.81 v1(116.11,45.81)
APU_RST#: length 20.7
  TOP w0.102: U11.1 116,37.59 115.28,38.31 114.91,38.31 114.66,38.06 112.36,38.06 v1(112.3,38.11) 111.82,38.59 110.55,38.59 110.37,38.42 109.49,38.42 109.31,38.59 v2(109.31,41.79)
  BOTTOM w0.102: v2(109.31,41.79) 109.13,41.97 107.43,41.97 107.28,42.12 R597.2 107,42.4 106.87,42.53 C616.2 105.94,42.1 104.68,42.1 103.49,43.29 101.77,43.29 101.6,43.13 101.15,43.13 U30.AW3
APU_RST_L_BUF: length 12.6
  TOP w0.102: v1(115.84,39.99) 116.41,39.99 116.51,39.9 U11.6 ; v1(116.09,45.17) 115.63,45.63 115.63,46.01 115.86,46.24 116.39,46.24 116.67,46.52 117.11,46.52 R203.1
  IN2 w0.089: v1(116.09,45.17) 116.62,44.64 116.62,42.63 116.39,42.4 116.39,40.55 v1(115.84,39.99)
  BOTTOM w0.102: CN7.12 115.73,44.82 v1(116.09,45.17)
APU_SIC: length 165.7
  TOP w0.102: v1(62.42,99.94) 62.44,99.94 62.98,99.4 65.75,99.4 69.02,96.13 69.02,95.49 72.01,92.5 72.89,92.5 76.25,89.14 81.72,89.14 86.96,83.91 87.66,83.91 87.85,83.72 88.11,83.72 88.53,84.14 88.53,84.36 88.73,84.57 89.47,84.57 v1(90.13,83.9) R131.1 91.02,83.9 91.45,83.48 92.82,83.48 93.04,83.69 Q7.4
  IN3 w0.089: v1(17.33,32.5) 17.71,32.88 17.71,35.29 19.75,37.32 19.75,40.25 20.92,41.42 20.92,45.95 17.59,49.29 17.59,52.44 18.27,53.12 18.27,55.13 21.55,58.41 21.55,59.44 24.73,62.62 24.73,74.38 23.56,75.55 23.56,79.74 24.48,80.66 24.48,90.31 26.78,92.62 26.78,96.97 v1(26.73,97.01)
  BOTTOM w0.089: U30.B22 86,74.41
  BOTTOM w0.102: 86,74.41 86,74.44 87.5,75.93 89.88,75.93 90.26,76.31 90.26,78.74 90.59,79.07 90.59,81.04 89.72,81.9 89.72,83.49 v1(90.13,83.9) ; v1(62.42,99.94) 62.32,99.94 61.33,98.94 56.26,98.94 55.42,99.78 50.89,99.78 50.36,99.25 44.76,99.25 43.97,100.04 43.27,100.04 42.49,99.25 39.17,99.25 37.75,97.83 27.54,97.83 v1(26.73,97.01) ; v1(17.33,32.5) 17.76,32.08 U32.8
APU_SID: length 164.3
  TOP w0.102: Q7.1 91.21,82.5 91.15,82.44 R135.1 90.25,82.44 v1(90.16,82.54) 89.22,82.54 88.71,83.04 88.2,83.04 87.56,83.68 86.8,83.68 81.6,88.89 75.26,88.89 68.75,95.39 68.75,96.01 65.72,99.05 62.7,99.05 v1(62.44,99.3)
  IN3 w0.089: v1(18.48,30.16) 17.97,30.67 17.97,35.17 20.02,37.21 20.02,40.13 21.19,41.31 21.19,45.98 17.84,49.33 17.84,52.31 18.46,52.93 18.46,55.05 21.74,58.33 21.74,59.36 25,62.62 25,74.54 23.81,75.72 23.81,79.62 24.75,80.55 24.75,90.2 27.05,92.51 27.05,96.7 v1(27.37,97.01)
  BOTTOM w0.089: 86.2,73.9 86.2,73.13 86.34,72.99
  BOTTOM w0.102: v1(27.37,97.01) 27.95,97.6 37.85,97.6 39.27,99.02 42.58,99.02 43.37,99.81 43.88,99.81 44.66,99.02 50.46,99.02 50.99,99.55 55.33,99.55 56.17,98.72 61.86,98.72 v1(62.44,99.3) ; U32.7 18.41,30.23 v1(18.48,30.16) ; 86.2,73.9 86.29,73.99 86.29,74.41 87.59,75.7 90.03,75.7 90.49,76.16 90.49,78.65 90.84,79.01 90.84,81.85 v1(90.16,82.54) ; 86.34,72.99 86.34,72.77 86,72.44 U30.D22
APU_SPI_CLK_M: length 8
  BOTTOM w0.102: v1(97.5,27.09) 97.38,27.09 Q31.1 96.65,29.26 96.99,29.61 R652.1 R649.1 96.99,31.89 97.19,32.09 R646.1 97.19,32.57 97.75,33.13 R622.1
APU_SPI_CLK_R1: length 93.6
  TOP w0.102: v1(120.15,25.39) 120.53,25.39 120.99,24.93 R311.1
  IN3 w0.102: v1(110.3,26.28) 110.7,25.87 110.7,24.98 112.08,23.61 118.68,23.61 120.15,25.08 v1(120.15,25.39) 120.84,24.7 121.97,24.7 124.64,27.37 128.42,27.37 128.9,26.88 131.61,26.88 132.16,26.33 134.75,26.33 135.06,26.02 137.09,26.02 139.74,23.38 153.6,23.38 153.76,23.23 155.13,23.23 155.51,22.85 160.55,22.85 161.35,23.65 161.35,24.19 v1(164.4,27.24)
  BOTTOM w0.102: R652.2 97.44,30.49 97.6,30.34 Q31.3 98.12,29.82 99.78,28.15 104.58,28.15 105.14,27.6 106.18,27.6 106.49,27.29 108.62,27.29 109.03,26.88 109.69,26.88 v1(110.3,26.28) ; v1(164.4,27.24) 163.42,28.22 163.42,29.03 164.1,29.7 164.1,31.53 163.76,31.86 163.76,34.07 161.68,36.16 160.15,36.16 159.71,35.72 C627.2 159.71,35.28 160.08,34.92 160.4,34.92 160.62,34.7 R638.1
APU_SPI_CLK_R2: length 7.1
  BOTTOM w0.089: U30.BC10 96.01,40.41
  BOTTOM w0.102: 96.01,40.41 96.01,39.48 97.45,38.04 97.45,37.15 97.67,36.92 97.67,34.76 R622.2
APU_SPI_CS0#_R1: length 100.9
  IN3 w0.102: v1(110.3,25.64) 110.3,24.75 111.85,23.2 121.05,23.2 124.07,26.22 131.69,26.22 132,25.92 134.58,25.92 134.95,25.56 136.98,25.56 140.25,22.29 160.56,22.29 161.5,23.23 162.62,23.23 165.42,26.02 168.26,26.02 v1(168.81,25.47)
  BOTTOM w0.102: R621.2 97.11,35.2 97.27,35.05 97.27,34.44 97.34,34.36 97.34,33.3 96.92,32.88 96.53,32.88 95.9,32.24 95.9,29.63 95.95,29.58 95.95,27.42 96.71,26.66 101.53,26.66 101.79,26.91 v1(104.46,26.91) 105.34,26.02 106.23,26.02 106.74,26.53 108.81,26.53 109.19,26.15 109.79,26.15 v1(110.3,25.64) ; R676.1 167.8,34.18 168.97,33.01 168.97,30.8 168.34,30.16 168.34,25.94 v1(168.81,25.47)
APU_SPI_CS0#_R2: length 5.5
  BOTTOM w0.099: 95.51,39.69 95.51,40.69 U30.BD11
  BOTTOM w0.102: 95.51,39.69 95.51,39.32 96.61,38.22 96.61,36.27 96.66,36.21 R621.1
APU_SPI_HOLD#_R1: length 77.1
  IN2 w0.089: v1(113.02,28.69) 113.09,28.69 113.98,29.58 119.06,29.58 119.82,28.82 127.95,28.82 128.61,28.15 129.73,28.15 130.05,28.47 132.99,28.47 133.39,28.88 135.24,28.88 135.63,28.48 136.27,28.48 137.17,29.38 137.95,29.38 141.7,33.13 144.08,33.13 144.84,33.9 146.39,33.9 148.72,36.22 153.06,36.22 155.1,34.18 156.86,34.18 157.94,33.11 160.69,33.11 160.84,32.96 v1(160.84,32.93)
  BOTTOM w0.102: R637.1 160.05,33.82 160.26,33.62 TP75.1 160.74,33.41 160.84,33.31 v1(160.84,32.93) 160.34,32.42 160.34,31.56 159.5,30.72 U34.7 ; v1(113.02,28.69) 112.33,28.69 111.69,29.32 110.09,29.32 107.86,31.56 106.18,31.56 105.98,31.36 105.98,30.85 105.73,30.59 102.55,30.59 101.63,31.52 101.32,31.52 101.08,31.76 101.08,33.89 101.61,34.43 R636.2
APU_SPI_HOLD#_R2: length 8.9
  BOTTOM w0.089: 98,39.76 98,41.09 U30.BC8
  BOTTOM w0.102: R636.1 101.66,35.29 101.79,35.42 101.79,37.81 101.15,38.44 99.59,38.44 98.54,39.48 98.28,39.48 98,39.76
APU_SPI_SI_R1: length 98.1
  TOP w0.102: v1(118.17,24.5) 118.55,24.12 118.78,24.12 120.74,22.16 R325.1
  IN3 w0.102: v1(163.76,27.24) 161.68,25.16 161.38,25.16 160.41,24.19 160.41,23.43 160.23,23.25 155.68,23.25 155.3,23.63 153.93,23.63 153.77,23.79 152.13,23.79 152.03,23.89 152.03,24.04 151.93,24.14 151.73,24.14 151.62,24.04 151.62,23.89 151.52,23.79 151.32,23.79 151.22,23.89 151.22,24.04 151.12,24.14 150.91,24.14 150.81,24.04 150.81,23.89 150.71,23.79 150.51,23.79 150.4,23.89 150.4,24.04 150.3,24.14 150.1,24.14 150,24.04 150,23.89 149.9,23.79 149.69,23.79 149.59,23.89 149.59,24.04 149.49,24.14 149.29,24.14 149.19,24.04 149.19,23.89 149.08,23.79 139.9,23.79 137.26,26.43 135.22,26.43 134.92,26.73 132.33,26.73 131.77,27.29 131.27,27.29 131.17,27.39 131.17,27.67 131.07,27.77 130.86,27.77 130.76,27.67 130.76,27.39 130.66,27.29 130.46,27.29 130.35,27.39 130.35,27.67 130.25,27.77 130.05,27.77 129.95,27.67 129.95,27.39 129.85,27.29 129.07,27.29 128.59,27.77 124.47,27.77 122.75,26.05 121.95,26.05 121.7,25.8 121.7,25.36 121.45,25.11 121.05,25.11 120.31,25.84 119.52,25.84 v1(118.17,24.5) 117.92,24.75 117.92,25.13 117.71,25.34 116.61,25.34 116.51,25.23 116.51,25.01 116.4,24.9 116.2,24.9 116.1,25.01 116.1,25.23 116,25.34 115.79,25.34 115.69,25.23 115.69,25.01 115.59,24.9 115.39,24.9 115.29,25.01 115.29,25.23 115.18,25.34 114.98,25.34 114.88,25.23 114.88,25.01 114.78,24.9 114.58,24.9 114.47,25.01 114.47,25.23 114.37,25.34 114.17,25.34 114.07,25.23 114.07,25.01 113.97,24.9 113.76,24.9 113.66,25.01 113.66,25.23 113.56,25.34 112.63,25.34 112.46,25.51 112.46,26.28 v1(112.84,26.66)
  BOTTOM w0.102: R626.2 101.15,35.45 101.15,34.56 100.67,34.07 100.67,31.57 102.06,30.19 106.34,30.19 107,30.85 v1(107.71,30.85) 107.99,30.85 109.92,28.92 111.21,28.92 112.28,27.85 112.91,27.85 113.27,27.49 113.27,27.09 v1(112.84,26.66) ; R639.1 162.75,34.4 163.26,33.9 163.26,32.88 162.58,32.2 162.58,28.43 v1(163.76,27.24)
APU_SPI_SI_R2: length 8
  BOTTOM w0.089: 97.81,40.84 97.81,39.65
  BOTTOM w0.099: U30.BB8 97.66,41.34 97.66,40.99 97.81,40.84
  BOTTOM w0.102: 97.81,39.65 98.21,39.25 98.45,39.25 99.47,38.24 101.05,38.24 101.41,37.88 R626.1
APU_SPI_SO_R1: length 94.3
  IN3 w0.102: v1(163.13,27.24) 161.53,25.64 161.35,25.64 160.84,26.15 160.65,26.15 160.5,25.99 160.5,25.85 160.89,25.45 160.89,25.31 160.75,25.17 160.61,25.17 160.21,25.56 160.07,25.56 159.92,25.42 159.92,25.28 160.32,24.88 160.32,24.73 160.17,24.59 160.03,24.59 159.63,24.99 159.49,24.99 159.05,24.55 158.21,24.55 158.11,24.45 158.11,23.76 158.01,23.66 157.8,23.66 157.7,23.76 157.7,24.45 157.6,24.55 157.4,24.55 157.29,24.45 157.29,23.76 157.19,23.66 156.99,23.66 156.89,23.76 156.89,24.45 156.79,24.55 156.58,24.55 156.48,24.45 156.48,23.76 156.38,23.66 156.18,23.66 156.08,23.76 156.08,24.45 155.97,24.55 155.69,24.55 155.28,24.14 154.21,24.14 153.99,24.37 153.99,24.66 153.6,25.04 146.58,25.04 146.47,24.94 146.47,24.34 146.37,24.24 146.17,24.24 146.07,24.34 146.07,24.94 145.97,25.04 145.7,25.04 144.86,24.19 143.5,24.19 143.39,24.29 143.39,24.86 143.29,24.96 143.09,24.96 142.99,24.86 142.99,24.29 142.89,24.19 142.68,24.19 142.58,24.29 142.58,24.86 142.48,24.96 142.28,24.96 142.17,24.86 142.17,24.29 142.07,24.19 141.87,24.19 141.77,24.29 141.77,24.86 141.67,24.96 141.46,24.96 141.36,24.86 141.36,24.29 141.26,24.19 141.06,24.19 140.96,24.29 140.96,24.86 140.85,24.96 140.65,24.96 140.55,24.86 140.55,24.29 140.45,24.19 140.07,24.19 137.43,26.83 135.39,26.83 135.09,27.14 132.5,27.14 131.46,28.18 123.48,28.18 123.26,27.96 123.26,27.82 123.51,27.57 123.51,27.43 123.37,27.28 123.23,27.28 122.98,27.53 122.83,27.53 122.69,27.39 122.69,27.24 122.94,26.99 122.94,26.85 122.79,26.71 122.65,26.71 122.4,26.96 122.26,26.96 121.22,25.92 v1(121.22,25.51) 120.48,26.25 119.19,26.25 118.68,25.74 113.14,25.74 v1(112.86,26.02)
  BOTTOM w0.102: R669.1 163.84,26.53 v1(163.13,27.24) ; v1(112.86,26.02) 112.71,26.02 112.28,26.45 111.33,26.45 110.09,27.7 109.38,27.7 108.11,28.97 100.12,28.97 99.63,29.46 99.63,30.67 99.33,30.97 v1(99.33,32.57) 99.14,32.76 R629.1 R611.2 ; Q33.3 121.35,25.39 v1(121.22,25.51)
APU_SPI_SO_R2: length 9.4
  BOTTOM w0.089: 96.2,40.84 96.2,39.73 96.33,39.61
  BOTTOM w0.099: U30.BA10 96.2,41.7 96.2,41.34 96.31,41.23 96.31,40.95 96.2,40.84
  BOTTOM w0.102: 96.33,39.61 96.33,39.49 97.65,38.17 97.65,37.27 97.98,36.94 97.98,36.24 98.22,36 98.61,36 99.14,35.47 R623.1 99.14,35.06 98.69,34.61 R611.1
APU_SPI_SO_TPM: length 37.9
  TOP w0.102: v1(117.41,24.5) 118.3,23.61 118.71,23.61 120.08,22.24 120.08,21.58 120.2,21.45 120.2,19.54 120.71,19.04 R350.1 R358.1
  IN3 w0.102: v1(112.05,26.02) 112.05,25.28 112.41,24.93 113.04,24.93 113.47,24.5 v1(117.41,24.5)
  BOTTOM w0.102: Q33.1 120.85,23.98 120.46,24.37 119.57,24.37 119.19,23.99 117.92,23.99 v1(117.41,24.5) ; R629.2 98.69,32.55 98.92,32.32 98.92,30.8 99.17,30.54 99.17,29.34 99.95,28.56 104.84,28.56 105.4,28 105.93,28 106.23,28.31 108.19,28.31 109.21,27.29 109.92,27.29 111.19,26.02 v1(112.05,26.02)
APU_SPI_WP_R1: length 74.9
  TOP w0.102: v1(162.49,27.24) 162.49,27.83 R668.1
  IN3 w0.102: v1(162.49,27.24) 161.91,26.66 160.58,26.66 158.88,24.95 154.41,24.95 153.92,25.44 145.53,25.44 144.69,24.6 144.23,24.6 143.44,25.39 139.46,25.39 137.08,27.77 135.11,27.77 134.73,28.15 132.07,28.15 131.63,28.59 123.15,28.59 121.22,26.66 118.98,26.66 118.58,26.25 113.88,26.25 v1(112.84,27.29)
  BOTTOM w0.102: R624.2 99.86,34.64 99.76,34.53 v1(99.76,31.36) 99.76,31.12 100.14,30.74 100.14,29.52 100.29,29.37 108.29,29.37 109.56,28.1 110.25,28.1 111.5,26.86 112.41,26.86 v1(112.84,27.29)
APU_SPI_WP_R2: length 8.1
  BOTTOM w0.089: 97.2,40.84 97.2,40.57 97.39,40.38 97.39,39.42
  BOTTOM w0.099: 97.2,40.84 97.31,40.95 97.31,41.23 97.01,41.53 U30.BA9
  BOTTOM w0.102: 97.39,39.42 98.01,38.8 98.26,38.8 99.25,37.81 99.25,37.58 100.1,36.73 100.1,36.08 99.86,35.84 R624.1
APU_SUSB#: length 27
  TOP w0.102: C403.1 100.76,27.1 99.74,28.12 99.74,29.34 99.5,29.58 v1(99.5,30.59) 98.61,31.48 98.61,32.33 98.16,32.78 98.16,34.22 97.43,34.95 97.43,35.49 96.66,36.26 96.66,39.03 95.97,39.72 95.97,41.87 95.67,42.18 95.67,43.95 95.57,44.06 95.57,44.62 v2(95,45.19) ; C403.1 100.55,26.57 R296.2 ; C403.1 100.76,26.76 101.98,25.54 102.17,25.54 102.65,25.06 102.65,24.03 102.84,23.85 U14.1
  BOTTOM w0.102: v2(95,45.19) 95.4,45.59 U30.AT11
APU_SUSCLK: length 213.3
  TOP w0.102: R435.2 v1(24.8,3.13)
  IN1 w0.089: v1(24.8,3.13) 25.43,3.13 26.35,4.05 31.05,4.05 32.45,5.45 32.45,7.99 33.21,8.75 42.1,8.75 48.91,15.56 63.1,15.56 63.48,15.18 65.24,15.18 65.62,14.8 74.59,14.8 75.6,15.81 81.01,15.81 84.59,19.39 88.1,19.39 89.98,17.51 92.14,17.51 93.03,18.4 100.52,18.4 103.88,21.77 103.88,22.68 104.46,23.25 104.46,26.4 106.23,28.18 106.23,29.45 105.54,30.15 v1(105.54,31.04)
  IN2 w0.089: v1(105.54,31.04) 106.74,29.83 109.92,29.83 110.3,30.21 110.3,30.47 111.57,31.74 118.81,31.74 121.13,29.41 131.74,29.41 132.1,29.04 132.75,29.04 133.16,29.45 135.44,29.45 137.79,31.8 139.3,31.8 141.27,33.77 143.87,33.77 147.61,37.51 150.46,37.51 151.19,36.79 153.33,36.79 155.36,34.75 157.1,34.75 157.83,34.02 158.83,34.02 159.11,34.3 159.88,34.3 160.04,34.14 164.35,34.14 165.04,34.83 166,34.83 166.84,34 169.2,34 170.14,33.05 170.14,32.41 172.74,29.81 182.16,29.81 183.96,31.61 185.23,31.61 186.52,30.31 186.52,29.55 188.66,27.42 190.89,27.42 192.29,26.02 193.36,26.02 v1(193.48,25.89)
  BOTTOM w0.102: R696.2 192.43,20.43 191.73,21.13 191.73,23.07 192.64,23.99 192.64,24.8 192.97,25.13 192.97,25.39 v1(193.48,25.89) ; v1(105.54,31.04) 105.22,31.36 105.22,31.86 104.58,32.5 104.58,33.13 104.44,33.28 U33.4
APU_SVC: length 97.2
  TOP w0.102: v1(149.69,56.8) 149.73,56.84 150.63,56.84 150.76,56.71 PR40.1
  IN1 w0.102: v1(109.28,82.03) 109.28,81.52 112.71,78.09 112.71,75.17 115,72.88 124.14,72.88 129.59,67.44 138.89,67.44 140.4,65.92 140.4,62.85 141.92,61.33 145.86,61.33 146.24,60.95 146.24,57.82 146.63,57.43 146.63,57.07 147.13,56.58 148.58,56.58 148.8,56.8 v1(149.69,56.8)
  BOTTOM w0.102: PC228.2 150.16,56.64 150,56.8 v1(149.69,56.8) ; R563.2 84.31,78.37 84.01,78.68 R549.2 83.6,79.52 83.51,79.61 C580.2 82.87,79.61 82.61,79.87 82.61,80.63 82.99,81.01 82.99,81.65 83.15,81.8 83.15,85.1 84.57,86.52 87.41,86.52 87.87,86.07 96.27,86.07 100.74,81.6 102.25,81.6 102.47,81.82 103.87,81.82 v1(104.05,81.65) 104.86,80.83 106.52,80.83 106.97,81.29 107.74,81.29 108.14,81.7 108.95,81.7 v1(109.28,82.03)
APU_SVD: length 97.8
  TOP w0.102: PR38.1 150.76,57.45 149.91,58.3 v1(149.67,58.3)
  IN1 w0.102: v1(149.67,58.3) 149.21,57.84 147.79,57.84 147,58.63 147,61.33 146.11,62.22 145.07,62.22 144.96,62.32 144.96,62.62 144.86,62.72 144.66,62.72 144.56,62.62 144.56,62.32 144.46,62.22 144.25,62.22 144.15,62.32 144.15,62.62 144.05,62.72 143.85,62.72 143.74,62.62 143.74,62.32 143.64,62.22 142.05,62.22 141.29,62.98 141.29,66.05 139.24,68.1 129.86,68.1 124.19,73.77 115.37,73.77 113.6,75.54 113.6,78.98 113.22,79.36 113.22,79.51 113.58,79.87 113.58,80.02 113.44,80.16 113.29,80.16 112.93,79.8 112.78,79.8 112.64,79.94 112.64,80.08 113,80.45 113,80.59 112.86,80.74 112.72,80.74 112.35,80.37 112.21,80.37 v1(111.69,80.37)
  BOTTOM w0.102: PC226.2 148.87,56.94 148.87,57.61 149.56,58.3 v1(149.67,58.3) ; v1(111.69,80.37) 111.19,79.87 110.3,79.87 109.13,81.04 108.42,81.04 108.01,80.63 107.25,80.63 106.79,80.17 104.59,80.17 104.21,80.55 100.85,80.55 95.99,85.41 87.59,85.41 87.33,85.67 86.66,85.67 86.24,85.26 86.24,83.84 86.09,83.69 86.09,83.22 85.79,82.92 85.79,82.28 85.65,82.15 C577.2 85.51,81.25 85.51,79.64 85.63,79.52 R551.2 85.91,78.85 85.79,78.73 R565.2
APU_SVT: length 98.3
  TOP w0.102: v1(149.63,57.67) 149.53,57.77 PR37.1
  IN1 w0.102: v1(149.63,57.67) 149.63,57.35 149.41,57.14 149.16,57.14 148.86,57.44 147.66,57.44 147.25,57.85 146.75,57.85 146.58,58.02 146.58,61.16 145.95,61.79 141.96,61.79 140.86,62.89 140.86,65.97 139.06,67.77 129.73,67.77 124.15,73.34 115.19,73.34 113.17,75.36 113.17,78.26 112.87,78.55 112.87,78.7 113.05,78.88 113.05,79.02 112.91,79.16 112.76,79.16 112.58,78.98 112.44,78.98 112.3,79.13 112.3,79.27 112.48,79.45 112.48,79.6 112.33,79.74 112.19,79.74 112.01,79.56 111.86,79.56 v1(111.04,80.38)
  BOTTOM w0.102: v1(111.04,80.38) 110.86,80.2 110.43,80.2 109.27,81.37 108.28,81.37 107.88,80.96 107.11,80.96 106.65,80.5 104.73,80.5 104.34,80.89 100.98,80.89 96.13,85.74 87.73,85.74 87.27,86.19 86.35,86.19 v1(86.22,86.07) 86.09,86.19 84.75,86.19 83.48,84.92 83.48,82.05 83.6,81.93 84.14,81.93 84.27,81.79 C576.2 85.08,81.39 85.15,81.32 85.15,79.64 85.02,79.52 R550.2 84.77,79.31 84.67,79.21 84.46,79.21 84.38,79.13 84.38,78.86 84.49,78.75 84.97,78.75 85.05,78.68 R564.2 ; PC227.2 149.2,57.24 v1(149.63,57.67)
APU_TCK: length 28.3
  TOP w0.102: v1(116.01,50.15) 117.44,48.73 R194.1
  IN2 w0.089: v2(103.54,45.71) 103.92,46.09 106.23,46.09 107,45.33 107.31,45.33 108.11,46.12 108.11,47.07 108.9,47.87 109.41,47.87 109.73,47.55 109.73,47.28 111.4,45.6 112.86,45.6 115.12,47.87 115.12,49.26 v1(116.01,50.15)
  BOTTOM w0.089: U30.AR2 102.09,46.49
  BOTTOM w0.099: 102.09,46.49 102.13,46.53
  BOTTOM w0.102: v2(103.54,45.71) 103.54,45.73 103.14,46.14 102.78,46.14 102.39,46.53 102.13,46.53 ; v1(111.97,52.59) 111.97,52.54 113.35,51.17 CN7.2 115.38,51.17 116.01,50.53 v1(116.01,50.15)
APU_TDI: length 15.2
  BOTTOM w0.089: 101.66,46.69 101.95,46.69
  BOTTOM w0.099: 101.95,46.69 102.02,46.76 102.47,46.76 ; 101.46,46.89 101.66,46.69
  BOTTOM w0.102: v1(109.61,40.63) R599.2 110.33,41.03 110.45,41.16 R598.1 110.45,42.43 110,42.88 C615.1 110,42.98 109.54,43.45 109.54,43.93 109.15,44.31 109,44.31 108.75,44.56 108.01,44.56 107.61,44.16 106.34,44.16 106.08,44.41 105.04,44.41 104.96,44.49 104.96,45.45 104.05,46.37 102.86,46.37 102.47,46.76 ; 101.46,46.89 101.11,46.89 U30.AP3
APU_TDO: length 22.9
  IN2 w0.089: v2(103.95,44.56) 104.33,44.18 106.76,44.18 108.85,46.28 110.09,46.28 110.6,45.77 110.6,45.4 111.49,44.51 112.66,44.51 116.04,47.89 v1(116.04,48.17)
  BOTTOM w0.102: v2(103.95,44.56) 103.69,44.82 101.98,44.82 U30.AU1 ; v1(116.04,48.17) 116.04,47.89 115.5,47.36 CN7.8 112.33,47.36 v1(111.9,46.93)
APU_TEST4: length 8.4
  BOTTOM w0.102: TP73.1 102.8,35.09 102.78,35.11 102.78,37.78 100.21,40.35 99.86,40.35 99.66,40.55 99.66,41.34 U30.BB6
APU_TEST5: length 5.7
  BOTTOM w0.102: TP70.1 103.21,37.68 100.2,40.69 U30.BD5
APU_TEST14: length 17
  IN3 w0.102: v1(84.52,84.19) 83.37,83.04 83.37,79.62 84.42,78.57 84.42,76.1 83.75,75.42 83.75,73.03 82.86,72.15 82.86,71.33 82.57,71.05 82.57,70.65 v2(82.97,70.25)
  BOTTOM w0.102: R531.1 v1(84.52,84.19)
  BOTTOM w0.112: v2(82.97,70.25) 83.23,69.99 U30.G25
APU_TEST15: length 17.8
  IN3 w0.089: v2(82.98,68.59) 83.5,69.12 83.5,71.36 84.39,72.25 84.39,72.99 84.9,73.5 84.9,79.11 85.53,79.74 85.53,82.16 85.12,82.56 v1(83.91,82.56)
  BOTTOM w0.102: v1(83.91,82.56) R537.1
  BOTTOM w0.112: v2(82.98,68.59) 83.31,68.26 U30.K25
APU_TEST16: length 13.6
  IN3 w0.102: v2(83,70.94) 83.11,71.05 83.11,72.11 84.01,73.01 84.01,75.17 84.62,75.79 84.62,79.47 85.28,80.12 85.28,81.65 v1(84.88,82.04)
  BOTTOM w0.102: R538.1 v1(84.88,82.04)
  BOTTOM w0.112: v2(83,70.94) 83.25,70.69 U30.F25
APU_TEST17: length 18.2
  IN2 w0.089: v1(84.54,83.55) 84.54,83.27 85.41,82.41 85.41,81.39 85.15,81.14 85.15,80.38 84.64,79.87 82.74,79.87 82.23,79.36
  IN2 w0.102: 82.23,79.36 82.23,77.96 83.14,77.06 83.14,72.75 v2(81.99,71.6)
  BOTTOM w0.102: R532.1 85.28,84.31 84.54,83.58 v1(84.54,83.55)
  BOTTOM w0.112: U30.F26 81.99,71.2 v2(81.99,71.6)
APU_TEST41: length 2.9
  TOP w0.102: TP21.1 99.25,51.93 98.61,51.93 v2(98.11,51.42)
  BOTTOM w0.102: v2(98.11,51.42) 97.34,51.42 U30.AK9
APU_THERMTRIP#: length 24.7
  TOP w0.102: R221.1 105.12,41.49 104.96,41.64 v1(104.84,41.64) 104.58,41.9 v1(104.23,41.9) 103.97,42.15 101.79,42.15 101.03,42.91 101.03,45.83 100.01,46.85 99.76,46.85 99.21,47.4 v2(97.34,47.4) ; v2(109.69,45.88) 110.7,46.9 112.48,46.9 112.66,46.73 R731.1 R732.1
  IN3 w0.089: v1(104.84,41.64) 104.96,41.77 104.96,41.9 105.6,42.53 105.6,43.04 108.82,46.26 109.31,46.26 v2(109.69,45.88)
  BOTTOM w0.102: v2(97.34,47.4) 96.91,47.83 U30.AN9
APU_TMS: length 24.5
  TOP w0.102: R197.1 116.07,49.47 v1(115.99,49.47)
  IN2 w0.089: v1(115.99,49.47) 115.45,48.93 115.45,47.81 112.36,44.72 111.58,44.72 110.81,45.5 110.81,45.83 110.17,46.47 108.77,46.47 107.38,45.07 106.74,45.07 106.49,45.33 105.29,45.33 v2(104.53,44.56)
  BOTTOM w0.102: v1(115.99,49.47) 115.56,49.9 113.85,49.9 ; v2(104.53,44.56) 104.02,45.07 102.16,45.07 101.91,45.31 101.69,45.31 101.55,45.18 101.19,45.18 U30.AU3
APU_TRST#: length 17.2
  TOP w0.102: C332.1 115.62,43.3 114.97,43.96 R215.2 R214.1 113.49,43.96 113.03,44.41 109.92,44.41 v1(109.67,44.66) 109.67,44.94 109.38,45.22 106.97,45.22 106.49,45.71 104.58,45.71 104.07,46.21 103.44,46.21 v2(102.95,45.73)
  BOTTOM w0.089: 101.66,46.29 102.34,46.29
  BOTTOM w0.099: 101.49,46.12 101.66,46.29
  BOTTOM w0.102: v2(102.95,45.73) 102.9,45.73 102.34,46.29 ; 101.49,46.12 101.34,46.12 100.97,46.49 U30.AR4
APU_TS_INT#: length 100.4
  TOP w0.102: v1(64.7,100.57) 64.96,100.82 Q4.3 ; R228.1 100.29,41.77 99.88,41.77 99.63,42.02 99.63,44.37 v2(99.49,44.5)
  IN3 w0.089: v2(99.49,44.5) 99.63,44.64 99.63,45.83 100.01,46.21 100.01,47.74 101.15,48.88 101.15,51.8 101.85,52.5 103.5,52.5 104.71,53.71 104.71,58.91 103.31,60.31 101.55,60.31 100.26,61.6 100.26,63.11 99.38,63.99 97.72,63.99 97.27,64.45 97.27,65.47 96.84,65.9 96.4,65.9 95.57,66.74 95.57,71.11 96.07,71.61 96.71,71.61 99.38,74.28 99.38,76.31 97.09,78.6 97.09,79.11 96.81,79.39 96.81,83.3 96.96,83.45 96.96,83.76 96.05,84.67 95.01,84.67 94.32,85.36 91.22,85.36 90.11,86.46 89.51,86.46 88.35,87.62 84.26,87.62 82.79,89.09 75.56,89.09 74.52,90.13 73.11,90.13 71.66,91.58 71.66,93.1 64.7,100.06 v1(64.7,100.57)
  BOTTOM w0.102: U30.AV6 99.21,44.21 v2(99.49,44.5)
APU_USBC_SCL_Q: length 15.3
  TOP w0.102: TP23.1 105.45,42.94 104.1,42.94 103.57,42.4 101.92,42.4 101.28,43.04 101.28,46.85 100.39,47.74 98.3,47.74 v2(96.54,49.5)
  BOTTOM w0.102: v2(96.54,49.5) 96.91,49.87 U30.AL9
APU_USBC_SDA_Q: length 14.8
  TOP w0.102: v2(98.1,49.5) 98.12,49.5 98.49,49.14 98.49,48.22 98.74,47.97 100.49,47.97 101.53,46.92 101.53,43.8 101.92,43.42 103.57,43.42 104.2,44.06 105.73,44.06 105.85,43.93 106.36,43.93 TP22.1
  BOTTOM w0.102: v2(98.1,49.5) 98.1,49.6 U30.AL8
APU_VDD_RUN_FB_H: length 78.8
  TOP w0.127: v1(88.48,81.93) 88.91,81.49 88.91,79.92 89.34,79.49 89.72,79.49 91.16,80.92 96.43,80.92 97.24,80.11 99.09,80.11 99.5,79.7 99.95,79.7 100.66,79 100.66,78.12 101.05,77.72 102.07,77.72 102.93,76.86 102.93,75.3 104.07,74.15 104.07,72.44 105.19,71.32 110.39,71.32 v1(111.95,72.88)
  IN3 w0.127: v1(88.48,81.93) 87.9,81.93 87.29,81.32 87.29,80.35 85.66,78.73 85.66,71.36 85.46,71.16 85.46,68.54 v2(85.02,68.1)
  BOTTOM w0.102: v2(85.02,68.1) 85.51,67.61 U30.K22
  BOTTOM w0.127: TP56.1 88.58,81.93 v1(88.48,81.93) ; v1(111.95,72.88) 113.52,71.31 113.52,67.12 114.36,66.28 114.36,65.77 114.07,65.48 113.69,65.48 113.6,65.39 113.6,62.6 113.14,62.14 113.14,60.23 112.58,59.68 112.58,53.81 113.27,53.12 114.67,53.12 115.61,52.18 118.81,52.18 119.06,52.44 PR265.2
APU_VDD_RUN_FB_L: length 57.3
  TOP w0.127: v1(103.31,73.9) 102.68,74.54 102.68,76.76 101.96,77.47 100.95,77.47 100.4,78.01 100.4,78.89 99.85,79.45 99.39,79.45 98.98,79.86 97.14,79.86 96.33,80.67 91.26,80.67 89.83,79.23 89.09,79.23 88.33,80 v1(88.33,80)
  IN1 w0.127: v1(103.31,73.9) 104.14,73.9 107.82,70.22 109.66,70.22 110.25,69.63 110.25,66.35 111.19,65.42 111.19,64.76 111.5,64.44 111.5,64.1 v1(112.8,62.81)
  BOTTOM w0.127: v1(112.8,62.81) 112.71,62.72 112.71,60.44 112.08,59.8 112.08,53.71 113.09,52.69 114.49,52.69 115.38,51.8 119.45,51.8 119.65,51.6 119.65,51.34 120.08,50.91 PR271.2 ; v1(88.33,80) 88.33,80.41 R546.2
APU_VDDIO_MEM_FB_H: length 76
  TOP w0.102: v1(62.67,116.65) 63.38,116.65 64.02,117.28 65.22,117.28 65.45,117.51 66.18,117.51 66.45,117.24 PR12.2
  IN3 w0.089: v1(66.99,92.06) 67.63,91.43 68.32,91.43 73.05,86.7 80.35,86.7 82.05,85 85.15,85 86.47,83.68 87.44,83.68 88.96,82.16 88.96,79.74 87.06,77.84 87.06,76.44 86.04,75.42 86.04,72.25 86.42,71.87 86.42,68.53 v2(85.98,68.09)
  BOTTOM w0.102: v2(85.98,68.09) 86.21,68.09 U30.J21 ; v1(62.67,116.65) 62.67,115.71 62.16,115.2 62.16,109.97 63.74,108.39 64.76,108.39 64.96,108.19 64.96,107.17 64.96,107.17 64.96,105.65 65.97,104.63 65.97,102.86 66.36,102.48 66.36,99.17 65.97,98.79 65.97,96.51 66.51,95.97 67.4,95.97 67.93,95.44 67.93,92.75 67.24,92.06 v1(66.99,92.06)
APU_VDDP_ALW_FB_H: length 69.9
  IN2 w0.089: v2(98.83,50.42) 99.25,50.84 100.72,50.84 101.9,49.66 107.34,49.66 108.88,51.19 110.27,51.19 110.81,50.66 110.81,47.87 111.36,47.31 112.77,47.31 113.54,48.07 113.54,49.83 115.07,51.37 116.95,51.37 118.93,49.39 118.93,41.52 119.57,40.88 127.19,40.88 129.35,38.72 130.62,38.72 131.7,37.64 137.57,37.64 139.41,39.48 148.45,39.48 v1(148.73,39.76)
  BOTTOM w0.102: U30.AK7 98.51,50.75 v2(98.83,50.42)
  BOTTOM w0.203: v1(148.73,39.76) 148.5,39.53 PR306.2
APU_VDDP_RUN_FB_H: length 54.2
  IN2 w0.089: v2(94.9,50.52) 96.47,50.52 97.98,49.01 100.26,49.01 100.53,49.27 109.14,49.27 109.36,49.06 109.74,49.06 110.3,48.5 110.3,47.61 111.06,46.85 112.96,46.85 113.98,47.87 113.98,49.52 115.43,50.96 116.6,50.96 118.25,49.31 118.25,41.06 119.57,39.74 127.19,39.74 129.86,37.07 129.86,36.44 129.47,36.05 v1(128.46,36.05)
  BOTTOM w0.102: v2(94.9,50.52) 94.51,50.91 U30.AK12 ; v1(128.46,36.05) 128.68,36.28 PR315.2
APU_VDDP_RUN_FB_L: length 54.1
  IN2 w0.089: v2(94.9,52.37) 94.9,52.36 95.31,51.94 95.31,51.17 95.69,50.79 96.46,50.79 97.26,50 97.98,50 98.06,49.92 100.67,49.92 101.12,49.47 109.23,49.47 109.45,49.25 109.82,49.25 110.49,48.58 110.49,47.69 111.13,47.05 112.79,47.05 113.73,47.99 113.73,49.64 115.25,51.17 116.77,51.17 118.45,49.49 118.45,41.62 119.42,40.65 126.91,40.65 130.36,37.2 130.36,36.44 v1(130.62,36.18)
  BOTTOM w0.102: PR316.2 130.52,36.28 v1(130.62,36.18) ; U30.AJ12 94.89,52.37 v2(94.9,52.37)
APU_VDDSOC_RUN_FB_H: length 90.9
  IN1 w0.127: v1(100.77,79.87) 101.33,80.43 101.33,83.12 100.26,84.19 100.26,86.47 98.23,88.51 v1(98.23,91.27)
  IN3 w0.127: v1(86.22,82.66) 86.88,82 86.88,80.45 85.28,78.85 85.28,71.89 84.54,71.16 84.54,69.32 v2(84.05,68.83)
  BOTTOM w0.102: v2(84.05,68.83) 84.4,68.48 U30.J23
  BOTTOM w0.127: v1(98.23,91.27) 119.34,91.27 121.22,89.39 121.22,88.51 122.52,87.21 123.58,87.21 125.26,88.89 128.1,88.89 131,85.99 131,82.41 130.27,81.68 PR229.2 ; v1(100.77,79.87) 100.77,80.14 96.58,84.34 91.65,84.34 90.95,85.04 87.48,85.04 87.18,85.33 86.8,85.33 86.6,85.13 86.6,83.7 86.45,83.55 86.45,82.94 86.21,82.71 86.21,82.67 v1(86.22,82.66) 86.6,82.28 TP55.1
APU_VDDSOC_RUN_FB_L: length 39.7
  IN2 w0.203: v1(122.39,81.29) 121.78,81.9 115.76,81.9 115.38,81.52 105.6,81.52 105.29,81.82 100.85,81.82 99.27,83.4 97.57,83.4 v1(97.22,83.04)
  BOTTOM w0.203: PR230.2 v1(122.39,81.29) ; v1(97.22,83.04) 96.2,83.04 95.95,83.3 95.95,83.71 95.61,84.05 91.39,84.05 90.79,84.64 88.63,84.64 v1(88.56,84.57) 88.45,84.47 88.45,82.66 88.3,82.51 R543.2
AUX_ZVSS: length 4.8
  BOTTOM w0.102: R520.1 96.93,98.51 97.47,99.05 100.24,99.05 100.51,98.77 U25.BA12
BAT-V: length 36.8
  TOP w0.457: PD2.1 127.87,33.52 v1(128.1,33.75)
  IN1 w0.381: v1(109.66,32.5) 109.66,31.1 109.23,30.67 109.23,29.75 109.74,29.25 109.74,25.39 110.63,24.5 v1(112.71,24.5)
  IN2 w0.381: v1(128.1,33.75) 127.7,34.15 114.87,34.15 113.85,35.17 111.31,35.17 110.3,34.15 110.3,32.75 110.04,32.5 v1(109.66,32.5)
  BOTTOM w0.152: PR343.2 117.41,25.26 116.75,24.6 115.54,24.6 PR344.2
  vias: v1(102.91,24.62)
BATLED0#: length 69.5
  TOP w0.102: v1(166.74,16.5) 166.74,16.7 166.48,16.96 U15.29
  IN2 w0.089: v1(215.07,32.37) 215.07,30.59 215.2,30.47 215.2,27.8 214.82,27.42 214.6,27.42 212.15,24.97 212.15,23 213.17,21.99 213.17,20.78 210.66,18.27 209.33,18.27 207.85,16.79 206.51,16.79 205.77,16.05 197.13,16.05 193.49,19.7 191.73,19.7 190.51,20.92 188.22,20.92 185.96,18.66 182.33,18.66 180.4,16.73 176.14,16.73 175.79,17.08 167.35,17.08 166.76,16.5 v1(166.74,16.5)
  BOTTOM w0.102: CN8.21 214.54,32.9 v1(215.07,32.37)
BATLED1#: length 73
  TOP w0.102: U15.25 166.31,18.56 166.64,18.88 166.85,18.88 167.71,19.75 168.01,19.75 v1(168.44,20.18)
  IN2 w0.089: v1(168.44,20.18) 168.86,20.6 169.92,20.6 171.23,19.29 175.58,19.29 177.84,17.03 180.43,17.03 182.3,18.9 185.94,18.9 188.14,21.11 190.59,21.11 191.81,19.89 193.62,19.89 197.26,16.24 205.69,16.24 206.43,16.98 207.77,16.98 209.25,18.46 210.53,18.46 212.79,20.72 212.79,22.1 211.96,22.93 211.96,25.05 214.03,27.12 214.03,32.6 214.31,32.88 215.2,32.88 v1(215.71,32.37)
  BOTTOM w0.102: CN8.20 214.68,33.4 v1(215.71,32.37)
BI: length 186.7
  TOP w0.102: PR105.1 99.91,22.21 v1(100.16,22.47) ; v1(152.59,37.2) R233.1
  IN1 w0.089: v1(100.16,22.47) 100.16,22.86 102.61,25.31 102.61,25.82 103.06,26.26 103.06,29.22 v1(104.89,31.05)
  IN2 w0.089: v1(104.89,31.05) 104.89,31.28 105.09,31.48 105.73,31.48 105.98,31.23 105.98,30.97 106.36,30.59 106.74,30.59 107.06,30.91 110.36,30.91 111.57,32.12 118.81,32.12 121.32,29.6 131.79,29.6 132.14,29.96 132.65,29.96 132.9,29.7 135.43,29.7 137.71,31.99 139.22,31.99 141.51,34.28 143.32,34.28 143.83,34.78 144.61,34.78 147.53,37.71 150.54,37.71 151.05,37.2 v1(152.59,37.2) ; v1(100.16,22.47) 100.16,23.71 99.12,24.75 98.28,24.75 97.78,24.24 96.58,24.24 94.32,26.5 87.06,26.5 86.29,25.74 73.74,25.74 72.89,24.89 69.6,24.89 69.05,24.34 63.04,24.34 62.98,24.28 50.37,24.28 48.7,25.94 43.74,25.94 40.9,23.11 37.47,23.11 35.2,25.39 26.86,25.39 26.64,25.6 26.64,27.04 26.85,27.24 26.85,29.04 27.14,29.33 27.14,33.5 25.98,34.66 25.98,55.22 22.92,58.28 v1(20.76,58.28)
  BOTTOM w0.102: v1(20.76,58.28) 21.25,58.77 SW2.1 SW2.2
BL#: length 5.1
  TOP w0.102: 54.93,102.84 55.16,103.07 55.34,103.07 55.58,102.84 Q3.3 55.75,102.39 56.04,102.09 R83.1 ; 54.93,102.84 Q3.2 ; 54.93,102.84 54.55,103.21 53.94,103.21 53.35,102.63 v1(53.35,102.53)
BL_ON: length 10.5
  TOP w0.102: v1(52.67,105.37) 52.97,105.68 53.69,105.68 R76.1 ; 55.31,106.52 D4.2 54.85,106.52 54.34,107.03 54.34,108.72 54.71,109.09 Q2.3 ; 55.31,106.52 55.31,106.11 54.32,105.12 R76.1 ; 55.31,106.52 55.71,106.52 55.94,106.29 v1(56.04,106.29) ; R76.1 54.25,104.64 54.28,104.61 Q3.6
  BOTTOM w0.102: v1(56.04,106.29) 56.07,106.31 56.07,106.41 56.22,106.57 CN2.26
BOARD_ID2: length 18
  TOP w0.102: R281.1 100.52,29.4 100.09,29.83 100.09,31.28 100.51,31.7 R257.2 v1(99.15,32.12) 98.39,32.88 98.39,34.37 97.66,35.1 97.66,35.58 96.89,36.36 96.89,39.13 96.2,39.81 96.2,41.77 96.51,42.07 96.51,42.49 96.08,42.91 v2(96.08,42.96)
  BOTTOM w0.102: U30.AW11 95.81,42.99 96.05,42.99 v2(96.08,42.96)
BOARD_ID3: length 17.5
  BOTTOM w0.102: R673.1 88.06,25.33 88.07,25.35 R663.2 87.56,27.03 87.56,28.18 87.69,28.31 v1(87.69,33.02) 88.83,34.17 88.83,37.07 89.34,37.58 89.34,39.1 89.79,39.54 89.79,40.23 89.84,40.28 89.84,40.93 U30.BC17
BOARD_ID4: length 91.4
  TOP w0.102: v1(56.15,101.46) 55.71,101.02 55.38,101.02 54.94,100.58 R92.1 R91.2 54.34,100.15 54.34,99.22 v1(54.01,98.89)
  IN3 w0.089: v2(93.98,46.84) 93.28,47.54 93.28,49.48 92.16,50.6 92.16,58.05 91.76,58.46 91.76,59.68 91.63,59.8 91.63,62.09 91.76,62.22 91.76,64.57 91.84,64.65 91.84,66.36 91.34,66.87 91.34,67.77 91.62,68.05 91.62,73.89 91.88,74.15 91.88,75.69 90.37,77.2 90.37,81.28 87.6,84.06 86.63,84.06 85.23,85.46 82.15,85.46 80.53,87.08 73.21,87.08 67.03,93.25 65.76,93.25 63.92,95.1 63.92,96.62 61.83,98.72 60.34,98.72 58.61,100.44 58.61,101.21 58.35,101.46 58.08,101.46 57.57,100.95 56.65,100.95 v1(56.15,101.46)
  BOTTOM w0.102: v2(93.98,46.84) 93.54,46.39 U30.AR13 ; R504.1 56.04,104.42 C556.2 56.57,104.26 56.7,104.13 56.7,102.73 56.4,102.42 55.76,102.42 55.69,102.35 55.69,101.92 v1(56.15,101.46)
BOARD_ID5: length 16.4
  TOP w0.102: R232.1 105.85,38.98 105.68,39.15 104.88,39.15 R231.2 104.33,38.98 104.07,39.23 v1(104.07,39.41)
  IN2 w0.089: v1(104.07,39.41) 104.07,39.61 104.33,39.86 104.33,41.01 102.93,42.4 102.55,42.4 102.02,42.94 99.86,42.94 99.25,43.55 98.36,43.55 97.48,44.42 97.48,44.71 v2(96.88,45.31)
  BOTTOM w0.102: U30.AP10 96.07,46.96 96.07,45.81 96.57,45.31 v2(96.88,45.31)
BOARD_ID6: length 89.5
  TOP w0.102: v1(58.18,100.95) 57.81,100.58 R94.2 R93.1
  IN3 w0.089: v2(92.08,43.64) 93.08,44.64 93.08,49.41 91.96,50.53 91.96,57.85 90.99,58.81 90.99,60.03 90.84,60.18 90.84,63.61 90.87,63.64 90.87,64.58 91.65,65.37 91.65,66.28 91.15,66.79 91.15,67.96 91.43,68.24 91.43,74.66 91.65,74.89 91.65,75.65 90.18,77.13 90.18,81.21 87.52,83.87 86.55,83.87 85.19,85.23 82.1,85.23 80.44,86.89 73.13,86.89 66.95,93.06 65.68,93.06 63.73,95.02 63.73,96.55 61.76,98.51 60.16,98.51 58.18,100.49 v1(58.18,100.95)
  BOTTOM w0.102: v2(92.08,43.64) 91.73,43.29 U30.AW15 ; R506.1 58.07,104.92 58.35,104.63 C558.2 58.79,103.83 58.79,101.56 v1(58.18,100.95)
BP_0: length 16.3
  TOP w0.102: v1(112.55,113.11) 112.76,113.32 112.76,115.92 115.17,118.32 115.96,118.32 116.5,118.86 117.65,118.86 119.31,120.52 119.31,120.75 119.57,121.01 TP2.1 119.72,123.87 R7.2
  BOTTOM w0.102: U25.AA38 112.37,112.92 v1(112.55,113.11)
BP_1: length 13.4
  TOP w0.102: v2(112.56,112.33) 112.56,112.48 112.99,112.91 112.99,113.88 119.75,120.64 TP7.1 119.85,120.81 R30.2
  BOTTOM w0.102: U25.AA37 112.35,112.12 v2(112.56,112.33)
BRIGHT: length 2.1
  TOP w0.102: R68.2 57.01,107.63 57.47,107.17 R69.2 R70.1
BT_EN: length 3.2
  TOP w0.102: R303.2 184.59,25.13 184.69,25.23 185.92,25.23 R306.2 186.27,25.03 v1(186.87,25.63)
BT_EN_R: length 10.3
  TOP w0.102: v1(188.02,23.99) 187.56,23.99 187.29,24.26 R309.1 186.96,24.75 186.83,24.88 R306.1
  BOTTOM w0.102: v1(188.02,23.99) 188.45,23.56 189.47,23.56 189.8,23.23 189.8,18.02 189.94,17.88 CN11.54
C1: length 4.3
  BOTTOM w0.102: R710.1 R709.2 20.21,16.93 19.42,16.93 v1(18.95,16.46) 18.22,15.73 U39.12
C2: length 3.4
  BOTTOM w0.102: R714.1 R713.2 ; R714.1 14.04,15.73 U39.6 ; R714.1 14.03,16.57 v1(14.11,16.65)
C_IN_CLK: length 2.8
  TOP w0.102: C203.2 25.73,76.17 25.57,76.17 v1(25.36,76.38)
  BOTTOM w0.102: v1(25.36,76.38) 25.15,76.17 24.21,76.17 24.12,76.27 U28.47
C_IN_CLK#: length 2.8
  TOP w0.102: v1(25.36,75.75) 25.57,75.96 25.72,75.96 C205.2
  BOTTOM w0.102: U28.48 24.12,75.87 24.21,75.96 25.15,75.96 v1(25.36,75.75)
C_IN_D0: length 2.9
  TOP w0.102: v1(24.95,77.58) 24.67,77.3 23.93,77.3 C196.2
  BOTTOM w0.102: v1(24.95,77.58) 24.74,77.37 24.21,77.37 24.12,77.47 U28.44
C_IN_D0#: length 3
  TOP w0.102: v1(24.95,76.95) 24.81,77.09 24.18,77.09 C202.2
  BOTTOM w0.102: U28.45 24.12,77.07 24.21,77.16 24.74,77.16 v1(24.95,76.95)
C_IN_D1: length 2.8
  TOP w0.102: v1(25.36,78.78) 25.57,78.57 25.72,78.57 C187.2
  BOTTOM w0.102: v1(25.36,78.78) 25.15,78.57 24.21,78.57 24.12,78.67 U28.41
C_IN_D1#: length 2.8
  TOP w0.102: C193.2 25.73,78.36 25.57,78.36 v1(25.36,78.15)
  BOTTOM w0.102: U28.42 24.12,78.27 24.21,78.36 25.15,78.36 v1(25.36,78.15)
C_IN_D2: length 3.8
  TOP w0.102: v1(24.9,80.11) 25.13,79.88 25.27,79.88 25.68,80.29 25.68,80.85 25.36,81.17 C181.2
  BOTTOM w0.102: v1(24.9,80.11) 24.57,79.78 24.14,79.78 24.05,79.87 U28.38
C_IN_D2#: length 3.8
  TOP w0.102: C182.2 25.89,81.09 25.89,80.2 25.36,79.67 25.09,79.67 v1(24.9,79.48)
  BOTTOM w0.102: v1(24.9,79.48) 24.81,79.56 24.14,79.56 24.04,79.47 U28.39
C_TX0_HDMI+: length 6.5
  TOP w0.102: R154.1 14.45,78.73 14.45,78.89 14.35,78.99 14.12,78.99 13.97,79.15 13.87,79.15 13.74,79.02 13.74,78.56 14.12,78.18 15.09,78.18 15.2,78.29 15.78,78.29 16.13,77.95 16.13,77.71 16.23,77.61 v1(16.34,77.61)
  BOTTOM w0.102: v1(16.34,77.61) 16.34,77.48 16.44,77.38 16.52,77.38 16.7,77.2 16.85,77.2 17.12,77.47 U28.17
C_TX0_HDMI-: length 6.6
  TOP w0.102: R148.1 13.78,79.36 13.52,79.11 13.52,78.47 14.03,77.96 15.17,77.96 15.29,78.08 15.7,78.08 15.91,77.86 15.91,77.4 v1(16.34,76.96)
  BOTTOM w0.102: v1(16.34,76.96) 16.37,76.99 16.93,76.99 17,77.07 U28.16
C_TX1_HDMI+: length 3.2
  TOP w0.102: R149.1 16.62,79.11 v1(16.19,79.54)
  BOTTOM w0.102: v1(16.19,79.54) 16.64,79.09 16.64,79.07 17.05,78.67 U28.20
C_TX1_HDMI-: length 3.2
  TOP w0.102: R155.1 17.49,78.49 17.09,78.89 16.53,78.89 16.52,78.88 v1(16.19,78.88)
  BOTTOM w0.102: v1(16.19,78.88) 16.55,78.88 17.16,78.27 U28.19
