# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Nets (continued)
M_B_DQ10: U5.C8 U30.K31
M_B_DQ11: U5.B8 U30.L30
M_B_DQ12: U5.A3 U30.G30
M_B_DQ13: U5.C2 U30.H29
M_B_DQ14: U5.C7 U30.K30
M_B_DQ15: U5.D7 U30.K29
M_B_DQ16: U6.J7 U30.N32
M_B_DQ17: U6.H7 U30.N29
M_B_DQ18: U6.H8 U30.P30
M_B_DQ19: U6.G2 U30.L32
M_B_DQ20: U6.H3 U30.L31
M_B_DQ21: U6.J3 U30.M30
M_B_DQ22: U6.H2 U30.L29
M_B_DQ23: U6.F7 U30.N31
M_B_DQ24: U6.D3 U30.R30
M_B_DQ25: U6.C3 U30.R32
M_B_DQ26: U6.B8 U30.V30
M_B_DQ27: U6.C7 U30.V32
M_B_DQ28: U6.A3 U30.P29
M_B_DQ29: U6.C2 U30.P31
M_B_DQ30: U6.C8 U30.U31
M_B_DQ31: U6.D7 U30.U29
M_B_DQ32: U9.C2 U30.AT29
M_B_DQ33: U9.D3 U30.AU32
M_B_DQ34: U9.C8 U30.AW31
M_B_DQ35: U9.C7 U30.AW30
M_B_DQ36: U9.C3 U30.AR30
M_B_DQ37: U9.A3 U30.AT31
M_B_DQ38: U9.B8 U30.AV30
M_B_DQ39: U9.D7 U30.AW29
M_B_DQ40: U9.H3 U30.AY29
M_B_DQ41: U9.J3 U30.AY32
M_B_DQ42: U9.F7 U30.BC27
M_B_DQ43: U9.H7 U30.BB26
M_B_DQ44: U9.J7 U30.BC25
M_B_DQ45: U9.H8 U30.BA25
M_B_DQ46: U9.G2 U30.BB30
M_B_DQ47: U9.H2 U30.BA28
M_B_DQ48: U12.F7 U30.BA24
M_B_DQ49: U12.H8 U30.BC24
M_B_DQ50: U12.J3 U30.BC22
M_B_DQ51: U12.G2 U30.BA22
M_B_DQ52: U12.J7 U30.BB25
M_B_DQ53: U12.H7 U30.BD25
M_B_DQ54: U12.H3 U30.BB22
M_B_DQ55: U12.H2 U30.BD22
M_B_DQ56: U12.C3 U30.BA21
M_B_DQ57: U12.C2 U30.BC21
M_B_DQ58: U12.B8 U30.BC18
M_B_DQ59: U12.C8 U30.BB18
M_B_DQ60: U12.A3 U30.BB20
M_B_DQ61: U12.D3 U30.BB21
M_B_DQ62: U12.D7 U30.BB19
M_B_DQ63: U12.C7 U30.BA18
M_B_DQSN0: U5.F3 U30.D28
M_B_DQSN1: U5.A7 U30.J29
M_B_DQSN2: U6.F3 U30.M31
M_B_DQSN3: U6.A7 U30.T31
M_B_DQSN4: U9.A7 U30.AU31
M_B_DQSN5: U9.F3 U30.BB27
M_B_DQSN6: U12.F3 U30.BA23
M_B_DQSN7: U12.A7 U30.BA20
M_B_DQSP0: U5.G3 U30.E29
M_B_DQSP1: U5.B7 U30.J31
M_B_DQSP2: U6.G3 U30.N30
M_B_DQSP3: U6.B7 U30.T30
M_B_DQSP4: U9.B7 U30.AU29
M_B_DQSP5: U9.G3 U30.BA27
M_B_DQSP6: U12.G3 U30.BC23
M_B_DQSP7: U12.B7 U30.BC20
M_B_EVENT#: R578.1 U30.AL30
M_B_ODT0: R113.2 U5.K3 U6.K3 U9.K3 U12.K3 U30.AP32
M_B_PARITY: R115.2 U5.T3 U6.T3 U9.T3 U12.T3 U30.AM31
M_B_RAS#: R132.2 U5.L8 U6.L8 U9.L8 U12.L8 U30.AN29
M_B_RST#: U5.P1 U6.P1 U9.P1 U12.P1 U30.AC32
M_B_WE#: R111.2 U5.L2 U6.L2 U9.L2 U12.L2 U30.AP31
M_TEST: TP57.1 U30.H26
MAA0_0: U25.G25 VRAM1.H4
MAA0_1: U25.H25 VRAM1.H5
MAA0_2: U25.E27 VRAM1.H11
MAA0_3: U25.D27 VRAM1.H10
MAA0_4: U25.D29 VRAM1.K11
MAA0_5: U25.H27 VRAM1.K10
MAA0_6: U25.H23 VRAM1.K5
MAA0_7: U25.E23 VRAM1.K4
MAA0_8: U25.D25 VRAM1.J5
MAA1_0: U25.E15 VRAM2.K4
MAA1_1: U25.H15 VRAM2.K5
MAA1_2: U25.G13 VRAM2.K11
MAA1_3: U25.D13 VRAM2.K10
MAA1_4: U25.H11 VRAM2.H11
MAA1_5: U25.H13 VRAM2.H10
MAA1_6: U25.H17 VRAM2.H5
MAA1_7: U25.G17 VRAM2.H4
MAA1_8: U25.D15 VRAM2.J5
MAIND: PC184.1 PQ8.2 PQ24.3 PQ26.2 PQ34.4 PR211.2
MAINON: PQ21.2 PR83.2 PR87.2 PR102.1 PR112.2 PR122.1 PR205.1 PR335.2 R384.1 U15.30
MAINON_ON_G: PQ6.2 PQ19.2 PQ20.2 PQ21.3 PQ23.2 PQ24.2 PQ25.2 PR210.1 PR212.2
MBCLK: PC126.1 PD4.1 PR107.2 PR327.1 R250.1 U15.110
MBDATA: PC127.1 PD3.1 PR106.2 PR325.1 R270.1 U15.111
MDI0+: U2.1 U24.9
MDI0+_1: CN3.1 U24.16
MDI0-: U2.2 U24.8
MDI0-_1: CN3.2 U24.17
MDI1+: U2.4 U24.12(TD4-)
MDI1+_1: CN3.3 U24.13
MDI1-: U2.5 U24.11
MDI1-_1: CN3.6 U24.14
MDI2+: U2.6 U24.2
MDI2+_1: CN3.4 U24.23
MDI2-: U2.7 U24.3
MDI2-_1: CN3.5 U24.22
MDI3+: U2.9 U24.6
MDI3+_1: CN3.7 U24.19
MDI3-: U2.10 U24.5
MDI3-_1: CN3.8 U24.20
MEM_CALRA: R95.2 U25.K15
MF_A0: R518.2 VRAM1.J1
MF_A1: R521.2 VRAM2.J1
MIC2-VREFO: R632.1 R642.1 U35.29
MSATA_DET: R235.2 R236.1 R431.1
MSATA_DET#_R: Q26.2 R423.1 R425.1
MVREFDA: C104.1 R88.1 R90.2 U25.K17
MVREFDB: C128.1 R101.1 R102.2 U25.U10
MX0: C684.1 CN10.10 CN16.10 U15.58
MX1: C685.1 CN10.9 CN16.9 U15.59
MX2: C686.1 CN10.8 CN16.8 U15.60
MX3: C687.1 CN10.7 CN16.7 U15.61
MX4: C688.1 CN10.6 CN16.6 U15.62
MX5: C689.1 CN10.5 CN16.5 U15.63
MX6: C690.1 CN10.4 CN16.4 U15.64
MX7: C691.1 CN10.3 CN16.3 U15.65
MY0: C463.1 CN10.26 CN16.26 U15.36
MY1: C464.1 CN10.25 CN16.25 U15.37
MY2: C465.1 CN10.24 CN16.24 U15.38
MY3: C466.1 CN10.23 CN16.23 U15.39
MY4: C467.1 CN10.22 CN16.22 U15.40
MY5: C468.1 CN10.21 CN16.21 U15.41
MY6: C469.1 CN10.20 CN16.20 U15.42
MY7: C470.1 CN10.19 CN16.19 U15.43
MY8: C471.1 CN10.18 CN16.18 U15.44
MY9: C472.1 CN10.17 CN16.17 U15.45
MY10: C473.1 CN10.16 CN16.16 U15.46
MY11: C474.1 CN10.15 CN16.15 U15.51
MY12: C475.1 CN10.14 CN16.14 U15.52
MY13: C476.1 CN10.13 CN16.13 U15.53
MY14: C477.1 CN10.12 CN16.12 U15.54
MY15: C683.1 CN10.11 CN16.11 U15.55
MY16: C461.1 CN10.28 CN16.28 U15.56
MY17: C462.1 CN10.27 CN16.27 U15.57
NBSWON#: C372.1 CN10.1 D34.2 R247.1 R697.2 SW3.1 SW3.2 U15.107
NVME_SSD_AUX_RST#: R429.2 R586.1 R748.1 TP61.1 U21.1 U30.AP7
OCP_DET: R391.1 R392.2 U19.16 U36.3
ODD_PRSNT#: C487.1 R388.2 U30.BD15
ODD_PRSNT#_C: C489.1 CN17.8 R375.1 R388.1
ODDPWRON: Q22.2 R413.2 R414.1 U15.20
PBA_FP_PWREN#: R694.1 U15.76
PBA_PWR: C698.2 Q34.1(S) R692.1 R711.2
PBA_PWR_C: CN13.8 R688.2
PBA_PWR_R: C410.2 C414.2 Q34.3 R688.1 R692.2
PCBEEP_EC: D31.2 U15.34
PCBEEP_EC_C: C636.2 C639.2 C643.2 R633.2 R634.1
PCH_AZ_CODEC_BITCLK: C610.2 C653.2 R588.1 U35.6
PCH_AZ_CODEC_RST#: Q38.1(S) R587.1 R656.2
PCH_AZ_CODEC_SDIN0: R662.2 U30.AL6
PCH_AZ_CODEC_SDIN0_R: R662.1 U35.8
PCH_AZ_CODEC_SDOUT: R585.1 U35.5
PCH_AZ_CODEC_SYNC: R590.1 U35.10
PCH_BLON_C: Q3.5 R71.2 R73.2 R74.2 R79.1
PCH_BLON_EC: R71.1 U15.88
PCH_DISP_ON: Q9.3 R128.2 R529.1
PCH_DPST_PWM: Q10.3 R69.1 R133.2
PCH_LVDS_BLON: Q13.3 R74.1 R170.1
PCH_SUSPWRDNACK: TP35.1 U15.15
PCIE_CLKREQ_LAN#: Q5.3 R99.1 R224.1 U30.AN11
PCIE_CLKREQ_SSD#: Q28.1(S) R241.1 R433.1 U30.AT14
PCIE_CLKREQ_WLAN#: Q44.3 R227.1 R698.2 U30.AN13
PCIE_LOM_WAKE#: R572.1 U2.21 U30.AE7
PCIE_REQ_LAN#_R: Q5.1(S) R99.2 R100.1 U2.12
PCIE_RST1#: R272.1 U30.AT13
PCIE_RST#: C138.2 C630.1 D16.1(CATHODE) R424.2 R628.2 R747.1 U2.19 U3.1
PCIE_RST#_R: R628.1 U30.AP6
PCIE_RXN9_LAN: C90.2 U30.K8
PCIE_RXN10_WLAN: CN11.43 U30.H7
PCIE_RXN13_SSD: R726.1 U30.F11
PCIE_RXN13_SSD_C: CN19.5 R726.2
PCIE_RXN14_SSD: R730.1 U30.H10
PCIE_RXN14_SSD_C: CN19.17 R730.2
PCIE_RXN15_SSD: R722.1 U30.F8
PCIE_RXN15_SSD_C: CN19.29 R722.2
PCIE_RXN16_SSD: R723.1 U30.F7
PCIE_RXN16_SSD_C: CN19.43 R723.2
PCIE_RXN_LAN_L: C90.1 U2.18
PCIE_RXP9_LAN: C94.2 U30.K7
PCIE_RXP10_WLAN: CN11.41 U30.H6
PCIE_RXP13_SSD: R725.1 U30.G11
PCIE_RXP13_SSD_C: CN19.7 R725.2
PCIE_RXP14_SSD: R729.1 U30.J10
PCIE_RXP14_SSD_C: CN19.19 R729.2
PCIE_RXP15_SSD: R721.1 U30.G8
PCIE_RXP15_SSD_C: CN19.31 R721.2
PCIE_RXP16_SSD: R724.1 U30.G6
PCIE_RXP16_SSD_C: CN19.41 R724.2
PCIE_RXP_LAN_L: C94.1 U2.17
PCIE_TXN0_SSD_C: C598.2 U30.L1
PCIE_TXN1_SSD_C: C600.2 U30.L2
PCIE_TXN2_SSD_C: C602.2 U30.M2
PCIE_TXN3_SATA1_TXN_SSD_C: C603.2 U30.N1
PCIE_TXN6_LAN_C: C608.1 U30.P4
PCIE_TXN7_WLAN_C: C606.1 U30.N4
PCIE_TXN9_LAN: C608.2 U2.14
PCIE_TXN10_WLAN: C606.2 CN11.37
PCIE_TXN13_SSD: C598.1 R739.1
PCIE_TXN13_SSD_C: CN19.11 R739.2
PCIE_TXN14_SSD: C600.1 R741.1
PCIE_TXN14_SSD_C: CN19.23 R741.2
PCIE_TXN15_SSD: C602.1 R743.1
PCIE_TXN15_SSD_C: CN19.35 R743.2
PCIE_TXN16_SSD: C603.1 R745.1
PCIE_TXN16_SSD_C: CN19.47 R745.2
PCIE_TXP0_SSD_C: C597.2 U30.L3
PCIE_TXP1_SSD_C: C599.2 U30.L4
PCIE_TXP2_SSD_C: C601.2 U30.M4
PCIE_TXP3_SATA1_TXP_SSD_C: C604.2 U30.N3
PCIE_TXP6_LAN_C: C607.1 U30.P2
PCIE_TXP7_WLAN_C: C605.1 U30.N2
PCIE_TXP9_LAN: C607.2 U2.13
PCIE_TXP10_WLAN: C605.2 CN11.35
PCIE_TXP13_SSD: C597.1 R740.1
PCIE_TXP13_SSD_C: CN19.13 R740.2
PCIE_TXP14_SSD: C599.1 R742.1
PCIE_TXP14_SSD_C: CN19.25 R742.2
PCIE_TXP15_SSD: C601.1 R744.1
PCIE_TXP15_SSD_C: CN19.37 R744.2
PCIE_TXP16_SSD: C604.1 R746.1
PCIE_TXP16_SSD_C: CN19.49 R746.2
PCIE_WAKE#: C380.2 R279.1 U30.AW12
PCIE_WLAN_WAKE#: Q24.3 R403.1 R576.1 U30.AE6
PCIE_ZVSS: R481.1 U25.AU41
PD#: C441.2 D15.2 D33.2 R327.1 R334.1 U35.47
PEG_RXN0: C44.1 U30.F13
PEG_RXN0_C: C44.2 U25.AU35
PEG_RXN1: C27.1 U30.H14
PEG_RXN1_C: C27.2 U25.AU39
PEG_RXN2: C17.1 U30.F15
PEG_RXN2_C: C17.2 U25.AR38
PEG_RXN3: C16.1 U30.K15
PEG_RXN3_C: C16.2 U25.AN38
PEG_RXP0: C37.1 U30.G13
PEG_RXP0_C: C37.2 U25.AV35
PEG_RXP1: C20.1 U30.J14
PEG_RXP1_C: C20.2 U25.AU38
PEG_RXP2: C19.1 U30.G15
PEG_RXP2_C: C19.2 U25.AR37
PEG_RXP3: C10.1 U30.J15
PEG_RXP3_C: C10.2 U25.AN37
PEG_TXN0: C594.1 U25.AT40
PEG_TXN1: C592.1 U25.AR40
PEG_TXN2: C590.1 U25.AP40
PEG_TXN3: C589.1 U25.AM40
PEG_TXP0: C596.1 U25.AT41
PEG_TXP1: C593.1 U25.AR41
PEG_TXP2: C591.1 U25.AP41
PEG_TXP3: C587.1 U25.AM41
PEGX_RST#: R103.1 R439.1 R489.2 U3.4 U23.2
PEGX_RST#_R: R489.1 U25.AV41
PLLCHARZ_H: TP15.1 U25.AU15
PLLCHARZ_L: TP16.1 U25.AV15
PLTRST#: C634.1 R308.1 R351.1 R352.1 R619.1
PMON: PC89.2 PR77.1 PR324.1 TP25.1
PP: R333.2 U16.4
PRE_SEL: R535.1 U28.27
PROCHOT_EC: C676.2 Q35.2 R691.2 U15.17
PS_0: C563.1 R512.2 R517.1 U25.AM29
PS_1: C547.1 R501.1 R507.2 U25.AV29
PS_2: C543.1 R496.1 R498.2 U25.AU31
PS_3: C546.1 R499.2 R500.1 U25.AV31
PWRLED#: CN8.19 U15.24
PX_EN: R449.1 TP44.1 U25.AC41
R_SPK+: R362.1 U35.45
R_SPK+_1: C431.1 CN14.1 R362.2
R_SPK-: R361.1 U35.44
R_SPK-_1: C430.1 CN14.2 R361.2
RAM_ID0: R266.2 R267.1 U30.BB7
RAM_ID1: R601.1 R604.2 U30.AL4
RAM_ID2: R664.2 R672.1 U30.BB16
RAM_ID3: R242.2 R243.1 U30.AR15
RASA0B: U25.D21 VRAM1.G3
RASA1B: U25.D19 VRAM2.L3
REGN6V: PC95.1 PR65.1 PU14.24
REQ_WLAN#: C700.1 CN11.53 Q44.1(S) R698.1 R704.2
RF_EN: CN11.56 R412.2
RING2: C629.2 CN8.6 CN8.7 CN8.8 R632.2 U35.17
ROMCSB: R6.2 U1.1
ROMSCK: R25.2 U1.6
ROMSI: R32.2 U1.5
ROMSO: R17.2 U1.2
RSET: R65.2 U2.31
RSMRST#: D5.1(CATHODE) R679.1 U15.112
RSMRST#_1V8S5: C342.1 C344.2 D5.2 R223.2 U30.AR8
RSVD_ID0: R151.1 R158.2 U30.T8
RSVD_ID1: R166.2 R167.1 U30.P8
RSVD_ID2: R168.1 R172.2 U30.R9
RSVD_ID3: R162.2 R163.1 U30.T9
RTC_CLK_APU: R627.2 U30.AW10
RTC_CLK_APU_C: R627.1 U33.2
S0A3_GPIO: C413.1 R313.2 U14.2 U30.AW13
S5_ON: PR93.1 PR103.2 PR299.1 R255.1 U15.100
SATA_RXN0_CN: C506.1 HD1.8
SATA_RXN0_HDD: C437.2 U30.L10
SATA_RXN0_IN: C437.1 U18.4
SATA_RXN1A_C: C456.1 CN17.5
SATA_RXN1A_ODD: C456.2 U30.J11
SATA_RXN_OUT: C506.2 U18.12
SATA_RXP0_CN: C505.1 HD1.7
SATA_RXP0_HDD: C436.2 U30.L9
SATA_RXP0_IN: C436.1 U18.5
SATA_RXP1A_C: C455.1 CN17.6
SATA_RXP1A_ODD: C455.2 U30.K11
SATA_RXP_OUT: C505.2 U18.11
SATA_TXN0_CN: C507.1 HD1.10
SATA_TXN0_HDD: C438.2 U30.K4
SATA_TXN0_IN: C438.1 U18.2
SATA_TXN1A_C: C458.1 CN17.2
SATA_TXN1A_ODD: C458.2 U30.J2
SATA_TXN_OUT: C507.2 U18.14
SATA_TXP0_CN: C508.1 HD1.11
SATA_TXP0_HDD: C439.2 U30.K2
SATA_TXP0_IN: C439.1 U18.1
SATA_TXP1A_C: C457.1 CN17.3
SATA_TXP1A_ODD: C457.2 U30.J4
SATA_TXP_OUT: C508.2 U18.15
SCL: R2.2 U25.AC35
SDA: R9.2 U25.AC34
SEN_A0: R59.1 VRAM1.J10
SEN_A1: R120.1 VRAM2.J10
SENSEA: R647.1 R651.1 U35.13
SERIRQ: R615.1 U15.5 U30.BC15
SI_SS_SEL: R478.1 R479.1 U22.5
SI_VDD: FB1.1 U22.1
SI_XTALIN: C535.1 R18.1 R442.2 U22.2 Y2.1
SI_XTALOUT: C536.1 R27.2 R442.1 U22.3(XOUT) Y2.3
SIO_EXT_SCI#: R589.1 U15.23 U30.AP4
SIO_RCIN#: R285.1 U15.4 U30.AT15
SL_CLK_100M: R480.2 U22.4
SLEEVE: C637.2 CN8.9 CN8.10 CN8.11 R642.2 U35.18
SMB_RUN_CLK: CN5.253 R286.2 R387.1 R395.1 U30.AN12
SMB_RUN_DAT: CN5.254 R287.2 R379.1 R394.1 U30.AP12
SMU_ZVDDP: R570.1 U30.P3
SPI_CS#_A: R254.2 R675.2 R676.2 TP74.1 U34.1
SPI_ROM_REQ: TP72.1 U30.BA11
SPI_SCK_A: R251.2 R638.2 TP71.1 U34.6
SPI_SDI_A: R253.2 R639.2 TP77.1 U34.5
SPI_SDO_A: R252.2 R669.2 TP82.1 U34.2
SPI_TPM_CS#: Q33.2 R316.1 R321.1 R625.1 U30.BD8
SPI_WP_R: R667.2 R668.2 TP81.1 U34.3(W\P\)
SSD_PWREN#: C519.2 Q27.2 R421.2 R422.1
SUSB#: R296.1 U14.4 U15.119
SUSC#: U15.18 U30.AV11
SUSCLK_32KHZ: CN11.50 R696.1
SUSLED#: CN8.18 U15.28
SUSON: PR121.1 R258.1 U15.120
SVC_APU: R563.1 U30.D25
SVD_APU: R565.1 U30.C25
SVI2_CLK: PC141.2 PR127.2 PR148.2 PR163.1 R98.1
SVI2_DATA: PC145.2 PR136.2 PR145.2 PR155.1 R97.1
SVI2_EN: PR168.1 R488.2 U23.4
SVI2_SVT: PC150.2 PR159.1 R96.1
SVT_APU: R564.1 U30.A25
SYS_HWPG: D21.1(CATHODE) PR72.1 PR351.1 U15.124
SYS_PWRGD: C426.2 R330.2 U30.AW2
SYS_PWRGD_R: C446.1 D12.2 D13.2 Q19.6 R330.1 R347.2
SYS_RST#: C611.2 D12.1(CATHODE) R592.1 R593.1 U30.AL2
SYS_SHDN#: PR66.1 PR71.1 PR111.1 PR310.2 Q14.3 R605.1 U15.85
TEMP_FAIL: R444.2 U25.R38
TEMP_MBAT#: PR108.2 PR110.1 PR337.1 U15.73
TEST_PG: C565.2 R523.2 R524.2 U25.AY13
TEST_PG_BACO: C564.2 R522.2 U25.BA13
THERMDA_1: C572.1 Q30.2 Q30.3 U32.2
THERMDC_1: C572.2 Q30.1(EMITTER) U32.3
TP_INTH#_L: CN12.7 Q32.1(S) R681.1 R682.1
TP_SMB_CLK: C433.1 CN12.6 Q20.3 R348.1
TP_SMB_DATA: C434.1 CN12.5 Q20.6 R349.1
TPCLK: L12.1 R671.2 U15.89
TPCLK-1: C662.1 CN12.2 L12.2
TPD_EN: R256.2 R686.1 R687.1
TPD_INT#: R226.1 R677.2 U30.AU4
TPD_INT#_EC: R246.1 R269.2 R670.2
TPDAT-1: C661.1 CN12.3 L11.2
TPDATA: L11.1 R674.2 U15.90
TPM_LRESET#: R308.2 U16.17
TPM_PIRQ: R307.2 U16.18
TRA_V_DAC: C100.1 U24.1 U24.4 U24.7 U24.10
TS_EN: R75.1 R319.1
TS_EN_C: C424.1 R319.2 U15.81
TS_EN_R: CN2.28 R75.2 R86.2
TS_INT#: CN2.37 Q4.1(S) R87.2
TS_PWR: C67.2 C74.1 CN2.31 Q4.2 Q42.1(S) R80.1 R81.2 R85.1 R86.1 R87.1 R210.2 R211.2 R519.2
TS_RST#: CN2.30 R84.1
TSPWRON#: Q42.2 R735.1 U15.109
TX0_HDMI+: CN4.7 R154.2 U27.2 U27.9
TX0_HDMI-: CN4.9 R148.2 U27.1 U27.10(NC#4)
TX1_HDMI+: CN4.4 R149.2 U29.4 U29.7
TX1_HDMI-: CN4.6 R155.2 U29.5 U29.6
TX2_HDMI+: CN4.1 R143.2 U29.1 U29.10(NC#4)
TX2_HDMI-: CN4.3 R146.2 U29.2 U29.9
TXC_HDMI+: C206.2 CN4.10 R169.1 U27.5 U27.6
TXC_HDMI-: C206.1 CN4.12 R171.1 U27.4 U27.7
TYPEC1_DDI1_HPD: TP14.1 U25.AU21
TYPEC_SBU1: CN15.A8 D24.2 TP39.1
TYPEC_SBU2: CN15.B8 D36.2 TP86.1
TYPEC_STRAP: R332.1 R339.2 U15.77
UART0_RXD: TP64.1 U30.BA17
UART0_TXD: TP65.1 U30.BC16
USB3_SS0RX+: C695.2 U39.8
USB3_SS0RX+_RE: C703.1 U39.4
USB3_SS0RX+_RE_C: C703.2 R408.1 U19.5
USB3_SS0RX-: C694.2 U39.7
USB3_SS0RX-_RE: C702.1 U39.5
USB3_SS0RX-_RE_C: C702.2 R401.1 U19.4
USB3_SS0TX+: C697.2 U39.11
USB3_SS0TX+_RE: C706.1 U39.1
USB3_SS0TX+_RE_C: C706.2 R416.1 U19.7
USB3_SS0TX-: C696.2 U39.10
USB3_SS0TX-_RE: C705.1 U39.2
USB3_SS0TX-_RE_C: C705.2 R415.1 U19.6
USB30_RX0+: C695.1 U30.AA2
USB30_RX0-: C694.1 U30.AA4
USB30_RX1+: C278.2 C285.2 U30.AD8
USB30_RX1+_C: C285.1 CN6.6 U7.10
USB30_RX1-: C289.2 C292.2 U30.AD9
USB30_RX1-_C: C289.1 CN6.5 U7.1
USB30_RX2+: C354.1 C357.2 U30.AD12
USB30_RX2+_C: C357.1 CN9.6 U13.10
USB30_RX2-: C360.2 C362.1 U30.AD11
USB30_RX2-_C: C360.1 CN9.5 U13.1
USB30_RX+_TYPEC1: C483.1 CN15.B11 R396.1 RV3.1 RV3.10(NC#4)
USB30_RX+_TYPEC1_C: C483.2 U19.3
USB30_RX+_TYPEC2: C460.1 CN15.A11 R363.1 RV7.1 RV7.10(NC#4)
USB30_RX+_TYPEC2_C: C460.2 U19.1
USB30_RX-_TYPEC1: C481.1 CN15.B10 R383.1 RV3.2 RV3.9
USB30_RX-_TYPEC1_C: C481.2 U19.2
USB30_RX-_TYPEC2: C453.1 CN15.A10 R355.1 RV7.2 RV7.9
USB30_RX-_TYPEC2_C: C453.2 U19.24
USB30_TX0+: C697.1 U30.AA1
USB30_TX0-: C696.1 U30.AA3
USB30_TX1+: C262.2 U30.AE1
USB30_TX1+_C: C262.1 R179.1
USB30_TX1+_C_R: C261.1 CN6.9 R179.2 U7.6
USB30_TX1-: C266.2 U30.AE3
USB30_TX1-_C: C266.1 R180.1
USB30_TX1-_C_R: C267.1 CN6.8 R180.2 U7.5
USB30_TX2+: C346.2 U30.AD2
USB30_TX2+_C: C346.1 R229.1
USB30_TX2+_C_R: C345.1 CN9.9 R229.2 U13.6
USB30_TX2-: C348.2 U30.AD4
USB30_TX2-_C: C348.1 R234.1
USB30_TX2-_C_R: C349.1 CN9.8 R234.2 U13.5
USB30_TX+_TYPEC1: C512.1 CN15.A2 RV7.5 RV7.6
USB30_TX+_TYPEC1_C: C512.2 U19.9
USB30_TX+_TYPEC2: C513.1 CN15.B2 RV3.5 RV3.6
USB30_TX+_TYPEC2_C: C513.2 U19.10
USB30_TX-_TYPEC1: C511.1 CN15.A3 RV7.4 RV7.7
USB30_TX-_TYPEC1_C: C511.2 U19.8
USB30_TX-_TYPEC2: C514.1 CN15.B3 RV3.4 RV3.7
USB30_TX-_TYPEC2_C: C514.2 U19.11
USB_BC_ON: U10.4 U15.97
USB_CHARGE_ON: R198.1 U10.5 U15.96
USB_CLT1: U10.6 U15.79
USB_OC0#: D29.1(CATHODE) U10.13
USB_OC1#: D28.1(CATHODE) U31.3
USB_OC2#: D30.1(CATHODE) U38.3
USB_OCP_ALL#: D28.2 D29.2 D30.2 R602.2 U30.AE9
USBON#: U15.99 U31.4 U38.4
USBP0+: R418.1 U30.AC6
USBP0-: R419.1 U30.AC7
USBP1+: R204.1 R205.1 U30.AA8
USBP1+_C: R187.1 U10.10
USBP1+_C_R: R188.1 R205.2
USBP1+_C_R_N: CN6.3 R187.2 R188.2 U7.7
USBP1+_U14: R204.2 U10.3
USBP1-: R207.1 R208.1 U30.AA9
USBP1-_C: R184.1 U10.11
USBP1-_C_R: R185.1 R208.2
USBP1-_C_R_N: CN6.2 R184.2 R185.2 U7.4
USBP1-_U14: R207.2 U10.2
USBP2+: R238.1 U30.AA11
USBP2+_C: CN9.3 R238.2 U13.7
USBP2-: R237.1 U30.AA12
USBP2-_C: CN9.2 R237.2 U13.4
USBP4+_DB: CN8.16 U30.W8
USBP4-_DB: CN8.15 U30.W9
USBP5+_CAM: R503.1 U30.W11
USBP5+_CAM_C: CN2.8 R503.2
USBP5-_CAM: R502.1 U30.W12
USBP5-_CAM_C: CN2.7 R502.2
USBP7+_FP: CN13.7 EC1.2 U30.Y7
USBP7-_FP: CN13.6 EC2.1 U30.Y6
USBP8+_TS: R516.1 U30.AC9
USBP8-_TS: R515.1 U30.AC10
USBP8_TS+_C: CN2.5 R514.2 R516.2
USBP8_TS-_C: CN2.4 R513.2 R515.2
USBP10+_BT: CN11.3 U30.Y10
USBP10-_BT: CN11.5 U30.Y9
USBP_TYPC+_C: CN15.A6 CN15.B6 R418.2 RV8.2
USBP_TYPC-_C: CN15.A7 CN15.B7 R419.2 RV9.2
USBPWRD2: C384.2 C390.2 C395.2 C647.2 C654.1 CN8.25 CN8.26 CN8.27 CN8.28 CN8.29 CN8.30 U38.1(OUT)
VA: PC20.1 PC27.1 PC144.1 PC147.1 PD1.1 PD2.2 PJ11.1 PQ1.5 PR60.1 PR321.1
VA2: PC10.1 PQ1.1 PQ1.2 PQ1.3(S3) PQ3.1 PQ3.2 PQ3.3(S3) PR319.1
VADJ1: C52.1 CN2.27 R67.1 R70.2
VGA_AC_BATT: D3.2 R31.2 R36.1 U25.AA34
VGA_ALERT: R39.2 TP8.1 U25.R37
VGA_RSTB: U3.2 U30.AV13
VGPU_CORE_PG: PR179.1 PR193.2 PR253.1 U23.1
VGPU_CORE_SENSE: PR208.2 U25.AR13
VL: PR109.1 PR326.1
VMON: R373.1 R374.2 U19.17(VMON)
VQQD_VPPSNS: PR116.2 PU1.12
VREF_PINSET_CPU: PR45.1 PR56.1 PR260.1 PR261.1 PR262.1 PR264.1 PR274.2 PR277.1 PU3.15
VREF_PINSET_GPU: PR143.1 PR144.1 PR149.1 PR152.1 PR169.1 PR175.1 PR177.2 PR178.2 PU8.15
VREFC_A0: C9.2 R46.2 R47.2 VRAM1.J14
VREFC_A1: C582.2 R553.2 R554.2 VRAM2.J14
VREFD1_A0: C21.2 R48.2 R50.2 VRAM1.A10
VREFD1_A1: C571.2 R526.2 R528.2 VRAM2.A10
VREFD2_A0: C545.2 R495.2 R497.2 VRAM1.U10
VREFD2_A1: C581.2 R547.2 R548.2 VRAM2.U10
VRM_PWRGD: D18.1(CATHODE) PR52.1 PR57.2 R200.2 R201.1 R202.2
VRON: PR36.1 R369.1 U15.69
VSEN_CPU: PR272.1 PU3.8(VSEN)
VSTBY_FSPI: R264.2 R265.1 U15.106
VSYNC: R12.2 R13.2 U25.W35
WCKA0_0: U25.D33 VRAM1.D4
WCKA0_1: U25.A34 VRAM1.P4
WCKA0B_0: U25.E33 VRAM1.D5
WCKA0B_1: U25.B34 VRAM1.P5
WCKA1_0: U25.A22 VRAM2.D4
WCKA1_1: U25.A8 VRAM2.P4
WCKA1B_0: U25.B21 VRAM2.D5
WCKA1B_1: U25.B9 VRAM2.P5
WEA0B: U25.G29 VRAM1.L12
WEA1B: U25.D11 VRAM2.G12
WLAN_PLT_RST#: C502.2 CN11.52 D16.2 D17.2 R397.1 R747.2
WLAN_WAKE#: CN11.55 Q24.1(S) R403.2 R409.1
WLANPWR_EN: U15.35 U20.4
WRST#: C427.1 D14.2 R331.1 U15.14(WRST#)
XTAL1: R64.2 U2.28
XTAL2: R63.1 U2.29
XTALIN: R27.1 R480.1 U25.BA39
XTALOUT: R18.2 TP3.1 U25.AY39
ZQ_A0: R457.2 VRAM1.J13(ZQ)
ZQ_A1: R555.2 VRAM2.J13(ZQ)
N301427: C2.1 R21.1 R40.2
N9111136: R1.2 R7.1
N9111150: R20.2 R30.1
N17002655: C670.2 U35.39
N17002661: C666.2 U35.37
N17002676: C655.1 U35.34
N17002678: C640.1 U35.19
N17002722: R317.2 R318.2 U35.48
N17002952: C652.1 U35.7
N17002968: R655.1 R656.1 U35.11
N17002995: C643.1 R654.1 U35.12
N17003129: C666.1 U35.35
N17003186: R645.1 U35.20
N17004316: D33.1(CATHODE) Q38.3
N17046941: PJ18.3 PR106.1
N17047007: PQ3.5 PR16.1 PR21.1
N17047009: PR336.2 PU14.20
N17047028: PR339.2 PU14.19
N17047083: PJ18.5 PR108.1
N17047104: PC108.1 PL15.2 PQ9.1 PQ9.2 PQ9.3(S3) PR92.1 PR342.2 PR344.1
N17047112: PC10.2 PC27.2 PQ3.4 PR320.1 PR352.2
N17047116: PQ1.4 PR352.1
N17047335: PC277.1 PR340.2
N17047399: PC271.2 PR328.2
N17047425: PJ18.4 PR107.1
N17047601: PC108.2 PQ9.4 PR85.1
N17398787: PR317.2 PU14.5
N17424918: PR325.2 PU14.11
N17424920: PR327.2 PU14.12
N17424921: PR322.2 PU14.7
N17424925: PR324.2 PU14.9
N17424950: PR337.2 PR338.2 PU14.15
N17661815: PR323.2 PU14.8
N19521323: PQ10.3 PR73.1
N19521733: PQ10.2 PR86.2 PR87.1 PR88.2
N19549602: PQ11.2 PR112.1 PR114.2 PR115.2
N25369936: Q20.1(S) R376.2 R394.2
N25369945: Q20.4 R377.2 R395.2
N26277307: PC233.1 PC240.1 PR263.2 PR265.1 PR272.2 PR289.1
N26277311: PR44.1 PR45.2
N26277331: PR49.1 PR50.2
N26277333: PR55.1 PR56.2
N26277349: PR267.1 PR273.2 PR284.1
N26277351: PR267.2 PR270.2
N26277353: PR273.1 PR277.2
N26277375: PC231.1 PR261.2
N26277377: PR231.1 PR233.2 PR235.1
N26277386: PR44.2 PR47.1 PR233.1
N26277388: PC71.2 PR46.2
N26277392: PR234.2 PR259.1 PR260.2
N26277394: PR234.1 PR262.2
N26277398: PC65.2 PR41.2
N26277400: PC73.2 PR54.2
N26277406: PR47.2 PR48.1
N26277420: PR281.1 PR282.1 PR284.2
N26277422: PC221.1 PR229.1 PR232.2 PR255.1
N26277961: PC56.1 PR33.2
N26277963: PC237.1 PR285.2
N26277967: PC203.1 PR241.2
N26418322: PC241.1 PC242.1 PC251.1 PC252.1 PC253.1 PC254.1 PC255.1 PC256.1 PJ15.2 PL13.2 PR313.2
N26418727: PC259.1 PR307.2
N26418739: PC244.2 PR294.1
N26547647: PC199.1 PQ27.2 PQ28.3 PR237.2
N27032306: PC223.1 PR257.2 PU3.28
N27032510: PR274.1 PR283.1
N27032514: PR264.2 PR268.1 PR283.2
N27752748: R630.1 R631.1 R645.2
N28087213: C544.2 R57.1 R58.1 R60.1 R61.1
N28100067: CN12.8 R687.2
N30442033: PC91.1 PC93.1 PR333.1 PU5.8
N30442036: PC117.1 PC119.1 PR341.2 PU5.13(VOUT1)
N30442060: PC107.1 PR90.2 PU5.4
N30442080: PC100.1 PR83.1 PU5.5
N30442084: PC115.1 PR93.2 PU5.3
N30568314: PC81.2 PR61.2 PR62.1 PU13.12
N30568326: PC81.1 PR59.1
N30568424: PC307.2 PR346.2 PR349.1 PU15.9
N30568429: PC307.1 PR350.1
N30568472: PC128.1 PR109.2 PU15.12
N30568498: PQ11.3 PR113.1
N30568542: PR64.2 PR68.2 PR72.2 PR318.1
N31161954: PC106.1 PC112.1 PR95.1 PU4.8
N31161958: PC281.1 PR330.2 PU4.4
N31161974: PC284.1 PU4.12
N31161976: PC283.1 PU4.10
N31161997: PC113.1 PC121.1 PR97.2 PU4.13(VOUT1)
N31162017: PC279.1 PR335.1 PU4.5
N31162025: PC280.1 PR329.2 PU4.3
N33761123: CN19.38 D25.2 R434.1
N33919807: Q9.2 Q11.3 R142.2
N33919901: Q11.2 R557.2
N33922442: Q8.3 Q10.2 R137.2
N33922489: Q8.2 R552.2
N36446693: C25.1 R63.2 Y1.3
N36953746: C668.2 Q34.2 R694.2
N36954805: R357.2 U17.7
N36977514: Q40.3 Q41.2 R703.2
N37139396: D9.2 R333.1
N37139525: R358.2 U16.24
N37139527: R325.2 U16.21
N37139529: R311.2 U16.19
N37139543: R321.2 U16.20
N37162929: R318.1 TP34.1
N37164012: C639.1 U35.16
N37164724: D31.1(CATHODE) D32.1(CATHODE) R634.2
N37738541: TP59.1 U30.AK32
N37738542: TP60.1 U30.AL31
N38048788: C268.1 R182.1 U30.AC21 U30.AD21
N38521997: CN16.1 D37.1 R697.1
N38680880: Q36.2 R689.1
N38756671: C501.2 R412.1 U15.66
N38756677: TP36.1 U15.78
N38756738: C416.2 R303.1 U15.82
N38756787: C373.2 R256.1 U15.98
N38756834: Q15.3 R233.2 SW2.3 SW2.4
N38757336: C369.1 R269.1 U15.128
N38757406: C341.1 Q15.2 R222.1 SW1.3 SW1.4
N38758998: C425.2 R322.1
N38759178: C418.1 U15.12
N39268705: Q32.3 R670.1 R677.1 R682.2
N39618724: R641.1 TP66.1 U30.BC11
N39785725: HD1.1 R705.1 R707.1
N40550359: Q29.2 Q29.5 R436.2 R439.2
N41800206: R658.1 R659.1 R660.1 R661.1
N42696396: TP53.1 U28.33
N42696414: TP54.1 U28.34
N42696431: R145.1 U28.36
N42868528: CN11.58 R702.1
N42946269: R424.1 R427.2 R428.2 U21.2
N42947913: Q26.3 R431.2
N43515700: TP18.1 U30.AC29
N43515715: TP62.1 U30.AR31
N43541412: Q19.2 Q19.3 R346.2
N43541437: C426.1 R326.2
N43551997: C344.1 R225.2
N43603731: C517.1 Q23.2 Q25.3 R420.2
N43605845: C488.1 Q21.2 Q22.3 R393.2
N43643606: Q12.3 Q13.2 R164.2
N43643623: Q12.2 R558.2
N43702733: CN2.24 R504.2
N43737419: CN2.29 R506.2
N44248719: C103.2 R84.2 R85.2
N44448022: Q39.3 R693.2 R708.2 R715.1
N44448095: Q39.2 R701.2
N44687038: TP30.1 U15.2
N44719631: Q14.2 R201.2
N44878476: CN19.68(SUSCLK) R435.1
N44885066: PD2.3(COMMON ANODE) PR74.2
N45198823: PC4.1 PC5.1 PL1.2 PR116.1 PR125.1
N45292490: CN19.69 R423.2
N45472894: PC114.1 PU5.12
N45472895: PC102.1 PU5.10
N45477665: C24.2 Q1.2 R56.2
N45479516: PC92.1 PR76.2 PU6.4(VIN)
N45481673: PC170.1 PC172.1 PR191.1 PR192.2 PR206.2 PR208.1
N45613574: R525.2 U26.3
N45705221: PC22.1 PR10.1 PR14.1
N45707852: PR160.2 PR162.1 PU8.24
N45737842: PC24.1 PR11.2
N45744946: D3.1(CATHODE) R28.1 R33.2
N45985279: L2.1 R53.1
N45985282: L1.1 R52.1
N45988033: R368.2 U20.3
N46048036: D8.2 R309.2 R310.1
N46807066: PC43.1 PC44.1 PC45.1 PC46.1 PC47.1 PC197.1 PC201.1 PC202.1 PC218.2 PJ3.2 PL10.2 PR249.1
N46807891: PC188.1 PC189.1 PC190.1 PR223.2 PR224.1 PU9.6
N47284656: PC104.1 PC105.1 PJ8.2 PU7.3(VIN)
N47284687: PC110.1 PC111.1 PC122.1 PC123.1 PJ7.2 PL4.2 PR99.2
N47284767: PC125.2 PR98.2
N47360845: Q14.1(EMITTER) R731.2
N47751595: C188.1 R150.1 R156.1
N47964247: C411.2 Q17.2 R302.2
N47965740: C444.2 Q18.2 R345.2
N48031337: R366.1 U19.18
N48031368: C509.2 R335.1 U19.13
N48041869: PC153.1 PR170.2 PU8.28
N48041922: PR153.2 PR157.1 PR202.1
N48041929: PR177.1 PR200.1
N48041930: PR171.1 PR178.1 PR200.2
N48041941: PR201.1 PR202.2 PR203.1
N48041971: PR117.1 PR150.2 PR165.1
N48041975: PR117.2 PR118.1 PR123.1
N48041983: PR124.2 PR138.1 PR144.2
N48042007: PC151.1 PR15.2 PR18.1 PR146.1
N48042043: PR149.2 PR150.1
N48042051: PR172.2 PR173.1
N48042052: PR175.2 PR176.1
N48042059: PR156.2 PR157.2
N48042060: PR152.2 PR153.1
N48042070: PC163.1 PR169.2
N48042075: PC166.2 PR174.2
N48042078: PR124.1 PR143.2
N48042080: PC159.2 PR158.2
N48042081: PC167.2 PR186.2
N48042082: PR164.1 PR165.2
N48043954: PC30.1 PR23.2
N48043955: PC175.1 PR199.2
N48073638: PC270.1 PR326.2 PU12.5(VCC)
N48073642: PR311.1 PU12.1
N48073650: PR310.1 PU12.3
N48075705: PC109.1 PR78.1 PR82.2 PU6.6
N48094139: PC109.2 PR82.1 PR104.1
N48094145: PC118.2 PR102.2 PU6.1
N48094152: PR79.2 PU6.5
N48094169: PQ20.3 PR213.2
N48094182: PQ23.3 PR219.2
N48094185: PQ19.3 PR204.2
N48094210: PQ6.3 PR58.2
N48095830: PR136.1 PR137.1 PR148.1
N48547452: PQ25.3 PR226.2
N48583626: PR303.2 TP63.1
N48758839: PC208.1 PR242.2
N48758857: PC205.2 PR243.1
N48838349: PC186.2 PC187.1 PR225.1 PU9.3
N48838408: PR220.1 PR223.1 PU9.7
N48838426: PR216.2 PR217.1 PU9.1
N48839459: PQ13.2 PQ29.3 PR227.2 PR228.1
N48839476: PQ13.3 PR129.2
N48839503: PQ29.2 PR236.2
N48839793: PQ4.2 PQ5.3 PR27.1 PR28.2
N48839805: PQ4.3 PR26.2
N48839825: PQ5.2 PR29.2
N48842289: PQ18.2 PQ22.3 PR214.2 PR215.1
N48842319: PQ18.3 PR25.2
N48842333: PQ22.2 PR221.2
N48844175: PQ2.2 PQ12.3 PQ15.2 PR2.2 PR3.1
N48844187: PQ15.3 PR141.2
N48844204: PQ12.2 PR119.2
N48844243: PQ2.3 PR9.2
N424048290: CN5.165 TP58.1
N424048650: CN5.162 TP20.1

Pads without a net: CN2 38; CN4 13 14; CN5 87 88 91 92 95 96 97 100 101 104 105 166; CN7 14 18 20; CN11 6 8 9 10 11 12 14 15 16 17 20 21 22 23 32 34 36 38 40 42 44 46 48 59 61 65 67; CN13 1 2 3 4; CN18 3; CN19 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CN20 3 4; HOLE4 1; HOLE16 1; NOREF 1; NOREF#2 1; NOREF#3 1; NOREF#7 1; NOREF#9 1; NOREF#10 1; PQ16 2; PQ17 2; PQ32 2; PQ33 2; PU2 5; PU7 5; PU9 5; PU10 7; PU11 7; U10 9; U16 2 3 5 6 7 9 10 11 12 13 14 15 25 26 27 28 29 30 31 32; U17 2 3; U25 AA2 AA4 AA7 AA8 AB1 AB2 AC1 AC2 AC4 AC5 AC8 AD1 AD2 AE2 AE4 AE7 AE8 AE34 AE37 AE38 AF1 AF2 AG1 AG2 AG4 AG5 AG8 AG34 AG37 AG38 AH1 AH2 AH40 AH41 AJ2 AJ4 AJ7 AJ8 AJ37 AJ38 AJ40 AJ41 AK1 AK2 AK40 AK41 AL1 AL2 AL4 AL5 AL8 AL37 AL38 AL40 AL41 AM1 AM2 AM11 AM19 AM21 AN2 AN4 AN5 AN8 AN34 AP1 AP2 AP11 AP19 AP21 AP23 AP29 AP31 AR1 AR2 AR4 AR5 AR23 AR29 AT1 AT2 AU2 AU4 AU7 AU11 AU19 AU27 AV1 AV2 AV7 AV9 AV11 AV19 AV23 AV27 AW1 AW2 AY3 AY4 AY5 AY6 AY7 AY8 AY10 AY11 AY14 AY15 AY16 AY18 AY19 AY20 AY21 AY22 AY24 AY25 AY26 AY27 AY28 AY30 AY31 AY32 AY33 AY34 AY35 AY36 BA3 BA4 BA6 BA7 BA8 BA10 BA11 BA14 BA15 BA16 BA18 BA19 BA20 BA21 BA22 BA24 BA25 BA26 BA27 BA28 BA30 BA31 BA32 BA33 BA34 BA35 BA36 C1 C2 D1 D2 E2 E11 F1 F2 G1 G2 G4 G5 H1 H2 H29 J2 J4 J7 J8 K1 K2 K41 L1 L2 L4 L5 L8 M1 M2 N2 N4 N7 N8 N34 N35 N38 P1 P2 R1 R2 R4 R5 R8 R10 R34 R40 R41 T1 T2 T40 T41 U2 U4 U7 U8 U34 U40 U41 V1 V2 V40 V41 W1 W2 W4 W5 W8 Y1 Y2; U28 2 4 9 10 12 25 26 37; U30 A8 A13 A15 A18 A20 AA6 AA20 AA25 AA27 AA29 AA30 AA31 AB29 AB31 AC1 AC2 AC3 AC4 AC12 AC26 AC27 AC30 AD3 AD6 AE12 AF6 AF11 AF12 AG1 AG2 AG3 AG4 AG9 AG10 AG12 AG21 AJ6 AJ8 AJ9 AJ27 AJ29 AK1 AK3 AK21 AL3 AL13 AL14 AL15 AL29 AM3 AM4 AM7 AM9 AM10 AM13 AM14 AN2 AN4 AN16 AP1 AR3 AR6 AR29 AT4 AU6 AU7 AV3 AV8 AW7 AW8 B6 B8 B13 B15 B16 B17 B18 B20 B21 B24 BB12 BD18 C6 C7 C8 C13 C14 C15 C16 C18 C19 C20 C21 C26 D6 D8 D13 D15 D16 D17 D18 D20 D21 D24 F10 F12 F14 F16 F18 G18 G19 H1 H2 H3 H4 H12 H16 H19 J12 J13 J16 J18 K13 K18 K19 L6 L7 L12 L14 L16 L19 M6 M8 M9 M11 M12 M13 M14 M19 M20 N6 N7 N9 N10 N12 N19 P6 P9 P11 P12 R1 R3 R6 R7 R10 R12 T2 T4 T6 T11 T12 U2 U4 V1 V3 V6 V7 V9 V10 V12 V24 V26 V29 V31 W1 W2 W3 W4 W6 W24 W25 W27 W29 W30 W31 Y12 Y26 Y27 Y30 Y32; U32 6; U33 1; U35 14 15 23 24; VRAM1 A5 U5; VRAM2 A5 U5

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4979 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 1047 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 221 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
+0.75V:
  vias: v1(91.2,67.47) v1(93.28,78.6) v1(93.28,77.96) v1(93.28,77.33) v1(93.28,76.69) v2(89.72,65.48) v2(89.97,66.27) v2(90.48,65.46) v2(90.99,66.37) v2(91.12,65.52)
+0.75V_S5:
  vias: v1(95.03,31.81) v2(92.01,48.88) v2(92.08,49.71) v2(92.59,48.88)
+0.95V_SENSE_REMOTE: length 2.2
  BOTTOM w0.203: PR314.1 127.67,35.83 128.08,35.42 v1(128.28,35.42) 128.97,35.42 129.22,35.67 PR315.1
+0.95VS5_SENSE_REMOTE: length 21.2
  BOTTOM w0.152: PR313.1 130.72,36.97 130.77,36.92 140.8,36.92 141.88,37.99 145.28,37.99 146.31,39.03 PC248.2
  BOTTOM w0.203: PR305.1 146.83,40.92 147.4,40.35 147.61,40.35 PR306.1 147.38,39.98 v1(147.13,39.73) 146.85,39.73 146.32,39.2 PC248.2
+1.2V: length 104.2
  TOP w0.203: v1(16.72,78.12) 17.26,77.58 C195.2 ; C201.2 17.11,76.82 v1(16.72,76.44) ; v1(24.34,77.87) 23.99,78.22 C192.2 ; v1(18.73,74.26) 19.24,74.76 C207.2 ; v1(20.73,74.26) 20.64,74.35 C209.2 C210.2 ; C184.2 C183.2 20,81.67 20.1,81.77 20.1,81.87 20.09,81.88 v1(20.09,81.9)
  IN2 w0.508: 17.21,73.39 16.95,73.14 16.06,73.14 15.47,72.54 14.75,72.54 14.03,73.27 14.03,80.5 17.21,83.68 17.59,83.68 22.54,88.63 22.54,90.54 23.46,91.45 27.14,91.45 30.69,95.01 44.16,95.01 45.02,95.87 46.54,95.87 48.07,97.4 v1(48.19,97.4)
  BOTTOM w0.102: U28.30 20.33,81.64 20.09,81.88 v1(20.09,81.9)
  BOTTOM w0.178: U28.15 16.95,76.67 v1(16.72,76.44) ; U28.46 v1(24.34,76.67) ; v1(16.72,78.12) 16.98,77.87 U28.18 ; U28.6 v1(20.73,74.26) ; U28.43 v1(24.34,77.87) ; U28.11 v1(18.73,74.26)
  BOTTOM w0.508: PR226.1 PQ26.1 63.64,82.28 60.44,85.49 60.44,86.65 60.89,87.11 61.81,87.11 62.05,87.35 62.05,88.26 61.78,88.53 61.78,89.27 61.4,89.65 60.72,89.65 60.21,90.16 60.21,96.64 58.56,98.28 55.99,98.28 55.15,99.12 51.81,99.12 50.08,97.4 v1(48.19,97.4)
  vias: v1(24.45,76.06)
+1.2VSUS: length 244.9
  TOP w0.102: C296.1 84.84,52.91
  TOP w0.152: PR6.1 66.07,117.76 65.34,117.76 65.12,117.54 63.87,117.54 63.43,117.97 58.63,117.97 57.82,118.78 52.47,118.78 50.15,121.1 PC9.1
  TOP w0.178: v1(40.12,38.21) 39.95,38.21 39.33,38.83 39.33,39.36 U12.J2 39.56,39.92 39.56,40.39 U12.J1
  TOP w0.203: U6.R1 34.52,75.93 33.34,75.93 32.67,75.27 C212.2 ; C377.2 38.83,31.83 v1(38.8,31.86) 38.26,31.33 C376.1 ; v1(31.92,33.58) 31.83,33.67 C356.1 ; C282.1 42.89,54.65 v1(42.73,54.49) 42.32,54.9 C281.1 ; C272.1 34.58,56.82 34.13,57.26 33.87,57.26 33.84,57.29 v1(33.82,57.29) ; R173.1 51.65,68.28 v1(51.62,68.31) ; C283.2 44.36,54.78 v1(44.64,54.49) 44.92,54.78 C284.1 ; v1(41.16,54.49) 40.86,54.8 C280.1 ; v1(31.29,33.07) 31.19,32.98 C358.1 ; C194.2 v1(32.07,77.96) R160.2 ; U9.R1 34.03,52.82 31.69,52.82 31.08,53.42 C293.2 30.67,53.76 30.85,53.94 v1(31.51,53.94) ; C340.2 30.7,41.23 30.71,41.24 v1(30.9,41.24) ; C221.1 30.13,70.21 v1(29.66,70.68) ; C333.2 44.61,42.81 44.95,42.47 v1(45.33,42.47) 45.18,42.62 C334.1 45.18,45.38 U9.B9 ; v1(43.62,31.79) 43.47,31.65 C378.1 ; C324.1 30.41,46.21 30.64,45.99 C326.1 30.8,45.58 31.13,45.25 31.68,45.25 31.79,45.35 33.95,45.35 U9.T9 ; R178.2 47.43,62.98 ; v1(41.73,80.11) 42.35,79.48 C189.2 ; v1(40.57,43.65) C331.1 C330.1 39.18,44.47 U9.L9
  TOP w0.254: C212.2 30.54,75.55 v1(30.8,75.81) ; C258.1 53.53,60.79 v2(53.55,60.82) ; U9.G9 v1(41.73,45.13) ; U5.T9 32.96,80.51 32.95,80.5 v1(32.93,80.5) ; U9.F8 v1(41.73,45.93) ; C221.1 30.13,69.8 30.87,69.07 34.07,69.07 U6.T9
  TOP w0.305: U12.L9 37.73,33.75 v1(37.73,33.7) ; v2(86.7,48.49) 86.69,48.48 86.69,48.37 C318.1 ; U5.R1 34.53,86.51 v1(34.52,86.51) ; v1(38.16,79.97) 38.13,80.01 U5.L9 ; U6.A9 v1(46.53,68.73) ; U5.J8 39.72,81.31 39.32,80.91 v1(39.32,80.9) 39.32,80.89 39.71,80.51 U5.J9 ; v1(40.13,33.75) U12.J9
  TOP w0.356: v1(44.91,87.31) 44.91,87.29 U5.C1 ; v1(44.91,75.93) 44.91,75.92 U6.C1 ; U6.J2 39.92,74.93 39.92,75.33 U6.J1 40.85,76.65 41.15,76.65 v1(41.34,76.84) ; U12.C1 44.53,40.55 v1(44.12,40.14) 44.12,40.16 U12.D1 ; U6.G9 41.33,69.12 41.73,68.72 v1(41.73,68.7) ; U9.D9 43.73,45.02 v1(43.78,44.97) ; v1(45.74,74.33) 45.73,74.33 U6.B3 ; U12.A9 46.13,34.15 v1(45.73,33.75) ; v1(39.26,67.99) 39.14,67.99 38.13,69 U6.L9 ; 45.72,45.93 45.72,45.92 U9.B9 ; 45.72,45.93 U9.A9 ; 45.72,45.93 v1(45.72,45.95) ; U6.D9 v1(44.13,68.73) ; U9.A1 v1(46.53,51.53) ; U12.T9 33.55,33.58 v1(31.92,33.58) ; U12.R1 34.24,41.24 v1(30.9,41.24) ; v1(44.13,52.33) 44.52,51.93 U9.C1 ; v1(38.56,75.93) 38.53,75.93 U6.L1 ; v1(41.73,69.5) 41.73,69.53 U6.F8 ; U5.G1 41.71,87.29 v1(41.71,87.33) ; v1(40.18,41.76) 39.33,41.76 U12.L1 ; U5.J2 v1(39.33,86.51) U5.J1 ; v1(46.04,37.83) 46.04,38.24 U12.B3 ; U6.J8 v1(39.33,69.53) ; U6.J9 39.92,68.93 39.92,68.65 40.56,68.01 v1(40.95,68.01) ; v1(46.54,75.93) 46.51,75.92 U6.A1 ; v1(44.11,75.93) 44.11,75.92 U6.D1 ; U9.J2 39.99,51.39 39.99,51.67 39.74,51.93 U9.J1 40.56,52.76 41.68,52.76 42.03,53.11 v1(42.03,53.31) ; U5.A9 46.13,80.47 v1(45.73,80.07) 45.33,80.47 U5.B9 ; v1(41.16,54.49) 41.01,54.34 39.81,54.34 38.13,52.66 U9.L1 ; v1(44.13,80.07) 43.73,80.47 U5.D9 ; U9.B3 v1(45.73,50.73) ; v1(42.53,75.13) 42.53,75.13 U6.F2 ; U12.A1 46.62,40.06 v1(46.62,39.33) ; U12.D9 43.33,33.75 v1(43.3,33.75) ; v1(45.74,85.71) 45.73,85.71 U5.B3 ; U5.F2 42.53,86.51 v1(42.51,86.53) ; U6.G7 41.33,70.7 v1(41.73,70.3) ; U12.F8 v1(41.73,34.55) ; v1(44.93,33.75) 44.93,33.76 U12.B9 ; U5.A1 46.51,87.29 v1(46.54,87.31) ; U9.J8 v1(40.13,45.93) ; v1(42.53,50.72) 42.51,50.72 42.13,51.11 U9.F2 ; U5.G9 v1(41.73,80.11) ; U12.G1 41.69,40.19 v1(41.73,40.19) 41.73,40.15 42.13,39.76 U12.F2 ; v1(44.11,87.31) 44.11,87.29 U5.D1 ; v1(37.74,86.52) U5.L1 ; U9.G1 v1(41.73,51.53) ; U6.B9 45.72,68.73 v1(45.73,68.73) ; U12.J8 v1(40.13,34.55) ; v1(40.13,45.13) U9.J9 ; U5.G7 v1(41.73,81.71) ; U6.G1 v1(40.93,75.93) ; U5.F8 v1(41.73,80.91) ; U9.D1 v1(43.33,52.33) ; U9.G7 v1(41.73,47.53) ; U12.G9 v1(41.73,33.75) ; U12.G7 v1(41.73,35.35)
  TOP w0.381: C322.1 69.78,47.87 69.66,47.99 ; v2(85.31,50.49) 85.32,50.51 C305.1 ; v1(65.09,83.23) 61.34,86.98 58.74,86.98 57.97,87.74 50.35,87.74 49.46,86.85 ; 84.84,52.91 v2(84.41,52.48) ; v1(52.35,69.46) 52.39,69.5 C220.2 ; v2(51.56,65.41) 51.54,65.4 C244.1 ; v2(86.13,52.54) 86.71,51.95 C300.1 ; C299.2 v1(53.02,53.33) ; C224.2 v1(51.62,68.31) ; v1(29.5,46.6) 29.64,46.46 C324.1 ; C297.1 54.42,53.5 54.04,53.88 v2(54.04,54.47) ; C265.1 86.73,56.93 v2(87.16,56.5) ; C228.2 51.52,67.04 v1(51.53,67.03) ; v2(83,56.48) 83.46,56.95 C271.2 ; v2(51.62,60.82) 51.75,60.69 C257.2 ; C223.2 v1(53.66,68.19) ; C259.2 v2(56.96,60.82) ; R182.2 85.26,55.17 85.26,54.57 v2(85.33,54.49) ; C291.1 86.93,53.93 v2(87.19,53.67) 87.24,53.67 87.37,53.81 C287.1
  TOP w0.508: C219.1 54.83,70 54.54,69.71 v1(54.29,69.71) ; v1(44.62,31.79) 44.62,31.42 44.61,31.41 C379.1 ; v1(56.45,69.71) C218.1
  BOTTOM w0.203: v1(72.07,52.18) 72.22,52.18 72.6,51.8 R578.2
  BOTTOM w0.254: v1(51.62,68.31) 51.48,68.46 CN5.112 ; CN5.117 57.13,67.21 56.37,67.96 v1(56.37,68.08) ; U30.AF26 82.91,54.39 v2(82.91,54.49) 83.31,54.89 U30.AE25 ; U30.AL23 84.91,50.09 v2(85.31,50.49) 85.7,50.89 U30.AK22 ; v2(56.08,58.22) 56.58,57.72 57.2,57.72 57.21,57.71 CN5.147 ; CN5.159 59.52,54.71 v1(59.75,54.47) ; CN5.111 59.49,68.71 59.75,68.44 v1(59.75,68.19) ; v2(53.52,55.99) 52.05,57.46 CN5.148 ; U30.AM25 83.72,49.4 v2(83.72,49.46) ; v2(57.08,55.96) 57.33,56.21 CN5.153 ; v2(51.62,60.82) 51.49,60.96 CN5.142 ; v2(85.27,48.44) 85.27,48.56 85.7,48.99 U30.AM22 ; v1(51.53,67.03) 51.45,66.96 CN5.118 ; v1(53.02,53.33) 51.89,54.46 CN5.160 ; v2(80.56,52.99) U30.AG28 ; v2(80.56,52.99) 80.56,53.06 80.91,53.41 80.91,53.79 U30.AF28 80.82,54.27 80.82,54.67 80.57,54.91 80.57,54.99 80.55,55.01 ; v2(80.56,52.99) 80.56,52.93 80.91,52.58 80.91,52.19 U30.AJ28 80.91,51.79 80.91,51.41 80.56,51.06 80.56,51.03 v2(80.53,51.01) 80.56,51.01 80.57,50.99 U30.AK28 81.1,50.85 80.93,50.67 80.93,50.17 U30.AL28 80.93,49.81 80.93,49.45 80.5,49.03 v2(80.5,48.99) U30.AM28 U30.AN28 80.95,47.84 80.95,47.14 U30.AP28 ; v2(80.9,56.49) 80.9,56.29 81.1,56.08 U30.AD28 U30.AE28 80.72,54.99 80.7,55.01 80.55,55.01 ; v1(55.43,67.07) 55.43,66.92 56.45,65.9 57.09,65.9 57.28,65.71 CN5.123 ; U30.AC28 81.49,56.61 v2(81.49,56.49) ; CN5.136 49.2,62.46 48.83,62.09 ; v2(80.52,55.01) 80.55,55.01 ; v2(78.03,48.31) 78.03,48.26 78.3,47.99 U30.AN32 ; v2(84.41,52.48) 84.47,52.48 84.91,52.04 U30.AJ23 84.91,51.93 v2(84.48,51.51) ; v2(56.32,63.57) 56.32,63.7 56.83,64.21 CN5.129 ; CN5.130 51.98,63.96 v2(52.41,63.53) ; U30.AL32 78.99,50.2 78.51,50.2 78.41,50.3 v2(78.41,50.3) ; U30.AF23 84.91,54.06 v2(85.33,54.49) 85.7,54.86 U30.AE22 ; v2(78.57,56.07) 78.65,55.99 U30.AD32 ; CN5.141 57.34,61.21 v2(56.96,60.82) ; U30.AG25 82.98,52.67 82.98,52.52 v2(82.96,52.49) 82.51,52.04 U30.AJ26 ; U30.AD23 84.41,55.5 v2(84.39,55.5) ; U30.AL26 82.51,50.09 v2(82.91,50.49) 83.31,50.89 U30.AK25 ; v2(51.56,65.41) 51.51,65.46 CN5.124 ; v1(59.75,62.71) CN5.135 ; v2(51.55,55.94) 51.53,55.96 CN5.154 ; v1(60.51,54.47) 59.75,53.71 CN5.163 ; U30.AG22 85.7,52.96 v2(86.13,52.54) 86.15,52.52 86.95,52.52 87.68,51.79 U30.AJ20 ; U30.AD26 v2(83,56.48)
  BOTTOM w0.3: v2(87.18,55.26) 87.31,55.26 87.58,54.99 U30.AE20 ; U30.AF32 79.2,53.99 78.67,53.99 v2(78.59,54.08) ; v2(87.16,56.5) 87.31,56.5 87.4,56.59 U30.AC20 ; U30.AJ32 78.63,51.99 v2(78.55,52.07) ; v2(78.67,46.06) 79.13,46.06 U30.AR32
  BOTTOM w0.305: U30.AG20 87.58,53.39 87.29,53.67 v2(87.19,53.67) ; U30.AN21 86.51,48.3 86.69,48.49 v2(86.7,48.49)
  BOTTOM w0.508: v1(65.09,83.23) PQ26.3
  vias: v1(40.09,66.79) v1(41.34,60.92) v1(41.84,63.59) v1(41.97,60.92) v1(42.61,63.59) v1(42.61,60.92) v1(42.73,64.88) v1(42.67,53.31) v1(43.24,66.41) v1(43.24,63.59) v1(43.24,60.92) v1(43.3,53.31) v1(43.88,63.59) v1(43.94,53.31) v1(44,60.92) v1(44.13,67.91) v1(44.13,66.41) v1(44.13,64.88) v1(44.51,67.04) v1(44.51,63.59) v1(44.57,53.31) v1(44.75,90.47) v1(44.77,67.93) v1(44.77,64.88) v1(44.77,60.92) v1(45.21,53.31) v1(45.27,67.04) v1(45.38,90.47) v1(45.4,64.88) v1(45.53,60.92) v1(45.65,67.91) v1(45.65,66.41) v1(46.02,90.47) v1(46.04,67.04) v1(46.04,64.88) v1(46.29,60.92) v1(46.42,67.91) v1(46.42,66.41) v1(46.65,90.47) v1(46.8,67.04) v1(47.05,60.92) v1(47.94,67.91) v1(47.94,66.79) v1(48.32,80.89) v1(48.32,80.07) v1(48.58,86.44) v1(48.58,85.62) v1(48.58,84.82) v1(48.58,44.94) v1(48.83,47.71) v1(48.83,46.19) v1(48.83,42.47) v1(48.96,80.89) v1(48.96,80.07) v1(48.96,53.33) v1(48.96,33.21) v1(50.4,34.83) v1(60.39,66.28) v1(60.51,118.76) v1(60.77,50.66) v1(61.63,65.37) v1(61.66,66.28) v1(61.78,50.66) v1(62.8,50.66) v1(63.05,64.88) v1(63.43,57.9) v1(63.46,56.5) v1(63.56,50.66) v1(63.69,64.88) v1(64.73,60.57) v1(64.7,57.9) v1(64.86,65.01) v1(65.72,48.63) v1(66.86,48.63) v1(68.11,48.88) v1(69.02,48.63) v1(69.66,48.63) v2(54.75,60.82) v2(70.55,56.12) v2(70.67,57.72) v2(72.07,55.26) v2(72.96,54.34) v2(73.47,48.3) v2(74.63,48.31) v2(75.12,54.47) v2(75.12,53.45) v2(75.77,48.31) v2(76.81,52.07) v2(76.89,48.31) v2(82.17,51.49) v3(23.4,94.86) v3(23.4,94.09) v3(24.14,95.62) v3(24.14,94.86) v3(24.14,94.09) v3(24.9,95.62) v3(24.9,94.86) v3(24.9,94.09) v3(50.94,115.4) v3(51.34,114.77) v3(51.5,112.13) v3(52.26,112.13) v3(53.02,112.13) v3(54.16,122.54) v3(54.16,121.78) v3(54.16,114.18) v3(54.27,113.42) v3(54.93,122.54) v3(54.93,121.78) v3(54.93,114.18) v3(55.69,122.54) v3(55.69,121.78) v3(56.45,122.54) v3(56.45,121.78)
+1.5V: length 8.8
  TOP w0.508: 196.78,18.69 200.27,18.69 v1(200.47,18.88) 201.23,18.88 201.79,18.33 201.79,17.46 202.41,16.84 R370.1
  vias: v1(193.56,21.55)
+1.05V_LAN: length 5.8
  TOP w0.203: U2.22 48.49,106 49.29,106.79 49.85,106.79 ; v1(43.66,108.53) 43.66,108.73 43.85,108.92 C48.2 44.13,108.8 44.13,108.19 44.04,108.1 U2.30
  vias: v1(38.26,105.27) v1(41.77,102.75) v1(42.28,103.16) v1(52.31,109.03) v1(52.31,108.39)
+1.05V_LAN_REGOUT:
  vias: v1(47.36,108.44)
+1.8V: length 444.9
  TOP w0.203: R206.2 R203.2 118.09,46.98 118.6,46.47 120.2,46.47 120.66,46.01 120.66,41.97 120.46,41.77 120.46,40.8 120.58,40.68 120.58,39.74 118.68,37.83 118.68,37.35 118.02,36.69 114.86,36.69 114.35,37.2 112.86,37.2 v1(111.64,35.98)
  TOP w0.305: R163.2 97.72,78.74 R151.2 ; v1(204.74,18.02) 204.78,18.02 R354.1 ; R151.2 97.72,79.22 98,79.51 98.84,79.51 99.25,79.11 99.71,79.11 100.06,78.75 100.06,77.15 100.76,76.45 R167.2 R168.2 ; R151.2 97.51,78.98 96.22,80.28 93.15,80.28 92.37,79.49 90.64,79.49 90,78.85 88.58,78.85 87.69,79.74 v1(87.69,80)
  TOP w0.381: R312.2 132.39,24.51 v1(132.9,23.99) 133.11,23.79 133.11,21.2 132.52,20.61 132.52,19.15 R356.1 ; v1(197.55,25.71) 197.41,25.85 R292.2 ; v1(87.69,80) 86.42,81.27 86.04,81.27 85.56,81.75 85.56,83.27 v1(85.28,83.55) 85.28,83.43 84.8,82.94 84.34,82.94 82.99,84.29 82.99,86.02 v1(82.41,86.6) 81.9,87.11 74.23,87.11 73.34,86.22 69.78,86.22 67.75,88.25 60.89,88.25 60.01,89.14 59.37,89.14 57.85,90.66 51.5,90.66 49.34,92.82 49.34,93.2 46.67,95.87 28,95.87 27.62,96.25 22.67,96.25 21.78,95.36 21.78,93.08 19.87,91.17 v1(19.87,90.41)
  TOP w0.508: v1(115.63,22.72) 115.63,24.12 116.9,25.39 118.3,25.39 119.6,26.69 123.48,26.69 123.76,26.4 125.39,26.4 125.77,26.02 131.63,26.02 132.14,25.51 R312.2 ; v1(98.74,24.24) 99.25,24.75 99.25,29.22 98.99,29.47 98.99,30.06 v1(98.74,30.31)
  IN1 w0.381: v1(18.97,83.79) 17.97,84.79 17.97,87.24 16.95,88.25 16.95,89.65 17.71,90.41 v1(19.87,90.41)
  IN1 w0.508: v1(111.64,35.98) 111.31,35.65 111.31,31.1 v1(111.69,30.72) 111.44,30.72 110.93,30.21 110.93,25.64 111.31,25.26 113.09,25.26 v1(115.63,22.72)
  IN2 w0.381: v1(132.9,23.99) 133,24.08 139.82,24.08 140.61,24.88 142.05,24.88 143.74,26.57 153.24,26.57 154.39,27.72 156.17,27.72 157.24,26.65 157.24,26.32 157.97,25.59 161.81,25.59 162.39,26.17 164.77,26.17 165.19,26.59 167.66,26.59 168.66,27.59 170.61,27.59 171.42,26.78 175.07,26.78 175.89,27.6 182.62,27.6 183.7,28.69 185.91,28.69 187.82,26.78 188.78,26.78 190.82,24.75 192.72,24.75 v1(193.36,24.12) 193.36,22.43 197.13,18.66 199.45,18.66 199.71,18.4 200.59,18.4 201.73,17.27 203.99,17.27 v1(204.74,18.02) ; v1(143.62,37.2) 138.75,37.2 138.24,36.69 135.57,36.69 135.32,36.44 135.32,35.67 134.3,34.66 131.89,34.66 131.38,34.15 128.84,34.15 128.2,34.78 115.63,34.78 114.87,35.55 114.87,35.93 113.57,37.22 112.89,37.22 v1(111.64,35.98)
  IN2 w0.508: v1(111.69,30.72) 111.06,30.09 111.06,29.83 110.34,29.12 105.42,29.12 105.32,29.22 100.11,29.22 99.02,30.31 v1(98.74,30.31) ; v1(26.63,36.36) 26.63,56.31 26.22,56.72 26.22,71.97 26.38,72.12 26.38,79.72 22.92,83.17 22.69,83.17 21.8,84.06 19.24,84.06 v1(18.97,83.79) ; v1(77.13,25.34) v1(77.76,25.34) 86.63,25.34 87.39,26.1 91.91,26.1 94.27,23.74 98.23,23.74 v1(98.74,24.24)
  IN3 w0.381: v1(150.19,59.36) 150.68,58.86 150.68,56.37 150.33,56.02 150.33,54.75 151.09,53.99 151.09,53.13 152.59,51.63 152.59,49.86 151.21,48.49 150.72,48.49 150.13,47.89 149.16,47.89 147.84,46.57 147.84,44.84 148.63,44.06 148.63,41.41 149.29,40.75 149.29,39.53 148.73,38.98 146.95,38.98 145.81,37.83 144.26,37.83 v1(143.62,37.2)
  IN3 w0.508: v1(197.55,25.71) 197.22,25.39 195.51,25.39 194.24,24.12 v1(193.36,24.12)
  BOTTOM w0.178: R556.1 v1(87.69,80)
  BOTTOM w0.203: R653.1 98.46,30.6 v1(98.74,30.31) ; v1(150.19,59.36) 150.19,57.89 151.06,57.01 PR258.1 ; R660.2 84.93,27.32 84.64,27.04 84.64,25.01 84.52,24.88 84.01,24.88
  BOTTOM w0.381: v1(204.74,18.02) 204.74,17.87 205.2,17.4 R699.1 ; PR213.1 82.22,87.36 82.41,87.17 v1(82.41,86.6) ; PR256.1 149.94,59.36 149.94,59.36 v1(150.19,59.36)
  vias: v1(13.78,20.2) v1(14.41,20.2) v1(26.6,35.67) v1(26.6,35.04) v1(27.29,35.7) v1(27.29,35.06) v1(27.57,36.54)
+1.8V_GFX: length 124.8
  TOP w0.203: R1.1 119.49,125.46 v1(119.24,125.21) ; R23.1 v1(123.25,121.73) ; v1(120.97,124.27) 120.84,124.14 R10.1 ; v1(120.08,123.18) 119.85,122.95 R20.1
  IN1 w0.254: v1(106.59,100.27) 107.3,100.27 107.83,100.8 107.83,103.69 107.96,103.82 107.96,108.39 108.72,109.16 108.72,110.98 109.08,111.34 109.43,111.34 110.86,112.76 110.86,113.47 111.36,113.98 113.14,113.98 116.19,117.03 116.65,117.03 118.88,119.26 119.65,119.26 v1(120.03,119.65)
  IN1 w0.508: v1(101.53,120.13) 101.15,120.13 101.03,120.26 100.16,120.26 99.19,119.28 95.61,119.28 94.55,118.22 92.89,118.22 90.46,120.66 85.74,120.66 84.98,119.89 79.16,119.89 76.8,122.26 72.75,122.26 72.58,122.09 v1(71.97,122.09) ; v1(97.78,112.51) 97.78,111.95 96.74,110.92 96.74,105.02 v1(95.85,104.13) 96.2,104.13 96.73,103.59 96.73,100.38 96,99.65 96,96.81 v1(95.38,96.19)
  IN2 w0.508: v1(101.53,120.13) 102.3,120.89 105.47,120.89 105.85,120.51 106.47,120.51 107.3,121.34 107.3,121.71 107.78,122.19 110.78,122.19 111.89,121.08 113.16,121.08 113.6,121.53 113.6,124.32 114.11,124.83 117.03,124.83
  BOTTOM w0.203: FB1.2 102.91,121.17 102.37,120.63 C540.1 ; R523.1 95.34,96.22 v1(95.38,96.19) ; v1(120.03,119.65) 119.92,119.75 R473.1 ; R478.2 101.86,119.01 101.53,119.34 v1(101.53,120.13) ; R477.1 124.62,119.73 v1(123.25,121.09) 122.57,121.09 121.32,119.85 R476.1 ; R471.1 117.26,119.75 v1(117.28,119.77) 117.31,119.75 R472.1 ; R453.1 117.41,121.27 v1(117.28,121.4) 117.16,121.27 R452.1 ; R454.1 119.54,122.64 v1(120.08,123.18) ; R522.1 94.2,96.35 v1(94.3,96.25) ; v1(71.97,122.09) 71.79,121.91 71.79,121.55 71.52,121.28 70.07,121.28 69.6,120.81 PR137.2
  BOTTOM w0.305: v1(71.97,122.09) 72.39,122.51 73.03,122.51 PR131.1
  BOTTOM w0.381: R512.1 96.32,103.65 v1(95.85,104.13) 96.32,104.6 R507.1 ; v1(97.78,112.51) R498.1 97.1,111.88 97.15,111.83 R499.1 ; C540.1 102.03,120.63 v1(101.53,120.13) 101.2,120.13 101.03,119.95 C541.1
  vias: v1(99.43,94.25) v1(99.38,93.18) v1(99.76,93.69) v1(102.55,89.01) v1(103.19,89.01) v1(104.46,98.13) v1(104.76,100.93) v1(105.5,100.93)
+1.8V_GFX_PG: length 99.4
  TOP w0.102: v2(88.43,116.88) 88.51,116.96 PR17.2
  IN1 w0.089: v2(75.2,120.99) 74.93,121.26 70.53,121.26 67.5,118.23 67.5,109.59 71.31,105.78 72.27,105.78 74.31,103.75 74.31,99.99 79.59,94.7 84.8,94.7 v1(91.12,88.38)
  IN2 w0.089: v1(113.98,88.51) 113.09,87.62 110.93,87.62 108.86,85.54 95.61,85.54 94.04,87.11 92.39,87.11 v1(91.12,88.38)
  IN3 w0.089: v2(75.2,120.99) 75.47,121.27 76.95,121.27 77.58,120.64 77.58,119.37 77.94,119.01 79.44,119.01 81.57,116.88 v2(88.43,116.88)
  BOTTOM w0.102: PR216.1 v1(113.98,88.51)
  BOTTOM w0.152: PR135.1 74.65,120.75 74.89,120.99 v2(75.2,120.99)
  BOTTOM w0.254: v1(91.12,88.38) 93.97,88.38 v1(94.52,88.94)
+1.8V_S5: length 316.2
  TOP w0.102: v1(159.45,33.51) 159.22,33.74 TP76.1
  TOP w0.203: R194.2 R197.2 118.35,47.97 118.37,47.99 119.31,47.99 119.44,47.87 v1(119.82,47.87) ; v1(121.45,49.31) 121.45,49.33 121.42,49.36 121.38,49.36 121.12,49.61 C313.1 120.49,49.61 120.44,49.66 U8.6 ; v1(116.01,43.8) 115.63,43.8 115.02,44.41 114.62,44.41 R215.1 ; v1(84.64,80.5) 84.77,80.63 v1(85.99,80.63)
  TOP w0.254: v1(162.15,30.21) 162.11,30.18 R667.1
  TOP w0.305: v1(111.57,41.64) 112.24,41.64 R223.1
  TOP w0.381: R343.1 131.89,20.94 v1(132.27,21.32) 132.27,21.69 R323.2 ; v1(202.75,19.09) 203.18,19.09 R353.2 ; v1(175.84,33.02) 175.84,32.71 175.7,32.57 R264.1 ; R320.2 199.87,23.49 v1(199.96,23.4) ; v1(198.56,29.53) 198.5,29.46 R278.2
  IN1 w0.254: v1(159.45,33.51) 161.1,33.51 162.15,32.47 v1(162.15,30.21)
  IN1 w0.381: v1(182.21,31.71) 182.61,32.12 185.1,32.12 186.52,30.69 189.21,30.69 191.1,32.58 192.41,32.58 193.21,31.79 196.3,31.79 v1(198.56,29.53)
  IN1 w0.508: v1(159.45,33.51) 159.75,33.82 159.75,36.05 160.23,36.54 160.72,36.54 161.35,37.17 161.73,37.17 162.32,37.76 166.48,37.76 168.13,36.1 169.43,36.1 170.67,34.86 172.25,34.86 173.16,33.95 174.92,33.95 v1(175.84,33.02)
  IN2 w0.203: v1(159.45,33.51) 166.03,33.51 166.2,33.34 167.42,33.34 167.83,32.93 v1(167.83,32.88)
  IN2 w0.381: v1(126.17,48.12) 127.95,46.34 138.24,46.34 143.19,41.39 146.37,41.39 146.75,41.77 148.37,41.77 151.62,38.52 153.2,38.52 155.87,35.85 159.68,35.85 159.95,36.13 161.86,36.13 162.61,35.38 162.97,35.38 163.71,36.13 166.38,36.13 166.74,36.49 167.4,36.49 167.93,35.95 168.95,35.95 170.62,34.28 172.17,34.28 172.93,33.51 174.18,33.51 174.67,33.02 v1(175.84,33.02) ; v1(28.38,28.82) 28.38,29.7 28.89,30.21 28.89,31.61 28.51,31.99 28.51,35.29 27.62,36.18 27.62,87.36 34.61,94.35 44.38,94.35 45.27,95.24 46.8,95.24 48.32,96.76 49.85,96.76 51.88,98.79 58.46,98.79 61.63,95.62 63.43,95.62 65.72,93.33 66.99,93.33 68.39,91.93 68.39,90.79 70.42,88.76 78.17,88.76 83.25,83.68 83.25,82.41 84.64,81.01 v1(84.64,80.5)
  IN2 w0.508: v1(198.56,29.53) 198.74,29.53 199.45,28.82 199.45,23.91 v1(199.96,23.4) 199.5,23.4 199.2,23.1 199.2,22.19 199.58,21.8 200.49,21.8 202.75,19.54 v1(202.75,19.09) ; v1(116.01,43.8) 115.76,43.8 113.47,41.52 111.69,41.52 v1(111.57,41.64)
  IN3 w0.381: v1(182.21,31.71) 181.67,32.24 176.31,32.24 175.84,32.71 v1(175.84,33.02) ; v1(111.57,41.64) 111.57,41.52 111.14,41.08 109.21,41.08 108.72,41.57 108.72,42.23 v2(108.16,42.79)
  BOTTOM w0.203: R549.1 R550.1 84.77,80.38 v1(84.64,80.5) ; R598.2 111.09,41.36 111.36,41.64 v1(111.57,41.64) ; v2(100.67,35.24) 100.65,35.27 R625.2 ; R551.1 85.91,80.55 v1(85.99,80.63) ; R597.1 107.78,42.4 v2(108.16,42.79) 107.78,43.17 R595.1 ; R650.1 98.46,32.02 98.24,32.24 98.24,35.11 v2(98.11,35.24) 98.13,35.27 R623.2 ; R675.1 167.32,33.64 167.83,33.13 v1(167.83,32.88)
  BOTTOM w0.381: v1(132.27,21.32) 131.76,21.83 129.6,21.83 126.05,25.39 v1(126.05,26.66) ; CN7.1 119.06,51.17 120.87,49.36 121.42,49.36 121.45,49.33 v1(121.45,49.31) ; CN7.19 119.31,39.74 v1(119.82,40.25)
  vias: v1(29.02,28.82) v1(29.3,31.13) v1(29.65,28.82) v1(85.25,26.83) v1(85.89,26.83) v2(100.67,34.66)
+1.8V_S5_1V8: length 1.3
  BOTTOM w0.102: R649.2 R650.2 R653.2
+1.8V_SW: length 16.2
  IN1 w0.508: v1(12.03,20.69) 12.15,20.81 14.92,20.81 15.25,20.48 16.65,20.48 17.59,19.54 17.59,18.91 19.06,17.44 19.95,17.44 21.68,15.71 22.26,15.71 v1(22.29,15.73)
  BOTTOM w0.203: U39.3 16.57,14.43 16.09,13.95 v1(16.09,13.55)
  BOTTOM w0.508: R710.2 21.77,15.61 22.16,15.61 v1(22.29,15.73) ; R714.2 14.5,14.96 v1(14.67,14.79)
  vias: v1(11.31,20.41) v1(11.31,19.77) v1(12.03,20.05) v1(12.81,20.61) v1(16.04,12.91)
+1.35V_GFX: length 40.5
  TOP w0.102: C86.1 133.28,104.5 133.47,104.69 v1(133.47,105.03)
  TOP w0.178: v1(135.21,104.85) 135.06,104.7 C88.1
  TOP w0.203: C140.1 134.22,93.59 v1(134.39,93.42) ; C5.1 v1(135.06,119.11) ; C124.1 116.75,97.14 v1(116.9,97.29) ; R125.1 142.81,85.33 142.94,85.2 ; v1(118.43,107.63) 118.42,107.63 118.42,107.59 C60.1 ; v1(109.28,97.32) 109.43,97.17 C122.1 ; C123.1 111.39,97.17 v1(111.49,97.27) ; C119.1 117.76,98.69 v1(117.61,98.84) 118.04,99.27 R90.1 ; v1(118.3,97.65) 118.2,97.55 C126.1 ; v1(117.97,110.1) 117.97,110.65 C36.1 ; C4.1 v1(133.89,119.11) ; R102.1 113.6,97.01 113.32,97.3 C120.1 112.5,97.3 v1(112.48,97.32) ; v1(108.11,97.27) 108.21,97.17 C121.1 ; C88.1 C87.1 ; C82.1 118.96,104.99 118.53,105.42 v1(118.45,105.42) ; C3.1 v1(133.03,119.11)
  TOP w0.508: v1(118.43,107.63) 118.41,107.65 118.41,107.79 119.1,108.49 C50.2 117.97,109.76 v1(117.97,110.1) ; C95.2 119.1,102.89 v1(118.38,102.16) ; PR26.1 149.15,72.62 149.67,73.14 149.67,77.08 148.78,77.96
  BOTTOM w0.305: VRAM2.N10 v1(143.98,86.19) VRAM2.P11 VRAM2.P12 ; VRAM2.N5 v1(143.98,90.99) ; v1(109.28,97.32) 108.88,97.72 U25.AG10 108.57,97.72 v1(108.11,97.27) ; VRAM2.R5 v1(145.57,90.21) ; VRAM1.B3 v1(146.38,106.98) ; VRAM2.P3 v1(144.78,92.59) ; VRAM1.B12 v1(146.38,114.98)
  BOTTOM w0.381: U25.K27 118.41,107.43 118.41,107.61 v1(118.43,107.63) ; U25.K23 118,104.97 v1(118.45,105.42) ; U25.L10 117.07,97.29 v1(116.9,97.29) 116.83,97.29 U25.N10 ; v1(117.61,98.84) 117.62,98.84 118,99.22 U25.K13 ; U25.AC10 111.36,97.27 v1(111.49,97.27) ; U25.K19 118,102.53 v1(118.38,102.16) ; U25.K31 118.02,109.24 118.02,110.04 v1(117.97,110.1) ; v1(118.3,97.65) 118,97.94 U25.K11 ; v1(112.48,97.32) 112.89,97.72 U25.W10
  vias: v1(135.24,112.54) v1(136.6,82.64) v1(136.85,112.51) v1(138.03,82.65) v1(138.24,80.12) v1(138.26,79.49) v1(138.84,82.66) v1(138.87,80.12) v1(138.9,79.49) v1(141.58,114.18) v1(142.33,90.99) v1(142.37,107.79) v1(142.43,105.14) v1(142.41,94.31) v1(142.38,93.39) v1(142.36,82.81) v1(142.62,117.09) v1(142.56,98.68) v1(143.19,84.61) v1(143.98,114.18) v1(143.98,107.02) v1(144.06,109.68) v1(144.08,82.66) v1(144.11,81.14) v1(144.24,88.55) v1(144.34,94.64) v1(144.74,81.14) v1(144.78,112.29) v1(145.1,104) v1(145.61,109.41) v1(145.58,92.59) v1(145.58,84.59) v1(146.17,88.55) v1(146.38,110) v1(146.52,82.85) v1(146.98,95.23) v1(147.31,114.94) v1(147.51,100.19) v1(147.51,99.55) v1(147.51,98.92) v1(147.89,109.05) v1(148.14,100.19) v1(148.14,99.55) v1(148.14,98.92) v1(148.65,115.38)
