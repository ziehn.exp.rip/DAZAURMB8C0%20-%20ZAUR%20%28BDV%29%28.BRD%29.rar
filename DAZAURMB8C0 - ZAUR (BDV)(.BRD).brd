# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N48094152: length 2.1
  TOP w0.102: PU6.5 195.26,29.52 v1(195.51,29.78) 195.36,29.93 PR79.2
N48094169: length 4.3
  BOTTOM w0.102: v1(80.46,90.44) PR213.2
  BOTTOM w0.508: PQ20.3 77.97,88.63 79.49,88.63 80,89.14 PR213.2
N48094182: length 2.7
  BOTTOM w0.102: v1(64.96,85.81) PR219.2
  BOTTOM w0.508: PR219.2 63.32,86.86 PQ23.3
N48094185: length 3.9
  BOTTOM w0.102: v1(62.6,92.96) PR204.2
  BOTTOM w0.508: PR204.2 PQ19.3
N48094210: length 3.2
  TOP w0.102: v1(128.32,39.27) PR58.2
  TOP w0.254: PQ6.3 131.19,39.86 130.6,39.27 PR58.2
N48095830: length 2.7
  BOTTOM w0.254: PR148.1 69.51,118.78 69.51,119.94 PR137.1 69.86,120.03 70.54,120.71 PR136.1
N48547452: length 2.8
  BOTTOM w0.102: PQ25.3 72.39,83.95 v1(72.86,83.48)
  BOTTOM w0.508: PQ25.3 PR226.2
N48583626: length 0.9
  BOTTOM w0.102: PR303.2 TP63.1
N48758839: length 1.4
  BOTTOM w0.533: PR242.2 141.82,68.56 PC208.1
N48758857: length 2.3
  BOTTOM w0.102: v1(150.23,68.41) PR243.1
  BOTTOM w0.254: PC205.2 149.48,68.65 PR243.1
N48838349:
  vias: v1(119.82,86.24)
N48838408: length 4
  BOTTOM w0.102: v1(107.66,88.15) 107,87.49 PR220.1 PR223.1 107.26,86.09 PU9.7
N48838426: length 4.7
  BOTTOM w0.102: PU9.1 114.26,87.36 v1(113.09,88.53)
  BOTTOM w0.381: PR217.1 PR216.2 115.39,88.13 114.97,87.72 PU9.1
N48839459: length 104.6
  IN2 w0.089: v1(131,122.29) 132.21,121.08 138.95,121.08 140.73,119.3 144.52,119.3 144.91,118.92 146.83,118.92 149.22,116.52 149.22,79.55 v1(149.67,79.11)
  IN3 w0.089: v1(149.67,79.11) 148.73,78.17 142.94,78.17 142.63,78.47 138.62,78.47 137.91,79.18 124.46,79.18 123.86,79.78 121.55,79.78 120.62,80.71 119.24,80.71 117.54,82.41 116.01,82.41 115.23,83.19 v1(113.07,83.19)
  BOTTOM w0.102: v1(130.68,124.09) PQ13.2 130.68,122.6 v1(131,122.29) ; v1(113.07,83.19) PR227.2 PR228.1 112.85,81.02 112.38,80.55 PQ29.3
N48839476: length 3.9
  BOTTOM w0.102: v1(132.52,120.69) 132.05,121.16 PQ13.3 130.22,121.16 130.1,121.28 PR129.2
N48839503: length 2.6
  BOTTOM w0.102: PQ29.2 113.86,78.11 114.13,77.84 v1(114.13,77.18) 113.91,76.96 PR236.2
N48839793: length 10.9
  TOP w0.102: PQ5.3 147.27,68.59 147.51,68.35 v1(147.51,67.02)
  TOP w0.254: PQ5.3 147.27,70.33 146.37,71.23 144.64,71.23 PQ4.2 143.87,70.51 PR27.1 142.17,69.67 PR28.2
N48839805: length 3.8
  TOP w0.102: PQ4.3 144.46,72.49 v1(144,72.95)
  TOP w0.254: PR26.2 146.11,72 145.62,72.49 PQ4.3
N48839825: length 2.1
  TOP w0.254: PQ5.2 149.27,67.59 149.29,67.57 v1(149.29,66.96) PR29.2
N48842289:
  vias: v1(91.86,90.49)
N48842319:
  vias: v1(93.25,93.18) v1(93.91,93.38) v1(93.91,92.75)
N48842333: length 2.6
  BOTTOM w0.102: PQ22.2 v1(94.54,87.38) 95.67,87.38 PR221.2
N48844175: length 17
  TOP w0.102: PR3.1 PR2.2 133.69,120.41 v1(133.11,119.82) 132.63,119.35 PQ2.2 131.82,120.19 v1(131.89,120.26)
  BOTTOM w0.102: PQ12.3 135.55,121.92 135.06,122.41 133.92,122.41 133.11,121.6 133.11,120.26 132.88,120.03 132.45,120.03 132.22,120.26 v1(131.89,120.26) 131.89,119.62 131,118.73 129.98,118.73 129.36,119.35 PQ15.2
N48844187: length 4.6
  BOTTOM w0.102: PQ15.3 129.11,117.35 128.64,116.88 v1(128.08,116.88) 128.08,118.35 127.69,118.74 PR141.2
N48844204: length 2
  BOTTOM w0.102: PQ12.2 136.15,124.63 136.09,124.69 PR119.2 v1(136.94,125.08)
N48844243: length 3.7
  TOP w0.102: PR9.2 v1(128.69,117.34) 129.73,117.34 129.74,117.35 PQ2.3
N424048290: length 2.2
  BOTTOM w0.102: CN5.165 60.63,53.21 TP58.1
N424048650: length 3
  TOP w0.102: TP20.1 52.26,53.91 v1(52.26,53.33)
  BOTTOM w0.102: CN5.162 51.63,53.96 v1(52.26,53.33)

## Copper pours and planes (outline as drawn)
+0.75V on TOP (solid shape): outline of 645 points within 88.95,65.25 95.05,79.87
+0.75V on BOTTOM (solid shape): 94.8,82.16 94.8,79.36 95.09,79.08 95.09,77.31 94.96,77.18 94.69,77.07 94.57,76.8 94.58,76.73 94.56,76.65 94.48,76.62 92.68,76.62 92.36,76.94 92.36,82.12 92.52,82.28 94.68,82.28
+0.75V on BOTTOM (solid shape): 90.24,66.64 90.25,66.63 90.51,66.48 90.76,66.63 90.78,66.64 90.81,66.65 91.22,66.65 91.24,66.64 91.25,66.63 91.36,66.52 91.51,66.48 91.54,66.48 91.75,66.27 91.75,65.63 91.37,65.25 89.59,65.25 89.33,65.51 89.33,65.61 89.32,65.65 89.31,65.69 89.31,65.99 89.32,66.03 89.33,66.08 89.33,66.27 89.55,66.49 89.57,66.49 89.68,66.54 89.76,66.63 89.78,66.64 89.81,66.65 90.22,66.65
+0.75V_S5 on TOP (solid shape): outline of 464 points within 91.76,26.66 96.68,49.95
+0.75V_S5 on BOTTOM (solid shape): outline of 254 points within 91.71,48.3 95.51,50.55
+1.2V on TOP (solid shape): 24.6,76.79 24.64,76.72 24.7,76.66 24.7,75.85 24.66,75.8 24.53,75.77 24.43,75.69 24.34,75.56 24.32,75.4 24.32,73.52 24.06,73.27 23.56,73.27 23.43,73.39 23.43,73.9 23.68,74.15 23.68,76.16 23.71,76.23 23.78,76.26 23.93,76.29 24.06,76.37 24.06,76.69 24.19,76.82 24.57,76.82
+1.2V on IN2 (solid shape): outline of 699 points within 16.26,72.25 24.7,82.16
+1.2VSUS on TOP (solid shape): 52.67,63.59 52.67,63.3 52.48,63.11 52.13,63.11 51.75,63.49 50.69,63.49 50.56,63.61 50.56,63.89 50.68,64 52.26,64
+1.2VSUS on TOP (solid shape): 47.32,91.41 47.32,90.69 46.8,90.17 44.65,90.17 44.47,90.35 44.47,90.57 44.8,90.91 44.8,91.43 44.88,91.52 47.21,91.52
+1.2VSUS on TOP (solid shape): 61.66,66.79 61.66,66.66 62.29,66.03 65.34,66.03 65.85,65.52 65.85,64.63 65.47,64.25 62.04,64.25 60.01,66.28 60.01,66.79 60.18,66.96 61.49,66.96
+1.2VSUS on TOP (solid shape): 69.34,48.91 69.35,48.88 69.34,48.84 69.29,48.74 69.28,48.63 69.39,48.36 69.66,48.25 69.77,48.26 69.87,48.31 69.91,48.32 69.94,48.31 70.16,48.09 70.17,48.07 70.17,48.01 70.17,47.73 70.17,47.7 70.18,47.68 70.17,47.63 70.13,47.61 65.47,47.61 65.34,47.74 65.34,48.53 64.91,48.96 62.72,48.96 62.37,49.31 62.37,49.4 62.23,49.54 62.22,49.56 62.19,49.61 62.14,49.64 62.13,49.65 62.07,49.71 61.5,49.71 61.44,49.64 60.67,49.64 60.49,49.82 60.49,50.79 60.59,50.89 67.35,50.89
+1.2VSUS on TOP (solid shape): 52.96,125.21 53.61,125.21 53.7,125.21 54.34,125.21 54.44,125.2 54.53,125.21 56.87,122.86 56.87,120.67 57.14,120.4 58.44,120.4 58.74,120.1 58.77,120.01 58.73,119.94 58.6,119.8 58.56,119.62 58.67,119.35 58.94,119.24 59.08,119.27 59.2,119.34 59.24,119.38 59.28,119.33 61.63,119.33 61.89,119.07 61.89,118.33 61.81,118.25 58.66,118.25 57.83,119.07 52.65,119.07 50.37,121.35 49.85,121.35 49.75,121.45 49.75,122.6 49.93,122.77 50.99,122.77 50.99,125 51.19,125.2 51.26,125.18 51.33,125.17 51.41,125.18 51.49,125.21 52.83,125.21
+1.2VSUS on TOP (solid shape): outline of 153 points within 40.19,32.17 51.14,63.23
+1.2VSUS on TOP (solid shape): outline of 660 points within 31.89,63.36 50.61,88
+1.2VSUS on BOTTOM (solid shape): 52.82,123.87 57.22,123.87 57.31,123.77 57.31,123.13 56.84,122.65 56.84,121.71 55.78,120.65 50.32,120.65 49.56,121.41 49.56,122.61 49.76,122.81 50.93,122.81 51.08,122.96 51.08,123.92 51.36,124.2 52.48,124.2
+1.2VSUS on BOTTOM (solid shape): outline of 147 points within 46.7,111.78 55.51,120.26
+1.2VSUS on BOTTOM (solid shape): outline of 14447 points within 23.05,31.05 49.2,96.13
+1.2VSUS on SGND (solid shape): outline of 126 points within 41.46,45.83 87.56,70.34
+1.2VSUS on IN2 (solid shape): outline of 1030 points within 23.08,93.71 57.34,115.08
+1.2VSUS on IN2 (solid shape): outline of 9288 points within 41.46,31.36 87.56,91.08
+1.2VSUS on SVCC (solid shape): 57.59,125.6 57.59,118.59 57.4,118.45 57.33,118.22 57.4,118 57.59,117.86 57.59,111.85 52.4,106.66 52.36,106.66 52.32,106.67 52.05,106.55 51.94,106.29 51.95,106.25 51.95,106.21 49.92,104.18 49.8,104.26 49.66,104.29 49.39,104.18 49.27,103.91 49.3,103.76 49.38,103.64 46.5,100.76 46.4,100.81 46.29,100.82 46.02,100.71 45.91,100.44 45.92,100.36 45.94,100.29 45.91,100.29 45.66,100.19 45.55,99.94 45.56,99.88 45.57,99.83 43.39,97.65 31.18,97.65 31.08,97.63 31,97.57 30.6,97.18 30.5,97.23 30.39,97.24 30.12,97.13 30.01,96.86 30.02,96.75 30.07,96.65 27.13,93.71 20.48,93.71 20.46,93.74 20.43,93.76 19.87,94.33 19.87,98.18 27.98,106.28 37.4,106.28 37.5,106.3 37.58,106.36 40.75,109.53 40.81,109.62 40.83,109.71 40.83,114.41 41.1,114.52 41.21,114.79 41.21,114.82 42.02,115.63 42.08,115.71 42.1,115.81 42.1,120.85 42.32,120.98 42.4,121.22 42.32,121.46 42.1,121.59 42.1,122.48 42.49,122.87 48.86,122.87 50.3,123.46 50.89,124.9 50.89,125.97 57.23,125.97
+1.2VSUS on SGND1 (solid shape): 85.7,59.71 85.66,59.63 85.65,59.54 85.76,59.29 86.01,59.18 86.1,59.19 86.18,59.23 87.56,57.85 87.56,51.85 87.31,51.6 87.26,51.6 87.02,51.51 86.9,51.29 83.55,51.29 83.34,51.51 83.3,51.54 83.25,51.55 83.21,51.55 83.09,51.78 82.85,51.87 82.64,51.79 82.51,51.6 82.38,51.77 82.17,51.84 81.94,51.76 81.82,51.55 81.39,51.55 81.22,51.73 81.22,53.07 81.2,53.12 81.17,53.17 80.71,53.63 80.71,54.71 80.83,54.84 80.88,55.01 80.83,55.19 80.71,55.32 80.71,56.7 80.92,56.92 80.95,56.96 80.96,57.01 80.96,59.24 81.52,59.8 85.61,59.8
+1.5V on TOP (solid shape): 195.92,23.23 195.93,23.21 195.93,22.15 197.06,21.02 197.06,17.54 196.99,17.47 196.99,16.55 196.81,16.37 194.7,16.37 194.33,16.74 194.33,20.1 192.96,21.48 192.96,22 192.72,22.24 192.72,22.97 192.72,23.18 192.75,23.21 193.17,23.21 193.19,23.21 193.23,23.23
+1.05V_LAN on TOP (solid shape): 52.66,109.02 52.66,108.5 52.45,108.29 52.45,107.04 51.65,106.23 49.71,106.23 49.61,106.33 49.61,106.82 50.12,107.33 50.12,107.37 50.12,107.38 50.12,108.23 50.16,108.27 51.6,108.27 51.85,108.52 51.85,108.97 52.12,109.24 52.43,109.24
+1.05V_LAN on TOP (solid shape): 40.65,106.18 40.75,106.18 40.76,106.17 40.93,106.13 41.1,106.17 41.11,106.18 41.96,106.18 42.04,106.1 43.02,106.1 43.03,106.09 43.03,105.91 43.02,105.9 41.88,105.9 41.73,105.75 38.95,105.75 38.77,105.57 38.77,103.39 39.18,102.98 41.03,102.98 42.01,103.97 42.01,104.06 42.05,104.1 43.03,104.1 43.08,104.05 43.08,103.88 43.05,103.86 43.01,103.86 42.68,103.53 42.68,103.2 42.44,102.96 42,102.52 41.91,102.43 41.34,102.43 40.87,101.96 40.05,101.96 39.98,102.03 38.88,102.03 38.81,101.96 38.12,101.96 37.68,102.4 37.68,106.06 37.91,106.29 39.61,106.29 39.74,106.41 40.42,106.41
+1.05V_LAN on IN1 (solid shape): outline of 396 points within 41.52,102.45 52.56,109.37
+1.05V_LAN_REGOUT on TOP (solid shape): 48.77,110.46 51.3,110.46 51.57,110.2 51.57,108.83 51.48,108.74 49.84,108.74 49.78,108.8 48.63,108.8 48.44,108.61 48.44,107.85 47.29,106.69 46.25,106.69 46.24,106.7 46.24,106.88 46.61,107.24 46.61,108 46.77,108.16 46.77,108.49 46.87,108.59 46.87,109.18 47.93,110.23 47.93,110.53 48.04,110.64 48.59,110.64
+1.8V on TOP (solid shape): 28.08,36.83 28.08,35.11 27.75,34.78 26.6,34.78 26.28,34.46 26.28,34.02 26,33.74 24.7,33.74 24.62,33.82 24.62,35.84 24.62,35.84 24.62,36.12 25.82,37.33 27.59,37.33
+1.8V on BOTTOM (solid shape): 14.79,20.28 14.79,19.16 14.67,19.04 13.63,19.04 13.5,19.16 13.5,20.48 13.55,20.53 14.54,20.53
+1.8V on BOTTOM (solid shape): 84.26,25.77 84.26,24.37 84.01,24.12 78.6,24.12 77.94,24.78 77.8,24.87 77.63,24.9 77.23,24.9 76.9,25.24 76.9,25.64 77.15,25.89 84.14,25.89
+1.8V on BOTTOM (solid shape): outline of 152 points within 83.78,82.92 86.03,85.84
+1.8V on IN3 (solid shape): outline of 2748 points within 12.89,19.15 78.35,39.08
+1.8V_GFX on TOP (solid shape): outline of 702 points within 93.88,92.61 107.68,101.85
+1.8V_GFX on BOTTOM (solid shape): 103.44,88.89 103.44,85.58 103.31,85.46 102.04,85.46 101.53,85.97 101.53,89.01 101.79,89.27 103.06,89.27
+1.8V_GFX on BOTTOM (solid shape): 106.04,101.18 106.06,101.17 106.08,101.16 106.84,100.4 106.84,100.16 106.61,99.93 106.21,99.52 106.21,99.2 106.1,99.09 105.8,99.09 105.68,99.21 105.68,99.39 104.85,100.22 104.28,100.22 104.18,100.33 104.18,100.51 104.45,100.78 104.45,101 104.63,101.18
+1.8V_GFX on IN2 (solid shape): outline of 3071 points within 101.92,87.24 123.72,125.53
+1.8V_GFX on IN3 (solid shape): 99.18,94.71 99.44,94.71 99.74,94.41 99.74,94.16 99.82,94.08 99.82,94.08 102.28,91.62 102.28,91.18 103.81,89.65 103.81,88.78 103.39,88.37 102.67,88.37 98.59,92.45 99.76,92.45 99.76,92.4 99.77,92.34 99.78,92.29 99.81,92.24 99.84,92.2 99.87,92.16 99.91,92.13 99.96,92.1 100.01,92.08 100.06,92.07 100.12,92.07 100.17,92.07 100.22,92.08 100.27,92.1 100.32,92.13 100.36,92.16 100.39,92.2 100.42,92.24 100.45,92.29 100.46,92.34 100.47,92.4 100.47,92.45 100.46,92.5 100.45,92.55 100.42,92.6 100.39,92.65 100.36,92.68 100.32,92.72 100.27,92.74 100.22,92.76 100.17,92.78 100.12,92.78 100.06,92.78 100.01,92.76 99.96,92.74 99.91,92.72 99.87,92.68 99.84,92.65 99.81,92.6 99.78,92.55 99.77,92.5 99.76,92.45 98.59,92.45 97.68,93.36 97.68,94.47 97.92,94.72 99.18,94.72
+1.8V_S5 on TOP (solid shape): 86.17,27.04 86.17,25.39 86.14,25.36 84.92,25.36 84.9,25.39 84.9,26.91 85.13,27.14 85.16,27.14 86.04,27.14 86.06,27.14
+1.8V_S5 on TOP (solid shape): 101.03,35.42 101.03,33.64 100.39,33.01 98.74,33.01 98.61,33.13 98.61,33.92 98.69,34 98.79,34 98.84,33.99 99.66,33.99 99.72,34.01 99.77,34.06 99.77,34.06 99.86,34.15 99.86,35.42 99.99,35.55 100.9,35.55
+1.8V_S5 on TOP (solid shape): 116.58,42.15 116.97,42.15 117,42.15 117.11,42.15 117.14,42.14 117.16,42.1 117.16,41.64 117.92,40.88 119.06,40.88 119.44,40.5 119.95,40.5 120.08,40.37 120.08,39.99 119.68,39.6 118.95,39.6 118.68,39.86 118.06,39.86 118.01,39.87 117.6,39.87 117.55,39.86 117.44,39.86 117.36,39.79 117.36,39.75 117.36,39.17 117.31,39.12 116.98,39.12 116.98,39.13 116.95,39.17 116.95,39.24 116.95,39.24 116.95,39.75 116.95,39.75 116.95,39.78 116.77,39.95 116.77,40.26 116.78,40.28 116.86,40.38 116.88,40.48 116.88,40.78 116.86,40.87 116.78,40.97 116.77,41.01 116.39,41.39 116.39,42.02 116.52,42.15
+1.8V_S5 on TOP (solid shape): 30.04,33.08 30.04,31.95 30.26,31.74 30.26,28.54 30.23,28.53 30.16,28.48 30.14,28.41 30.14,24.65 30.14,24.59 29.68,24.59 29.66,24.61 28.61,24.61 28.6,24.61 28.46,24.75 28.46,28.33 28.13,28.66 28.13,29.83 28.31,30.01 28.31,30.61 28.33,30.65 28.34,30.66 28.51,30.93 28.41,31.24 28.37,31.27 28.33,31.3 28.25,31.34 28.17,31.35 28.1,31.39 28.08,31.46 28.08,31.48 27.65,31.86 27.33,31.39 27.31,31.31 27.23,31.27 26.06,31.27 25.97,31.36 25.97,32.9 26.33,33.26 27.59,33.26 27.72,33.17 27.87,33.13 28.13,33.23 28.25,33.47 28.26,33.52 29.6,33.52
+1.8V_S5 on BOTTOM (solid shape): 159.76,34.59 159.76,34.12 159.81,34.06 159.81,33.52 159.8,33.47 159.8,33.41 159.91,33.12 160.18,32.96 160.19,32.95 160.19,32.55 160.16,32.52 160.16,31.86 160.04,31.75 159.59,31.75 159.53,31.76 159.47,31.76 159.37,31.75 159.27,31.71 157.64,31.71 157.55,31.79 157.55,32.24 157.68,32.38 157.8,32.32 157.92,32.29 158.06,32.32 158.18,32.39 158.24,32.41 158.3,32.39 158.56,32.29 158.81,32.39 158.88,32.41 158.94,32.39 159.06,32.32 159.19,32.29 159.57,32.68 159.19,33.06 159.06,33.03 158.94,32.96 158.88,32.94 158.81,32.96 158.56,33.06 158.3,32.96 158.24,32.94 158.18,32.96 158.09,33.02 157.99,33.05 157.91,33.12 157.94,33.22 158.16,33.45 158.16,33.75 158.35,33.95 158.66,33.95 158.82,34.1 158.82,34.53 158.95,34.67 159.68,34.67
+1.8V_S5 on BOTTOM (solid shape): outline of 788 points within 14.49,9.28 29.86,29.15
+1.8V_S5 on SVCC (solid shape): outline of 193 points within 26.86,25.77 132.01,54.6
+1.8V_SW on BOTTOM (solid shape): 11.91,21.48 14.63,21.48 14.83,21.29 14.83,20.85 14.79,20.81 13.46,20.81 13.27,20.63 13.27,20.61 13.25,20.58 13.25,19.19 13.22,19.16 12.86,19.16 12.76,19.26 12.76,19.39 12.58,19.58 11.32,19.58 10.74,20.16 10.74,21.48 10.91,21.66 11.73,21.66
+1.8V_SW on BOTTOM (solid shape): 16.44,13.83 16.44,13.76 16.43,13.75 16.39,13.7 16.38,13.65 16.38,13.44 16.38,13.41 16.37,13.38 16.33,13.34 16.33,12.79 16.23,12.69 15.81,12.69 15.66,12.84 14.88,12.84 14.79,12.93 14.79,13.71 14.82,13.74 15.71,13.74 15.83,13.76 15.93,13.83 16.06,13.96 16.32,13.96
+1.8V_SW on IN2 (solid shape): outline of 117 points within 10.98,12.67 17.51,21.07
+1.35V_GFX on TOP (solid shape): outline of 3846 points within 137.9,77.82 149.32,117.83
+1.35V_GFX on BOTTOM (solid shape): outline of 8617 points within 128.18,77.97 149.1,119.81
+1.35V_GFX on IN1 (solid shape): outline of 5414 points within 107.23,77.17 149.22,117.35
+1.35V_GFX on IN3 (solid shape): outline of 6518 points within 107.63,78.43 149.22,110.73
+1V8_TPM_VSB on TOP (solid shape): 132.15,19.78 132.15,19.41 131.89,19.14 131.74,19.14 131.38,18.78 131.38,18.27 131.25,18.15 130.29,18.15 129.86,18.58 128.46,18.58 127.73,19.31 127.73,19.68 127.73,19.73 127.77,19.75 129.04,19.75 129.38,19.42 130.06,19.42 130.35,19.71 130.35,19.86 130.41,19.92 132.01,19.92
+1V8TPM on TOP (solid shape): 121.93,20.92 122.29,20.92 122.46,20.74 122.46,20.56 122.41,20.51 121.98,20.51 121.63,20.15 121.37,20.15 121.35,20.18 121.35,20.59 121.09,20.84 121.09,21.32 121.14,21.37 121.47,21.37
+1V8TPM on TOP (solid shape): 132.53,23.91 132.53,23.9 132.61,23.75 132.74,23.65 132.75,23.64 132.76,23.62 132.76,22.53 132.71,22.48 131.13,22.48 131.06,22.55 131.06,22.89 130.8,23.15 130.57,23.15 130.5,23.08 130.49,23.08 130.35,22.99 130.26,22.85 130.26,22.84 130.12,22.7 129.23,22.7 129.04,22.89 128.79,22.89 128.79,22.95 127.76,22.95 127.76,23.28 127.83,23.34 129.33,23.34 129.35,23.35 130.03,23.35 130.21,23.53 130.21,23.61 130.63,24.03 132.42,24.03
+2.5V_SUS on TOP (solid shape): 26.13,86.84 26.13,84.18 25.88,83.93 25.47,83.93 25.47,83.93 24.91,83.93 24.75,84.09 24.75,86.97 24.83,87.05 25.92,87.05
+2.5V_SUS on TOP (solid shape): 48,45.59 48,42.77 47.99,42.76 47.99,41.45 47.94,41.41 47.02,41.41 46.93,41.5 46.93,45.5 47.16,45.72 47.87,45.72
+2.5V_SUS on TOP (solid shape): 50.85,90.45 50.85,88.78 50.4,88.33 47.08,88.33 46.91,88.5 46.91,89.04 48.58,89.04 48.58,89.01 48.58,88.96 48.6,88.9 48.62,88.86 48.65,88.81 48.69,88.77 48.73,88.73 48.77,88.7 48.82,88.68 48.88,88.67 48.93,88.66 48.99,88.66 49.05,88.67 49.1,88.69 49.16,88.71 49.21,88.75 49.23,88.77 49.41,88.95 49.86,88.96 49.9,88.96 49.94,88.98 49.98,89.01 50.01,89.04 50.03,89.07 50.05,89.12 50.06,89.16 50.07,89.26 50.07,89.31 50.07,89.36 50.07,89.4 50.06,89.5 50.05,89.55 50.03,89.59 50.01,89.63 49.98,89.66 49.94,89.68 49.9,89.7 49.86,89.71 49.25,89.71 49.22,89.71 49.16,89.7 49.1,89.68 49.05,89.66 49,89.62 48.98,89.6 48.69,89.31 48.67,89.29 48.63,89.24 48.6,89.18 48.59,89.13 48.58,89.07 48.58,89.04 46.91,89.04 46.91,89.9 47.7,90.69 50.61,90.69
+2.5V_SUS on TOP (solid shape): outline of 346 points within 33.32,26.54 58.25,30.59
+2.5V_SUS on BOTTOM (solid shape): 34.99,30.85 34.99,28.56 34.73,28.3 32.83,28.3 32.57,28.56 32.57,31.23 32.83,31.48 34.35,31.48
+2.5V_SUS on BOTTOM (solid shape): 59.52,30.27 59.52,28.97 59.17,28.62 56.78,28.62 56.7,28.69 56.7,29.83 59.33,29.83 59.33,30.08 57.57,30.08 57.57,29.83 56.7,29.83 56.7,29.85 57.17,30.33 59.47,30.33
+2.5V_SUS on BOTTOM (solid shape): outline of 1428 points within 21.08,83.83 59.62,123.3
+3V on TOP (solid shape): 189.63,30.61 189.63,29.03 189.55,28.94 188.02,28.94 187.89,29.07 187.89,30.59 188.02,30.72 189.52,30.72
+3V on TOP (solid shape): 105.79,41.16 106.11,41.16 106.24,41.02 106.24,39.52 106.11,39.38 105.39,39.38 105.39,41.19 105.46,41.26 105.69,41.26
+3V on TOP (solid shape): 13.15,10.27 13.15,7.89 12.99,7.73 11.24,7.73 11.11,7.86 11.11,10.2 11.3,10.39 13.03,10.39
+3V on TOP (solid shape): 88.96,26.4 88.96,25.61 88.91,25.56 88.91,24.88 88.85,24.82 88.85,24.74 88.73,24.62 88.61,24.62 88.58,24.65 88.43,24.65 87.96,25.12 87.96,26.4 88.08,26.53 88.83,26.53
+3V on TOP (solid shape): 150.96,29.83 150.96,28.39 150.39,27.81 149.17,27.81 149.07,27.71 149.04,27.69 149.01,27.65 148.91,27.55 148.91,26.4 148.72,26.21 146.66,26.21 146.58,26.29 146.58,29.75 146.86,30.04 150.75,30.04
+3V on TOP (solid shape): 161.38,27.55 161.45,27.51 161.48,27.44 161.48,27.42 161.51,27.26 161.61,27.13 161.61,27.04 161.99,26.66 162.01,26.63 162.65,26.63 163,26.28 163.16,26.28 163.19,26.27 163.52,26.27 163.64,26.15 163.64,26.02 163.51,25.89 162.75,25.89 162.62,25.77 161.35,25.77 160.34,26.78 160.34,27.17 160.34,27.21 160.34,27.42 160.36,27.44 160.46,27.44 160.56,27.55
+3V on TOP (solid shape): outline of 814 points within 48.66,90.82 65.59,100.12
+3V on BOTTOM (solid shape): 60.37,104.08 60.37,103.44 60.39,103.38 60.39,102.56 60.23,102.4 59.42,102.4 59.27,102.55 59.27,104.04 59.38,104.16 60.3,104.16
+3V on BOTTOM (solid shape): 65.31,92.89 65.72,92.89 66.04,92.58 66.04,88.34 66.03,88.32 66.02,88.3 65.85,88.12 64.32,88.12 64.2,88.25 64.2,90.03 64.8,90.63 64.8,91.15 64.67,91.28 64.39,91.28 64.38,91.27 64.11,91.27 63.91,91.47 63.91,93.24 63.99,93.32 64.88,93.32
+3V on BOTTOM (solid shape): outline of 339 points within 15.17,82.66 23.81,90.32
+3V on SVCC (solid shape): outline of 1331 points within 17.84,18.66 205.42,125.97
+3V on IN3 (solid shape): outline of 3283 points within 10.6,4.94 28.38,32.71
+3V_CCD_PWR1_C on BOTTOM (solid shape): 59.38,106.71 59.57,106.71 59.57,107.57 59.76,107.57 59.77,107.57 59.84,107.57 59.87,107.54 59.87,106.6 59.87,106.6 59.87,105.91 60.26,105.52 61.53,105.52 61.66,105.4 61.66,104.76 61.53,104.63 59.37,104.63 59.35,104.66 59.3,104.81 59.2,104.93 59.13,105.04 59.02,105.11 58.99,105.12 58.99,105.9 59.02,105.91 59.02,105.92 59.04,105.92 59.23,106.06 59.3,106.29 59.23,106.49 59.07,106.63 59.07,107.57 59.38,107.57
+3V_EC on TOP (solid shape): 161.25,25.51 162.75,25.51 163.13,25.13 163.23,25.13 163.24,25.13 163.54,25.13 163.59,25.08 163.6,25.07 163.72,24.92 163.9,24.85 163.92,24.85 163.99,24.78 164.35,24.78 164.65,24.47 164.65,24.14 164.58,24.07 164.36,24.07 164.24,24.18 164.07,24.22 163.97,24.21 163.89,24.17 163.64,24.17 163.56,24.24 162.04,24.24 161.86,24.28 161.68,24.24 161.03,24.24 160.84,24.28 160.66,24.24 160.46,24.24 160.34,24.37 160.34,25.89 160.46,26.02 160.74,26.02
+3V_GFX on BOTTOM (solid shape): 60.43,120.72 60.43,120.71 60.43,119.53 60.28,119.39 59.21,119.39 59.2,119.38 58.68,119.38 58.57,119.49 58.57,119.92 59.19,120.54 59.19,121.15 59.3,121.27 59.89,121.27
+3V_GFX on BOTTOM (solid shape): 110.83,125.72 110.83,125.72 110.94,125.6 111.3,125.6 111.31,125.59 111.95,125.59 112.08,125.46 112.08,125.08 111.94,124.94 110.92,124.94 110.91,124.95 110.1,124.95 110.1,124.96 110.1,125.46 110.08,125.57 110.04,125.67 110.03,125.68 110.03,125.78 110.08,125.83 110.72,125.83
+3V_GFX on IN1 (solid shape): outline of 2449 points within 102.56,82.46 128.11,125.57
+3V_HDMI on BOTTOM (solid shape): 16.83,81.9 17.59,81.9 17.97,81.52 17.97,80.28 17.87,80.17 17.33,80.17 17.21,80.3 17.21,81.01 17.18,81.04 17.18,81.05 17.08,81.26 16.87,81.37 16.85,81.37 16.83,81.39 15.68,81.39 15.66,81.42 15.66,82.13 15.68,82.16 16.57,82.16
+3V_HDMI on IN2 (solid shape): outline of 202 points within 17.21,73.9 23.43,83.7
+3V_LAN on TOP (solid shape): 49.5,108.63 49.65,108.63 49.74,108.54 49.74,107.54 49.2,107 48.49,106.29 47.31,106.29 47.3,106.29 46.25,106.29 46.24,106.3 46.24,106.5 46.25,106.5 47.33,106.5 48.57,107.74 48.57,108.51 48.69,108.63 49.5,108.63
+3V_LAN on TOP (solid shape): 42.23,108.95 42.23,108.57 42.48,108.32 43.07,108.32 43.34,108.04 43.34,107.03 43.06,107.03 43.04,107.05 43.04,107.76 42.89,107.91 42.33,107.91 42.07,108.16 41.69,108.16 41.41,108.44 40.63,108.44 40.56,108.51 40.56,109.03 40.64,109.1 42.07,109.1
+3V_LAN on TOP (solid shape): 48.82,114.46 48.82,114.46 48.86,114.42 50.86,114.42 51.36,113.91 51.36,113.35 51.67,113.05 52.14,113.05 52.42,113.32 52.42,113.51 52.53,113.62 53,113.62 53.08,113.58 53.1,113.5 53.1,113.42 53.1,113.35 53.13,113.26 53.13,112.83 52.89,112.59 51.22,112.59 50.89,112.25 50.89,111.8 50.73,111.64 49.94,111.64 49.62,111.96 49.62,113.04 49.26,113.4 49.26,113.4 49.12,113.54 48.18,113.54 47.95,113.78 47.95,114.75 48.01,114.82 48.46,114.82
+3V_LAN on IN1 (solid shape): outline of 360 points within 41.46,107.68 49.74,113.83
+3V_LDO_EC on TOP (solid shape): 160.65,31.74 160.84,31.93 161.03,31.74 161.03,30.92 158.88,28.76 158.88,26.95 158.44,26.51 158.36,26.53 158.3,26.53 158.21,26.52 158.12,26.48 158.11,26.48 158.05,26.48 157.54,25.97 157.54,25.82 157.49,25.77 157.49,23.62 158.15,22.95 158.15,22.57 158.18,22.55 158.18,21.7 158.39,21.49 158.39,21.31 158.56,21.14 158.56,20.69 158.3,20.43 157.67,20.43 157.61,20.5 157.61,22.9 157.1,23.41 157.1,26.23 157.78,26.9 157.92,26.9 157.99,26.89 158.05,26.88 158.1,26.89 158.42,27 158.53,27.27 158.52,27.35 158.49,27.43 158.49,28.92 160.65,31.08
+3V_RTC on TOP (solid shape): 103.44,32.12 103.44,29.07 103.18,28.81 102.54,28.81 102.47,28.88 102.47,31.28 102.68,31.48 102.8,31.48 102.93,31.61 102.93,32.12 103.06,32.24 103.31,32.24
+3V_RTC_1 on TOP (solid shape): 106.84,29.55 106.84,29.2 106.74,29.09 106.41,29.09 106.08,29.43 106.08,29.57 105.94,29.57 105.93,29.58 103.95,29.58 103.82,29.7 103.82,30.21 103.95,30.34 106.06,30.34
+3V_RTC_2 on TOP (solid shape): 105.04,28.71 105.04,28.41 105.62,27.82 105.62,27.39 105.55,27.32 104.86,27.32 104.58,27.04 102.93,27.04 102.8,27.16 102.8,27.93 103.69,28.82 104.93,28.82
+3V_S5 on TOP (solid shape): 48.99,112.8 48.99,111.84 48.88,111.73 47.91,111.73 47.69,111.51 47.4,111.51 47.34,111.57 47.34,112.76 47.5,112.92 48.88,112.92
+3V_S5 on TOP (solid shape): 93.91,26.91 93.91,26.64 94.17,26.38 94.17,25.92 94.15,25.89 92.52,25.89 92.39,26.02 92.39,26.91 92.52,27.04 93.79,27.04
+3V_S5 on TOP (solid shape): 86.17,114.16 87.49,114.16 87.49,113.91 86.29,113.91 86.07,113.68 83.32,113.68 83.02,113.98 83.02,114.34 83.12,114.44 84.26,114.44 84.44,114.62 85.71,114.62
+3V_S5 on TOP (solid shape): 14.24,10.54 14.24,9.79 14.32,9.71 14.32,8.96 14.46,8.82 14.46,8.81 14.52,8.75 14.52,7.86 14.49,7.83 13.55,7.83 13.42,7.96 13.42,10.5 13.6,10.68 14.1,10.68
+3V_S5 on TOP (solid shape): 153.73,26.36 153.73,24.14 153.65,24.06 148,24.06 147.99,24.06 147.12,24.06 146.87,24.31 146.87,25.85 147.05,26.02 151.83,26.02 152.27,26.46 153.63,26.46
+3V_S5 on TOP (solid shape): 159.95,26.28 159.95,24.24 159.93,24.22 159.68,24.1 159.57,23.84 159.58,23.79 159.59,23.72 159.37,23.5 159.23,23.5 159.19,23.54 159.13,23.55 158.75,23.55 158.69,23.54 158.65,23.5 158.61,23.5 158.36,23.76 158.36,24.8 158.68,25.13 158.68,25.39 158.94,25.64 158.96,25.67 158.96,26.3 159.19,26.53 159.7,26.53
+3V_S5 on TOP (solid shape): 187.78,22.41 187.78,21.97 187.77,21.96 187.77,17.82 188.02,17.56 188.02,17.13 187.39,16.5 187.39,15.24 187.01,14.86 187.01,13.08 186.73,12.8 186.73,12.79 186.37,12.43 185.23,12.43 185.16,12.5 185.16,12.65 185.16,12.66 185.2,12.72 185.21,12.79 185.21,13.09 185.15,13.24 185.02,13.31 184.97,13.32 184.97,13.58 185.08,13.68 185.08,14.44 185.13,14.49 185.66,14.49 185.99,14.82 185.99,15.1 186.12,15.23 186.12,16.59 186.57,17.05 186.57,18.2 186.12,18.66 186.12,21.11 186.56,21.56 186.56,21.68 186.84,21.96 186.96,21.96 187.51,22.5 187.7,22.5
+3V_S5 on BOTTOM (solid shape): outline of 107 points within 50.91,99.12 62.76,104.2
+3V_S5 on IN2 (solid shape): outline of 772 points within 17.06,87.83 49.97,121.02
+3V_S5 on SVCC (solid shape): outline of 1077 points within 3.63,19.67 192.85,92.19
+3V_S5 on IN3 (solid shape): 51.62,121.53 51.62,120 51.5,119.87 48.83,119.87 48.58,120.13 48.58,121.53 48.7,121.65 51.5,121.65
+3V_S5 on IN3 (solid shape): outline of 342 points within 76.39,112.13 84.39,115.68
+3V_S5 on IN3 (solid shape): outline of 501 points within 41.74,98.77 53.19,112.97
+3V_SSD on TOP (solid shape): 37.92,4.44 38.2,4.44 38.64,4.44 38.72,4.36 38.72,2.61 38.59,2.48 35.81,2.48 35.54,2.75 35.54,4.05 35.91,4.43 36.13,4.43 36.48,4.43 36.86,4.8 37.56,4.8
+3V_SSD on TOP (solid shape): 23.01,4.25 23.01,3.16 22.88,3.03 22.88,2.75 22.82,2.64 22.8,2.53 22.81,2.48 22.82,2.43 22.8,2.34 22.72,2.29 21.89,2.29 21.86,2.32 21.86,2.38 21.89,2.46 21.9,2.53 21.89,2.6 21.86,2.67 21.86,2.88 21.72,3.02 21.72,3.86 21.78,4.01 21.81,4.16 21.81,4.18 21.99,4.35 22.91,4.35
+3V_SSD on TOP (solid shape): outline of 98 points within 11.49,4.94 19.26,7.35
+3V_SSD on BOTTOM (solid shape): outline of 840 points within 15.54,1.32 39.93,7.51
+3V_WLAN_P on TOP (solid shape): 198.94,14.59 199.04,14.69 199.14,14.59 199.14,13.99 198.78,13.63 198.78,12.12 198,11.34 197.97,11.32 197.93,11.31 197.86,11.34 197.83,11.42 197.83,11.45 197.86,11.49 198.58,12.21 198.58,13.71 198.94,14.07
+3V_WLAN_P on TOP (solid shape): outline of 417 points within 187.13,9.66 196.1,31.75
+3V_WLAN_P on BOTTOM (solid shape): 191.98,31.56 191.98,31.42 192.19,31.2 193.29,31.2 193.42,31.07 193.42,28.49 193.25,28.32 191.89,28.32 191.8,28.41 191.8,30.18 191.74,30.24 190.03,30.24 190,30.27 190,30.53 191.55,30.53 191.55,30.72 191.55,30.73 190,30.73 190,31.04 190.79,31.04 191.51,31.76 191.78,31.76
+3V_WLAN_P on BOTTOM (solid shape): 192.37,13.16 192.37,12.18 194.35,12.18 194.58,12.41 195.16,12.41 195.21,12.36 195.21,11.84 194.89,11.52 194.19,11.52 194.11,11.44 194.02,11.44 193.96,11.38 193.96,10.86 193.91,10.8 193.51,10.8 193.02,11.29 191.7,11.29 191.7,11.37 191.71,11.42 191.32,11.8 190.94,11.42 190.95,11.35 190.96,11.29 190.95,11.2 190.87,11.15 190.52,11.15 190.5,11.17 189.9,11.17 189.79,11.28 189.79,11.72 190.01,11.94 190.01,13.03 191.55,13.03 191.55,13.23 190.01,13.23 190.01,13.51 190.03,13.52 192.01,13.52
+3VLCD_CON on TOP (solid shape): 64.47,104.15 64.52,104.1 64.52,103.71 64.52,103.66 64.51,103.62 64.58,103.38 64.76,103.22 65.09,102.89 65.09,102.65 65.09,102.61 65.09,102.58 65.09,102.54 65.09,102.41 64.96,102.27 63.13,102.27 62.9,102.5 61.73,102.5 61.53,102.7 61.53,102.98 61.53,103.34 61.36,103.51 61.36,103.82 61.49,103.96 62.19,103.96 62.23,103.97 62.27,103.99 62.28,104 62.39,104 62.55,104.15
+3VLCD_CON on BOTTOM (solid shape): outline of 172 points within 63.68,93.16 66.05,102.88
+3VLCD_CON_R on TOP (solid shape): 61.83,106.36 62.31,106.36 62.36,106.32 62.36,104.5 62.26,104.41 60.5,104.41 60.29,104.62 60.29,105.98 60.13,106.14 60.13,106.2 60.13,106.47 60.22,106.56 60.69,106.56 60.9,106.77 60.9,107.07 61.12,107.07
+3VLCD_CON_R on BOTTOM (solid shape): 60.37,107.53 60.37,107.5 60.37,106.71 60.57,106.71 60.57,107.5 60.58,107.53 60.87,107.53 60.87,107.5 60.87,106.71 61.07,106.71 61.07,107.5 61.08,107.53 61.37,107.53 61.38,107.52 61.38,106.71 61.41,106.68 61.41,106.22 61.14,105.95 60.18,105.95 60.07,106.06 60.07,106.93 60.1,106.97 60.1,107.49 60.14,107.53
+3VPCU on TOP (solid shape): 106.23,26.66 106.23,26.4 105.98,26.15 104.07,26.15 103.95,26.28 103.95,26.66 104.07,26.78 106.11,26.78
+3VPCU on TOP (solid shape): 55.47,112.51 55.47,110.36 55.3,110.2 54.16,110.2 53.86,109.89 53.86,109.58 53.81,109.58 53.8,109.59 53.52,109.59 53.27,109.84 53.27,110.93 54.97,112.63 55.35,112.63
+3VPCU on TOP (solid shape): 187.46,23.64 187.46,22.82 186.86,22.21 186.73,22.21 186.58,22.06 186.49,22 186.4,21.98 186.36,21.98 186.33,21.99 185.51,21.17 184.51,21.17 184.36,21.32 184.35,21.32 184.22,21.45 184.35,21.58 184.47,21.58 184.61,21.44 184.73,21.44 184.84,21.37 184.97,21.35 185.11,21.37 185.22,21.44 185.42,21.44 186.15,22.17 186.14,22.2 186.14,22.24 186.16,22.33 186.22,22.42 186.52,22.72 186.65,22.72 186.96,23.03 186.96,23.43 186.52,23.86 186.35,23.86 186.29,23.8 186.21,23.75 186.11,23.73 185.48,23.73 185.23,23.98 185.48,24.23 186,24.23 186.06,24.29 186.14,24.35 186.24,24.37 186.73,24.37
+3VPCU on TOP (solid shape): outline of 161 points within 152.17,29.5 159.58,33.13
+3VPCU on BOTTOM (solid shape): 120.84,89.27 120.84,88.42 122.11,87.15 122.11,83.55 121.86,83.3 120.86,83.3 120.84,83.3 120.59,83.04 119.31,83.04 119.19,83.17 119.19,84.06 119.31,84.18 120.58,84.18 120.67,84.21 120.71,84.3 120.71,84.32 120.93,84.54 120.93,86.44 118.99,88.39 118.99,89.22 118.55,89.65 111.06,89.65 110.1,89.65 110.01,89.74 107.45,89.74 107.17,90.02 107.17,90.72 107.39,90.94 119.17,90.94
+3VPCU on IN1 (solid shape): outline of 1852 points within 107.64,32.18 159.59,91.04
+3VPCU on IN2 (solid shape): 162.32,32.4 162.32,31.71 161.63,31.02 160.59,31.02 160.36,31.24 160.36,31.75 160.35,31.76 160.49,31.76 160.49,31.71 160.5,31.66 160.51,31.61 160.53,31.56 160.56,31.51 160.6,31.47 160.64,31.44 160.69,31.41 160.74,31.4 160.79,31.38 160.84,31.38 160.9,31.38 160.95,31.4 161,31.41 161.05,31.44 161.09,31.47 161.12,31.51 161.15,31.56 161.18,31.61 161.19,31.66 161.2,31.71 161.2,31.76 161.19,31.82 161.18,31.87 161.15,31.91 161.12,31.96 161.09,32 161.05,32.03 161,32.06 160.95,32.08 160.9,32.09 160.84,32.09 160.79,32.09 160.74,32.08 160.69,32.06 160.64,32.03 160.6,32 160.56,31.96 160.53,31.91 160.51,31.87 160.5,31.82 160.49,31.76 160.35,31.76 159.93,32.18 159.93,32.7 160.04,32.81 160.51,32.81 160.53,32.76 160.56,32.71 160.59,32.68 160.63,32.64 160.67,32.62 160.72,32.6 160.77,32.58 160.82,32.57 160.87,32.57 160.93,32.58 160.98,32.6 161.03,32.63 161.08,32.66 161.11,32.7 161.15,32.74 161.17,32.79 161.19,32.85 161.86,32.85
+3VPCU on IN2 (solid shape): outline of 1239 points within 53.31,85.84 110.81,110.69
+3VPCU_EC on TOP (solid shape): 163.71,32.8 163.71,31.56 163.36,31.21 163.32,31.17 163.28,31.12 162.88,30.72 162.36,30.72 162.24,30.83 162.24,31.25 162.24,31.25 162.24,31.31 162.25,31.31 162.25,31.65 162.45,31.86 162.45,32.82 162.64,33.01 163.5,33.01
+5V on TOP (solid shape): 17.46,85.2 17.46,83.93 17.21,83.68 16.19,83.68 16.06,83.81 16.06,85.2 16.19,85.33 17.33,85.33
+5V on TOP (solid shape): 215.96,13.96 215.96,12.69 215.7,12.43 213.68,12.43 213.42,12.69 213.42,14.72 213.68,14.97 214.95,14.97
+5V on TOP (solid shape): 60.88,100.82 60.88,100.3 60.65,100.07 60.65,99.26 60.54,99.15 59.61,99.15 59.32,99.43 59.32,100.55 59.51,100.74 60.07,100.74 60.31,100.98 60.72,100.98
+5V on TOP (solid shape): 143.95,15.87 143.95,13.67 143.62,13.35 142.15,13.35 141.56,13.94 141.56,15.03 141.28,15.31 140.22,15.31 140.06,15.47 140.06,15.87 140.18,15.99 143.83,15.99
+5V on BOTTOM (solid shape): 18.22,29.83 18.22,28.43 18.1,28.31 15.94,28.31 15.68,28.56 15.68,29.7 15.94,29.96 18.1,29.96
+5V on BOTTOM (solid shape): 61.99,96.59 63.36,96.59 63.45,96.49 63.45,95.64 63.31,95.49 62.42,95.49 62.16,95.24 62.16,95.03 62.16,94.22 62.04,94.09 60.64,94.09 60.61,94.11 60.59,94.14 60.59,96.29 60.89,96.59 61.98,96.59
+5V on BOTTOM (solid shape): outline of 130 points within 175.27,23.02 180.82,28.1
+5V on IN1 (solid shape): 17.33,30.85 17.33,28.43 17.08,28.18 15.94,28.18 15.56,28.56 15.56,30.72 15.94,31.1 17.08,31.1
+5V on IN1 (solid shape): outline of 551 points within 14.68,70.24 22.77,85.73
+5V on IN2 (solid shape): 17.71,85.58 17.71,84.44 17.59,84.31 16.06,84.31 15.94,84.44 15.94,85.71 16.06,85.84 17.46,85.84
+5V on IN2 (solid shape): outline of 95 points within 58.61,96 63.56,100.8
+5V on IN2 (solid shape): outline of 248 points within 176.11,17.51 181.31,24.13
+5V on SVCC (solid shape): outline of 1260 points within 2.03,2.03 217.77,29.7
+5V_HDD on TOP (solid shape): 215.07,17 216.6,17 216.72,16.88 216.72,16.88 216.72,14.21 216.61,14.1 216.09,14.1 215.09,15.1 213.68,15.1 213.55,15.23 213.55,16.88 213.68,17 215.07,17
+5V_HDD on BOTTOM (solid shape): 216.72,16.25 216.72,14.71 216.6,14.58 214.49,14.58 214.42,14.66 214.4,14.66 214.4,14.67 213.57,14.67 213.53,14.7 213.53,14.97 214.4,14.97 214.4,15.17 213.56,15.17 213.56,14.97 213.53,14.97 213.53,15.47 214.4,15.47 214.4,15.67 213.56,15.67 213.56,15.47 213.53,15.47 213.53,15.97 213.54,15.98 213.56,15.98 213.56,15.97 214.4,15.97 214.4,15.98 214.43,15.98 214.56,16.12 214.56,16.37 214.69,16.5 215.07,16.5 215.08,16.51 216.47,16.51
+5V_HDMIC on TOP (solid shape): 14.23,83.55 14.25,83.55 14.39,83.45 14.54,83.42 14.67,83.45 14.78,83.51 14.79,83.51 14.82,83.51 14.85,83.5 14.92,83.43 14.92,80.76 14.67,80.5 12.76,80.5 12,79.74 11.36,79.74 11.13,79.97 11.13,80.78 13.65,83.3 13.65,83.5 13.67,83.54 13.7,83.55
+5V_HDMIC on BOTTOM (solid shape): 13.4,81.39 13.9,81.39 14.03,81.27 14.03,80.61 12.91,80.61 12.51,81.01 12.51,81.39 12.65,81.54 13.26,81.54
+5V_HDMIC on IN3 (solid shape): 15.46,88.2 15.81,87.89 16.16,88.2 16.17,88.25 16.65,88.25 16.85,88.05 16.85,87.44 16.17,86.77 16.17,85.05 16.09,84.82 16.17,84.59 16.17,81.85 15.68,81.35 15.6,81.37 15.56,81.37 15.3,81.26 15.2,81.01 15.2,80.97 15.22,80.89 14.82,80.5 12.71,80.5 12.02,79.81 11.35,79.81 11.17,79.99 11.17,81.17 11.77,81.78 13.3,81.78 14.74,83.21 14.74,83.51 14.9,83.81 14.74,84.1 14.74,85.68 14.74,85.69 14.77,85.83 14.74,85.98 14.74,85.99 14.74,86.32 14.29,86.77 14.29,88.06 14.47,88.25 15.45,88.25
+5V_KB on BOTTOM (solid shape): outline of 206 points within 196.78,11.54 205.31,16.24
+5V_ODD on TOP (solid shape): outline of 103 points within 128.71,13.19 145.2,18.11
+5V_ODD on BOTTOM (solid shape): 129.95,17.94 129.99,17.93 130,17.89 130,17.11 130.2,17.11 130.2,17.89 130.21,17.93 130.25,17.94 130.45,17.94 130.49,17.93 130.5,17.89 130.5,17.11 130.7,17.11 130.7,17.89 130.71,17.93 130.75,17.94 130.95,17.94 130.99,17.93 131,17.89 131,17.11 131.2,17.11 131.2,17.89 131.21,17.93 131.25,17.94 131.45,17.94 131.49,17.93 131.5,17.89 131.5,17.11 131.7,17.11 131.7,17.89 131.71,17.93 131.75,17.94 131.95,17.94 131.99,17.93 132,17.89 132,17.11 132.2,17.11 132.2,17.89 132.21,17.93 132.25,17.94 132.45,17.94 132.49,17.93 132.5,17.89 132.5,17.11 132.7,17.11 132.7,17.89 132.71,17.93 132.75,17.94 132.95,17.94 132.99,17.93 133,17.89 133,17.11 133.01,17.08 133.02,17.05 133,17.03 132.87,16.89 132.8,16.8 132.78,16.69 132.78,16.67 132.14,16.04 130.69,16.04 129.68,17.05 129.68,17.09 129.7,17.11 129.7,17.92 129.72,17.94
+5V_PVDD on BOTTOM (solid shape): outline of 168 points within 200.59,17.64 203.9,24.07
+5V_S5 on TOP (solid shape): 22.67,23.1 22.67,21.32 22.54,21.2 20.51,21.2 20.38,21.07 20.38,20.18 20.53,20.03 20.53,19.39 20.6,19.23 20.76,19.17 21.04,19.17 21.2,19.23 21.27,19.39 21.27,19.46 21.28,19.48 21.69,19.48 21.81,19.43 21.93,19.42 22,19.4 22.04,19.33 22.18,19.12 22.41,19.04 22.46,19.04 22.5,19.05 22.55,19.06 22.63,19.03 22.66,18.96 22.66,18.21 22.15,17.7 22.09,17.7 22.01,17.68 21.96,17.6 21.96,17.59 21.52,17.15 20.05,17.15 19.98,17.22 19.98,18.53 19.86,18.53 19.86,18.65 19.85,18.65 19.86,18.68 19.74,19.08 19.33,19.12 19.29,19.11 19.11,19.29 19.11,21.3 19.11,21.45 19.08,21.48 19.07,21.49 19,21.59 18.9,21.66 18.89,21.67 18.86,21.7 18.71,21.7 16.97,21.7 16.93,21.7 16.57,21.7 16.32,21.96 16.32,23.1 16.7,23.48 22.29,23.48
+5V_S5 on BOTTOM (solid shape): 22.7,43.89 22.7,42.89 22.5,42.69 20.48,42.69 20.4,42.78 20.4,44.12 20.53,44.25 22.34,44.25
+5V_S5 on BOTTOM (solid shape): 24.9,23.79 24.9,23.07 24.9,23.05 24.89,23.03 24.51,22.66 24,22.66 22.37,21.03 19.66,21.03 18.98,21.7 18.75,21.7 18.71,21.7 17.16,21.7 17.06,21.74 16.95,21.75 16.85,21.74 16.76,21.71 16.75,21.7 16.7,21.7 16.32,22.08 16.32,23.74 16.44,23.86 24.83,23.86
+5V_S5 on BOTTOM (solid shape): 196.12,26.94 196.12,26.38 195.96,26.22 195.9,26 195.96,25.77 196.12,25.61 196.12,24.42 196.05,24.34 195.18,24.34 194.88,24.65 194.88,25.74 193.86,26.76 193.69,26.76 193.48,26.96 193.48,27.32 193.56,27.39 195.67,27.39
+5V_S5 on BOTTOM (solid shape): 210.83,20.62 210.83,19.76 210.62,19.54 210.51,19.54 210.16,19.5 209.99,19.19 210.02,19.03 210.12,18.91 210.12,18.43 210.12,18.34 210.09,18.27 210.01,18.24 209.52,18.24 209.23,18.53 209.23,18.71 209.1,18.84 208.26,18.84 207.93,19.17 207.93,19.65 208.09,19.8 208.13,19.81 208.21,19.85 208.24,19.93 208.24,20.33 208.72,20.81 208.88,20.81 208.89,20.8 209.89,20.8 209.93,20.84 210.03,20.84 210.07,20.85 210.6,20.85
+5V_S5 on BOTTOM (solid shape): 16.23,28.01 16.31,27.97 16.33,27.89 16.32,27.84 16.32,27.8 16.7,27.42 17.08,27.8 17.08,27.84 17.07,27.89 17.09,27.97 17.17,28.01 18.24,28.01 18.33,27.92 18.35,27.86 18.34,27.79 18.32,27.76 18.32,27.72 18.32,26.35 18.33,26.3 18.36,26.26 18.38,26.24 18.38,25.84 18.19,25.65 15.94,25.65 15.71,25.87 15.71,27.83 15.9,28.01
+5V_S5 on IN1 (solid shape): outline of 258 points within 15.68,26.04 22.54,44.06
+5V_S5 on IN2 (solid shape): outline of 261 points within 15.7,21.03 22.57,28.46
+5V_S5 on SVCC (solid shape): outline of 341 points within 17.84,15.48 210.63,27.54
+5VPCU on TOP (solid shape): 48.8,26.9 48.8,22.98 48.62,22.8 47.41,22.8 46.75,23.46 46.19,23.46 46.04,23.61 46.04,27.29 46.09,27.34 48.36,27.34
+5VPCU on TOP (solid shape): 23.94,27.23 23.94,26.88 24.18,26.64 24.9,26.64 24.98,26.56 24.99,26.54 25,26.53 24.98,26.47 24.98,26.43 24.98,26.12 25.01,26.01 25.09,25.93 25.1,25.92 25.11,25.9 25.11,25.6 24.67,25.16 23.31,25.16 22.72,25.75 22.72,26.14 22.54,26.32 22.54,27.3 22.59,27.35 23.06,27.35 23.08,27.37 23.79,27.37
+5VPCU on TOP (solid shape): 24.08,31.2 24.08,31.18 24.08,31.14 24.07,31.09 24.08,31.05 24.08,31.01 24.08,30.54 24.09,30.54 24.09,30.24 24.09,30.21 24.1,30.18 24.1,29.58 24.09,29.56 24,29.46 23.97,29.35 23.97,29.08 23.65,28.76 22.57,28.76 22.52,28.81 22.52,29.64 22.4,29.75 22.4,31.24 22.53,31.37 23.91,31.37
+5VPCU on TOP (solid shape): 19.53,47.57 19.53,47.28 19.47,47.16 19.45,47.03 19.45,46.71 19.44,46.71 19.44,45.65 19.62,45.47 19.62,45.45 20.51,44.56 20.51,43.17 20,42.66 18.1,42.66 17.08,43.67 17.08,43.9 17.21,44.18 17.08,44.47 17.08,45.96 17.46,46.34 17.46,46.85 18.21,47.6 19.02,47.6 19.05,47.6 19.08,47.61 19.49,47.61
+5VPCU on TOP (solid shape): 147.91,17.89 147.91,17.13 148.4,16.65 148.4,15.99 148.65,15.74 148.77,15.66 148.91,15.63 149.91,15.63 149.98,15.61 150.05,15.61 150.12,15.61 150.19,15.63 151.37,15.63 151.4,15.62 151.42,15.58 151.42,15.26 151.21,15.05 151.19,15.05 151.14,15.07 151.09,15.08 150.79,15.08 150.74,15.07 150.68,15.05 148.78,15.05 148.72,15.07 148.68,15.08 148.37,15.08 148.33,15.07 148.27,15.05 148.17,15.05 148.07,15.15 146.95,15.15 146.89,15.21 146.89,17.91 147,18.02 147.79,18.02
+5VPCU on BOTTOM (solid shape): 30.92,22.47 30.92,21.58 30.65,21.3 30.63,21.3 30.54,21.26 30.5,21.17 30.5,17.47 30.41,17.39 28.05,17.39 27.93,17.51 27.93,18.61 27.74,18.8 27.74,22.33 28.12,22.72 30.67,22.72
+5VPCU on IN2 (solid shape): outline of 7319 points within 18.86,8.11 213.68,45.58
+5VPCU on SVCC (solid shape): outline of 94 points within 145.48,30.97 187.51,47.36
+5VPCU on IN3 (solid shape): outline of 339 points within 184.11,18.5 192.01,32.72
+A3VPCU on TOP (solid shape): 182.94,18.81 184.31,18.81 184.49,18.63 184.49,17.94 184.39,17.84 182.48,17.84 182.36,17.97 182.36,18.81 182.48,18.93 182.81,18.93
+V3A_LX on BOTTOM (solid shape): 149.03,35.41 149.03,35.17 149.41,34.78 150.32,34.78 150.52,34.59 150.52,31.2 150.31,31 149.69,31 148.83,30.13 148.78,30.14 148.51,30.02 148.4,29.75 148.35,29.7 148.28,29.69 148.24,29.7 148.19,29.7 148.04,29.55 148.04,28.89 147.86,28.71 147.23,28.71 147.13,28.82 147.13,29.3 147.27,29.44 147.27,30.5 147.11,30.66 145.9,30.66 145.84,30.72 145.84,30.79 145.84,31.61 145.84,31.62 145.84,31.85 145.84,31.85 145.84,32.32 145.84,32.33 145.84,32.77 146.04,32.97 147.33,32.97 147.91,33.55 147.91,35.75 147.98,35.82 148.63,35.82
+V3A_OUT on TOP (solid shape): 154.63,34.98 156.19,34.98 156.65,34.51 156.65,33.07 156.49,32.91 152.73,32.91 152.64,32.87 152.6,32.78 152.6,32.66 151.82,31.87 151.82,30.82 151.71,30.71 150.88,30.71 150.5,30.33 148.08,30.33 147.99,30.42 147.99,33.84 148.14,34 148.58,34 149.24,34.66 149.92,34.66 150.71,35.44 150.71,36.03 150.84,36.15 153.46,36.15
+V3A_OUT on BOTTOM (solid shape): 152.17,37.53 152.25,37.48 152.26,37.38 152.22,37.29 152.32,36.93 152.59,36.82 152.73,36.84 152.85,36.92 152.92,36.95 152.99,36.92 154.16,35.75 154.77,35.75 155.14,35.38 155.93,35.38 156.27,35.04 156.85,35.04 157.06,34.83 157.91,34.83 157.95,34.79 157.95,33.42 157.53,32.99 157.39,33.04 157.29,33.06 157.02,32.95 156.91,32.68 157.02,32.41 157.29,32.29 157.31,32.3 157.39,32.27 157.42,32.19 157.42,32.05 157.19,31.81 157.16,31.81 156.89,31.7 156.78,31.43 156.77,31.4 156.55,31.18 155.12,31.18 155.04,31.16 154.97,31.12 154.97,31.12 154.93,31.11 154.12,31.11 153.96,30.94 153.95,30.94 153.84,30.86 153.77,30.75 153.76,30.74 153.15,30.13 151.21,30.13 150.8,30.54 150.8,34.86 150.55,35.11 150.33,35.11 149.87,35.57 149.87,37.46 149.95,37.53
+V5P5A_LX on BOTTOM (solid shape): 41.89,22.36 41.89,21.8 42.08,21.61 42.19,21.61 42.51,21.28 42.52,21.27 42.62,21.09 42.8,20.99 42.81,20.99 43.46,20.34 43.46,18.91 43.26,18.71 42.03,18.71 41.36,18.04 41.36,16.49 41.29,16.42 40.91,16.42 40.84,16.49 40.84,17.11 40.48,17.47 38.79,17.47 38.3,17.96 38.3,20.43 40.45,22.58 41.66,22.58
+V5P5A_OUT on BOTTOM (solid shape): 32.5,25.56 32.5,25.14 32.42,25.06 31.85,25.06 31.71,24.93 31.71,24.21 31.46,23.95 31.46,23.95 31.41,23.9 31.41,23.04 31.5,22.95 32.51,22.95 32.88,23.32 37.38,23.32 37.98,22.72 37.98,16.71 37.26,16 37.26,15.04 36.81,14.59 36,14.59 35.88,14.72 35.88,15.47 35.31,16.04 32.47,16.04 32.35,16.16 31.86,16.16 31.72,16.03 28.2,16.03 28.07,16.15 28.07,16.95 28.26,17.13 30.67,17.13 30.8,17.26 30.8,17.38 30.8,17.41 30.8,21.2 31.12,21.52 31.12,22.5 30.86,22.76 30.86,24.06 30.93,24.13 30.93,25.3 31.32,25.69 32.37,25.69
+VCC_CORE on TOP (solid shape): 131.69,56.01 131.69,52.51 130.16,50.98 127.82,50.98 127.72,51.07 127.72,53.89 128.03,54.2 128.03,55.18 128.59,55.74 128.59,55.92 128.66,55.99 131.1,55.99 131.3,56.2 131.51,56.2
+VCC_CORE on TOP (solid shape): outline of 6398 points within 88.57,50.37 120.79,72.08
+VCC_CORE on BOTTOM (solid shape): outline of 282 points within 113.73,50.47 131.71,72.79
+VCC_CORE on IN2 (solid shape): outline of 6760 points within 88.56,49.21 126.55,71.61
+VCC_CORE on SVCC (solid shape): outline of 266 points within 88.58,50.41 132.01,70.85
+VDD_08 on TOP (solid shape): 97.13,118.98 97.33,118.97 97.54,118.76 97.54,116.76 97.21,116.43 94.58,116.43 94.31,116.16 94.31,115.34 93.94,114.97 93.83,114.84 93.79,114.67 93.86,114.44 94.06,114.3 94.09,114.29 94.09,112.86 93.79,112.56 92.57,112.56 92.37,112.76 92.37,115.15 92.14,115.38 92.14,118.07 92.26,118.2 93.43,118.2 94.24,119 96.94,119
+VDD_08 on TOP (solid shape): outline of 96 points within 105.42,108.19 116.77,110.83
+VDD_08 on BOTTOM (solid shape): 97.55,117.03 97.55,115.74 97.24,115.43 96.4,115.43 95.95,114.98 95.03,114.98 94.92,115.03 94.8,115.05 94.69,115.03 94.58,114.98 94.39,114.98 94.29,115.03 94.17,115.05 94.06,115.03 93.96,114.99 93.95,114.98 93.82,114.98 93.7,115.1 93.7,116.79 93.84,116.93 95.76,116.93 96.04,117.21 97.37,117.21
+VDD_08 on IN3 (solid shape): outline of 2191 points within 94.55,109.21 114.36,121.25
+VDD_18 on TOP (solid shape): 88.8,50.78 88.8,50.31 88.48,49.99 88.48,49.83 88.48,49.74 88.48,49.03 88.33,48.88 87.7,48.88 87.48,48.67 87.07,48.67 86.77,48.97 86.77,49.67 87.09,50 87.71,50 87.78,50.03 87.81,50.1 87.81,50.8 87.99,50.97 88.61,50.97
+VDD_18 on BOTTOM (solid shape): outline of 101 points within 81.21,26.4 84.52,31.86
+VDD_18 on BOTTOM (solid shape): 87.37,50.71 87.58,50.71 87.75,50.69 87.91,50.76 87.92,50.77 87.94,50.77 88.06,50.77 88.29,50.55 88.32,50.48 88.29,50.41 88.22,50.31 88.2,50.19 88.25,50.02 88.4,49.9 88.42,49.88 88.43,49.85 88.42,49.79 88.49,49.57 88.66,49.43 88.72,49.36 88.69,49.27 88.57,49.15 88.27,49.15 88.23,49.16 88.22,49.2 88.22,49.24 88,49.45 88,49.46 87.89,49.63 87.7,49.7 87.49,49.61 87.4,49.39 87.4,49.34 87.42,49.29 87.41,49.19 87.32,49.15 86.97,49.15 86.77,49.35 86.77,49.75 86.86,49.99 86.77,50.23 86.77,50.52 87.02,50.77 87.3,50.77
+VDD_18 on IN3 (solid shape): outline of 2322 points within 83.12,29.32 93.41,50.79
+VDD_18_S5 on TOP (solid shape): outline of 1181 points within 81.98,25.49 89.85,50.01
+VDDCI on TOP (solid shape): 93.28,122.87 93.66,121.44 94.51,120.22 94.52,120.2 94.52,119.65 93.53,118.65 92.92,118.65 92.57,119.01 89.13,119.01 88.57,119.57 88.57,121.1 89.01,121.54 89.01,122.58 89.34,122.92 93.27,122.92
+VDDCI on TOP (solid shape): outline of 143 points within 108.18,97.7 117.61,108.39
+VDDCI on BOTTOM (solid shape): 93.29,122.86 94.07,120.81 95.77,119.42 95.77,118.91 95.77,118.91 95.77,117.68 95.5,117.4 91.43,117.4 90.23,118.6 90.23,120.1 90.25,120.14 90.28,120.16 90.43,120.16 90.43,120.36 90.37,120.43 89.89,120.43 89.58,120.75 89.58,122.74 89.89,123.06 93.08,123.06
+VDDCI on IN1 (solid shape): outline of 2240 points within 107.79,97.98 117.64,109.63
+VDDCI on IN2 (solid shape): outline of 6526 points within 91.25,97.82 117.66,122.8
+VDDCI on SVCC (solid shape): 116.14,110.1 115.15,110.1 115.02,110.33 114.77,110.43 114.52,110.33 114.39,110.1 114.11,110.1 114.01,110.08 113.93,110.02 112.86,108.95 111.55,108.95 110.73,109.77 110.65,109.82 110.55,109.84 109.41,109.84 109.31,109.82 109.23,109.77 108.67,109.21 107.33,109.21 107.35,109.27 107.35,109.33 107.24,109.6 106.97,109.71 106.83,109.69 106.7,109.6 106.29,110.02 106.2,110.08 106.11,110.1 105.61,110.1 105.55,110.11 105.49,110.12 105.43,110.11 105.37,110.1 104.59,110.1 104.47,110.17 104.33,110.2 104.19,110.17 104.07,110.1 103.55,110.1 102.98,110.66 103.02,110.76 103.04,110.87 102.93,111.12 102.68,111.22 102.58,111.21 102.48,111.16 97.78,115.86 97.7,115.92 97.6,115.94 91.73,115.94 91.25,116.42 91.25,116.71 91.41,116.85 91.48,117.05 91.41,117.26 91.25,117.4 91.25,125.97 116.14,125.97
+VDDCI on IN3 (solid shape): outline of 260 points within 110.21,97.9 117.61,108.65
+VDDCR_SOC on TOP (solid shape): 129.86,77.96 132.65,77.96 133.07,77.54 133.07,74.07 132.54,73.53 132.52,73.52 132.5,73.52 128.76,73.52 128.71,73.47 128.69,73.46 128.16,73.46 127.93,73.69 127.93,74.26 127.95,74.28 127.95,78.09 128.2,78.35 129.47,78.35
+VDDCR_SOC on TOP (solid shape): outline of 3595 points within 70.17,59.08 91.39,83.17
+VDDCR_SOC on BOTTOM (solid shape): 122.01,81.22 122.14,81 122.44,80.91 122.83,80.53 122.83,80.43 122.86,80.34 122.95,80.31 123.18,80.31 123.21,80.29 123.25,80.26 123.7,80.26 123.95,80.5 124.76,80.5 125,80.26 125.2,80.26 125.2,80.25 125.86,80.1 126.53,80.04 127.2,80.1 127.86,80.25 127.86,80.26 129.12,80.26 129.24,80.13 129.24,78.91 130.03,78.12 132.75,78.12 132.99,77.88 132.99,74.44 131.96,73.41 129.24,73.41 129.06,73.59 125.37,73.59 123.87,75.1 123.87,79.36 119.11,79.36 119.11,77.96 114.74,77.96 114.11,78.6 114.11,80.02 114.92,80.84 114.92,81.19 115,81.27 122.01,81.27
+VDDCR_SOC on IN1 (solid shape): outline of 1671 points within 86.8,56.67 93.49,65.84
+VDDCR_SOC on IN2 (solid shape): outline of 4490 points within 86.16,59.03 129.35,82.14
+VDDCR_SOC on SVCC (solid shape): outline of 344 points within 82.1,58.41 130.62,80.38
+VDDQ on TOP (solid shape): 30.03,64.93 30.82,64.93 30.95,64.81 30.95,63.94 30.92,63.92 29.09,63.92 28.74,64.27 28.74,65.04 28.99,65.29 29.68,65.29
+VDDQ on IN1 (solid shape): outline of 1213 points within 27.32,30.19 49.44,92.7
+VDDQ_VTT on TOP (solid shape): 49.25,31.87 49.25,30.36 49.13,30.24 47.23,30.24 47.23,30.25 47.23,31.5 47.25,31.57 47.32,31.6 47.38,31.61 48.1,31.61 48.15,31.6 48.19,31.6 48.23,31.6 48.27,31.61 48.46,31.61 48.59,31.75 48.59,31.92 48.71,32.03 49.09,32.03
