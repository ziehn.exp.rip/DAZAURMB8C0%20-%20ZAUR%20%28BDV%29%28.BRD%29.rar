# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_PARITY: length 145.1
  TOP w0.102: v1(33.3,86.13) 32.57,86.86 32.57,87.62 31.05,89.14 30.41,89.14 30.32,89.24 R115.2
  TOP w0.165: v1(32.68,49.77) 33.23,50.33 U9.T3 ; U6.T3 33.44,73.24 v1(32.65,73.24) ; U12.T3 32.93,38.95 v1(32.8,38.85) ; U5.T3 v1(33.3,86.13)
  IN1 w0.089: v1(33.3,86.13) 33.08,85.92 33.08,82.28 32.45,81.65 32.45,80.38 32.83,80 32.83,77.58 32.45,77.2 32.45,74.71 33.08,74.08 33.08,73.68 v1(32.65,73.24) 32.45,73.04 32.45,66.41 34.99,63.87 34.99,56.12 34.86,55.99 33.21,55.99 33.08,55.87 33.08,55.61 33.21,55.49 34.35,55.49 34.48,55.36 34.48,55.1 34.35,54.98 33.21,54.98 33.08,54.85 33.08,50.18 v1(32.68,49.77) 32.57,49.77 32.32,49.52 32.32,46.85 33.08,46.09 33.08,43.55 33.97,42.66 33.97,41.39 33.21,40.63 33.21,38.21 33.08,38.09 32.83,38.09 32.7,38.21 32.7,38.75 v1(32.8,38.85)
  IN3 w0.133: v1(64.07,60.57) 63.74,60.9 59.65,60.9 58.13,62.41 50.44,62.41 49.38,61.36 41.11,61.36 40.62,60.86 37.72,60.86 33.48,59.11 32.27,57.9 32.27,56.33 30.33,54.39 30.33,53.66 29.48,52.81 29.48,48.04 30.07,47.45 30.07,44.37 30.8,43.63 30.8,42.55 33.23,40.12 33.23,39.28 v1(32.8,38.85)
  BOTTOM w0.089: 78.8,49.61 78.92,49.49 79.6,49.49 U30.AM31
  BOTTOM w0.102: 73.98,50.69 75.07,50.69 75.12,50.74 76.79,50.74 77.82,49.72 78.7,49.72 78.8,49.61
  BOTTOM w0.165: 73.98,50.69 72.34,50.69 68.26,54.77 68.26,56.37 v1(64.07,60.57)
M_B_RAS#: length 155.6
  TOP w0.102: R132.2 v1(31.3,83.43)
  TOP w0.165: U12.L8 37.72,35.36 v1(36.89,35.36) ; U5.L8 38.13,81.35 37.74,81.73 37.74,82.21 37.09,82.86 v1(37.09,83.24) ; U6.L8 37.73,70.32 v1(36.92,70.32) ; v1(36.92,46.72) 37.73,46.72 U9.L8
  IN2 w0.089: v1(37.09,83.24) 37.09,81.35 37.18,81.27 37.39,81.27 37.52,81.14 37.52,77.2 37.28,76.96 37.28,74.27 37.78,73.77 37.78,73.43 37.53,73.18 37.53,71.83 37.42,71.72 37.42,70.52 37.23,70.32 v1(36.92,70.32) 36.38,69.79 36.38,68.57 36.89,68.06 36.89,59.42 37.02,59.3 38.92,59.3 39.05,59.17 39.05,58.91 38.92,58.79 38.16,58.79 38.03,58.66 38.03,58.41 38.16,58.28 38.92,58.28 39.05,58.15 39.05,53.33 38.03,52.31 38.03,50.16 38.16,50.03 38.16,49.63 37.95,49.42 37.43,49.42 37.23,49.22 37.23,48.95 37.4,48.78 37.4,47.2 v1(36.92,46.72) 36.38,46.19 36.38,44.69 36.51,44.56 37.27,44.56 37.4,44.44 37.4,35.87 37.4,35.86 37.4,34.87 37.31,34.78 36.98,34.78 36.89,34.87 v1(36.89,35.36)
  IN3 w0.089: v1(31.3,83.43) 31.81,82.92 34.03,82.92 34.26,83.15 34.95,83.15 35.34,82.76 36.62,82.76 v1(37.09,83.24)
  IN3 w0.133: v1(62.8,57.9) 62.1,58.6 58.87,58.6 57.77,59.7 51.15,59.7 50.14,58.69 38.16,58.69 36.04,57.81 34.97,56.75 34.97,55.65 34.63,55.3 34.63,54.89 31.86,52.12 31.86,48.73 32.24,48.35 32.24,45.27 32.97,44.53 32.97,43.48 33.92,42.53 34.22,42.53 35.51,41.24 35.51,40.91 36,40.42 36,38.34 36.4,37.94 36.4,36.64 35.72,35.96 35.72,35.17 35.99,34.91 36.45,34.91 v1(36.89,35.36)
  BOTTOM w0.089: 78.8,48.77 78.97,48.77 79.06,48.69 79.38,48.69 79.5,48.81 79.74,48.81 80.06,48.49 U30.AN29
  BOTTOM w0.102: 73.98,49.47 74.15,49.64 76.77,49.64 77.3,49.11 78.38,49.11 78.72,48.77 78.8,48.77
  BOTTOM w0.165: v1(62.8,57.9) 62.8,57.87 63.33,57.34 63.69,57.34 64.58,56.45 64.58,56.03 64.43,55.88 63.58,55.88 63.43,55.74 63.43,55.53 63.58,55.39 64.43,55.39 64.58,55.24 64.58,55.03 64.43,54.89 63.58,54.89 63.43,54.74 63.43,54.54 63.58,54.39 64.43,54.39 64.58,54.25 64.58,51.42 64.93,51.07 70.29,51.07 71.89,49.47 73.98,49.47
M_B_RST#: length 155.1
  TOP w0.102: v2(30.34,54.98) 32.32,54.98 33.88,53.42 34.24,53.42 U9.P1 ; v1(30.54,62.85) 30.67,62.98 44.97,62.98 47.43,65.44 47.43,69.58 51.17,73.32 61.1,73.32 69.12,65.29 69.12,64.92 70.73,63.31 71.87,63.31 73.44,61.73 73.44,61.23 73.62,61.05 74.15,61.05 v2(74.99,60.21) ; v1(30.41,41.77) 34.51,41.77 U12.P1 ; U5.P1 35.73,86.98 34.71,88 v1(34.54,88) ; v1(31.43,75.81) 31.48,75.75 32.4,75.75 32.88,76.24 35.02,76.24 U6.P1
  IN1 w0.089: v1(30.54,62.85) 30.03,62.34 30.03,61.33 30.92,60.44 30.92,53.2 30.54,52.82 30.54,41.9 v1(30.41,41.77) 29.91,42.28 29.91,52.94 30.34,53.38 v2(30.34,54.98) 30.34,59.88 29.14,61.07 29.14,62.85 30.16,63.87 30.16,69.51 29.14,70.52 29.14,71.36 31.43,73.65 v1(31.43,75.81) 31.43,75.88 30.8,76.52 30.8,81.39 31.81,82.41 31.81,86.73 33.09,88 v1(34.54,88)
  BOTTOM w0.102: v2(74.99,60.21) 76.16,59.04 76.52,59.04 78.05,57.51 78.69,57.51 U30.AC32
M_B_WE#: length 156.8
  TOP w0.102: R111.2 v1(37.15,89.52)
  TOP w0.165: v1(37.73,49.9) 37.73,50.73 U9.L2 ; U5.L2 v1(37.73,85.71) ; v1(37.93,72.88) 37.76,73.06 37.76,74.36 U6.L2 ; U12.L2 37.74,39.37 37.74,37.81 v1(37.93,37.58)
  IN1 w0.089: v1(37.73,85.71) 37.73,83.24 36.89,82.41 36.89,82.03 37.01,81.91 37.39,81.91 37.65,81.65 37.65,78.6 38.16,78.09 38.16,73.11 v1(37.93,72.88) 37.71,72.88 37.4,72.58 37.4,71.87 37.56,71.71 37.56,70.57 38.54,69.58 38.54,68.1 38.03,67.59 38.03,64.63 38.16,64.5 39.3,64.5 39.43,64.38 39.43,64.12 39.3,63.99 38.16,63.99 38.03,63.87 38.03,63.61 38.16,63.49 39.34,63.49 39.43,63.4 39.43,52.69 38.67,51.93 38.67,50.02 38.42,49.77 37.86,49.77 v1(37.73,49.9) 37.73,49.84 37.02,49.14 37.02,48.37 37.56,47.83 37.56,46.69 38.16,46.09 38.16,44.06 38.03,43.93 38.03,40.63 37.53,40.12 37.53,37.46 37.62,37.37 37.84,37.37 37.93,37.46 v1(37.93,37.58)
  IN3 w0.089: v1(37.73,85.71) 37.15,86.29 v1(37.15,89.52)
  IN3 w0.133: v1(37.93,37.58) 37.93,37.81 37.01,38.73 37.01,42.8 35.72,44.09 35.72,46.62 35.26,47.08 34.6,47.08 34.48,47.19 34.48,47.37 34.6,47.48 34.82,47.48 34.94,47.6 34.94,48.04 34.86,48.12 34.39,48.12 34.28,48.24 34.28,48.41 34.39,48.53 34.79,48.53 34.89,48.63 34.89,48.77 34.61,49.05 34.61,49.37 35.11,49.88 35.11,50.02 34.99,50.15 34.99,50.41 35.09,50.51 35.56,50.51 35.66,50.61 35.66,50.82 35.54,50.94 34.98,50.94 34.86,51.05 34.86,51.22 34.98,51.34 35.54,51.34 35.66,51.45 35.66,51.62 35.54,51.74 34.98,51.74 34.86,51.85 34.86,52.02 34.98,52.14 35.54,52.14 35.66,52.25 35.66,52.46 35.54,52.58 35.28,52.58 35.16,52.7 35.16,52.86 35.28,52.98 35.91,52.98 36.02,53.09 36.02,53.26 35.87,53.41 35.87,53.57 36,53.7 36.16,53.7 36.31,53.55 36.48,53.55 36.61,53.68 36.61,54.72 37.53,55.64 37.53,56.32 37.78,56.57 38.39,56.82 50.84,56.82 51.34,57.32 54.98,57.32 55.15,57.49 57.42,57.49 58.12,56.79 58.8,56.79 58.92,56.68 58.92,56.47 59.04,56.35 59.2,56.35 59.32,56.47 59.32,56.68 59.44,56.79 59.6,56.79 59.72,56.68 59.72,56.47 59.84,56.35 60,56.35 60.12,56.47 60.12,56.68 60.24,56.79 60.4,56.79 60.52,56.68 60.52,56.47 60.64,56.35 60.8,56.35 60.92,56.47 60.92,56.68 61.04,56.79 61.21,56.79 61.39,56.61 61.39,56.29 62.03,55.64 65.77,55.64 68.36,53.05 72.46,53.05 73.73,51.79 73.9,51.79 74.38,52.27 74.57,52.27 74.69,52.15 74.69,52.01 74.18,51.5 74.18,51.34 74.3,51.22 74.46,51.22 74.97,51.73 75.14,51.73 75.26,51.61 75.26,51.45 74.74,50.94 74.74,50.77 74.88,50.63 75.07,50.63 75.37,50.94 75.56,50.94 75.69,50.81 75.69,50.62 75,49.93 75,49.79 75.12,49.67 75.28,49.67 75.93,50.32 76.1,50.32 76.21,50.2 76.21,50.03 75.43,49.25 75.43,49.08 75.54,48.96 75.71,48.96 76.52,49.78 76.69,49.78 77.43,49.03 77.43,48.83 77.3,48.7 77.07,48.7 76.64,49.14 76.46,49.14 76.08,48.76 76.08,48.56 v2(76.33,48.31)
  BOTTOM w0.089: 78.8,47.47 78.82,47.49 79.6,47.49 U30.AP31
  BOTTOM w0.102: 78.8,47.47 76.34,47.47 76.01,47.8 76.01,47.99 v2(76.33,48.31)
M_TEST: length 10.7
  IN3 w0.102: v1(82.97,78.22) 82.99,78.19 82.99,78.09 83.25,77.84 83.25,73.4 82.48,72.64 82.48,71.36 82.18,71.05 v2(82.18,69.49)
  BOTTOM w0.102: v1(82.97,78.22) 82.74,78.22 TP57.1
  BOTTOM w0.112: v2(82.18,69.49) 82.51,69.16 U30.H26
MAA0_0: length 24.5
  TOP w0.102: 122.52,104.96 120.43,104.96 v1(120.02,105.37)
  TOP w0.127: 122.52,104.96 123.2,104.96 123.76,105.52 128.71,105.52 132.72,109.53 139.83,109.53 v1(140.78,108.58)
  BOTTOM w0.102: U25.G25 119.6,105.79 v1(120.02,105.37)
  BOTTOM w0.127: v1(140.78,108.58) 141.18,108.18 VRAM1.H4
MAA0_1: length 26.2
  TOP w0.102: 119.7,105.8 v1(119.31,105.42)
  TOP w0.127: v1(141.58,109.38) 140.41,110.55 132.13,110.55 128.56,106.97 123.46,106.97 122.29,105.8 121.09,105.8 120.99,105.9 119.8,105.9 119.7,105.8
  BOTTOM w0.102: U25.H25 118.81,105.92 v1(119.31,105.42)
  BOTTOM w0.127: VRAM1.H5 v1(141.58,109.38)
MAA0_2: length 25.3
  TOP w0.102: 120.71,106.92 v1(120.25,106.46)
  TOP w0.127: 120.71,106.92 122.16,106.92 123.55,108.32 128.28,108.32 131.53,111.56 139.43,111.56 140.16,112.29 v1(140.16,112.45)
  BOTTOM w0.102: U25.E27 120.4,106.61 v1(120.25,106.46)
  BOTTOM w0.127: v1(140.16,112.45) 139.97,112.64 139.97,113.11 140.25,113.39 140.79,113.39 VRAM1.H11
MAA0_3: length 24.1
  TOP w0.102: 122.22,106.37 121.88,106.03 121.42,106.03 v1(120.99,106.46)
  TOP w0.127: v1(141.01,112.42) 139.64,111.05 131.92,111.05 128.22,107.35 123.2,107.35 122.22,106.37
  BOTTOM w0.102: U25.D27 121.2,106.67 v1(120.99,106.46)
  BOTTOM w0.127: v1(141.01,112.42) 141.01,112.43 141.19,112.61 141.19,112.98 VRAM1.H10
MAA0_4: length 22.3
  TOP w0.102: v1(120.86,107.61) 121.26,108 121.96,108
  TOP w0.127: 121.96,108 122.23,108 123.54,109.31 124.67,109.31 125.49,110.12 128.92,110.12 131.89,113.09 138.04,113.09 v1(139.14,114.18)
  BOTTOM w0.102: v1(120.86,107.61) 121.2,107.94 U25.D29
  BOTTOM w0.127: VRAM1.K11 139.18,114.18 v1(139.14,114.18)
MAA0_5: length 24.5
  TOP w0.102: v1(119.31,106.41) 119.62,106.41 120.36,107.15
  TOP w0.127: 120.36,107.15 121.88,107.15 123.66,108.93 124.8,108.93 125.63,109.76 126.93,109.76 127.48,109.22 128.68,109.22 131.53,112.07 139.09,112.07 v1(139.47,112.45)
  BOTTOM w0.102: v1(119.31,106.41) 118.8,106.92 U25.H27
  BOTTOM w0.127: VRAM1.K10 139.58,112.56 v1(139.47,112.45)
MAA0_6: length 24.4
  TOP w0.102: 129.17,103.67 123.28,103.67 123.06,103.88 119.63,103.88 v1(119.31,104.2)
  TOP w0.127: v1(139.16,107.78) 139.16,107.72 138.25,106.82 133.07,106.82 132.44,106.18 132.44,105.49 130.62,103.67 129.17,103.67
  BOTTOM w0.102: v1(119.31,104.2) 118.8,104.71 U25.H23
  BOTTOM w0.127: v1(139.16,107.78) 139.21,107.83 139.21,108.34 139.58,108.71 VRAM1.K5
MAA0_7: length 22.8
  TOP w0.102: v1(120.72,104.3) 121.18,104.76 122.03,104.76 122.11,104.69 123.38,104.69
  TOP w0.127: v1(139.98,108.58) 139.51,109.05 132.82,109.05 128.33,104.56 123.51,104.56 123.38,104.69
  BOTTOM w0.102: v1(120.72,104.3) 120.4,104.62 U25.E23
  BOTTOM w0.127: v1(139.98,108.58) 139.58,108.18 VRAM1.K4
MAA0_8: length 22.8
  TOP w0.102: 121.45,105.47 v1(121.35,105.37)
  TOP w0.127: 121.45,105.47 122.85,105.47 123.25,105.88 128.41,105.88 132.57,110.04 140.12,110.04 v1(140.78,109.38)
  BOTTOM w0.102: U25.D25 121.2,105.51 v1(121.35,105.37)
  BOTTOM w0.127: VRAM1.J5 140.38,108.98 v1(140.78,109.38)
MAA1_0: length 29.2
  TOP w0.102: v1(120.76,99.89) 120.76,99.68 121,99.44 122.32,99.44 123.96,97.8 124.47,97.8 125.21,97.06 125.21,96.33 126.02,95.52 129.53,95.52
  TOP w0.127: v1(141.58,90.99) 139.98,89.39 138.02,89.39 137.66,89.75 136.6,89.75 136.08,90.27 136.08,90.92 135.32,91.68 134.81,91.68 134.35,92.14 132.73,92.14 131.9,92.97 131.9,94.97 131.35,95.52 129.53,95.52
  BOTTOM w0.102: v1(120.76,99.89) 120.4,100.24 U25.E15
  BOTTOM w0.127: VRAM2.K4 v1(141.58,90.99)
MAA1_1: length 30.5
  TOP w0.102: 128.99,95.24 125.84,95.24 124.95,96.13 124.95,96.96 124.37,97.55 123.89,97.55 122.19,99.24 120.8,99.24 120.34,99.71 120.34,100.02 120.11,100.24 119.55,100.24 v1(119.24,99.93)
  TOP w0.127: 128.99,95.24 129.22,95.01 130.84,95.01 131.54,94.31 131.54,92.62 132.43,91.73 133.58,91.73 133.94,91.38 133.94,90.81 134.98,89.76 136.08,89.76 136.45,89.39 137.52,89.39 137.87,89.04 140.36,89.04 v1(141.26,89.95)
  BOTTOM w0.102: v1(119.24,99.93) 118.8,100.37 U25.H15
  BOTTOM w0.127: v1(141.26,89.95) 141.26,90.51 VRAM2.K5
MAA1_2: length 29.2
  TOP w0.102: 128.26,94.6 125.72,94.6 122.15,98.17 121.34,98.17 121.13,98.38 120.55,98.38 v1(120.13,98.79)
  TOP w0.127: v1(140.82,87.26) 139.75,88.33 137.58,88.33 137.22,88.68 136.15,88.68 135.78,89.05 134.69,89.05 134.22,89.52 132.78,89.52 132.27,90.03 132.27,90.88 130.83,92.32 130.83,93.81 130.64,94 128.86,94 128.26,94.6
  BOTTOM w0.102: U25.G13 v1(120.13,98.79)
  BOTTOM w0.127: v1(140.82,87.26) 140.82,86.15 141.17,85.79 VRAM2.K11
MAA1_3: length 28.4
  TOP w0.102: v1(120.93,98.78) 121.01,98.78 121.42,98.37 122.63,98.37 123.66,97.34 124.17,97.34 124.7,96.81 124.7,95.97 125.77,94.91 128.56,94.91
  TOP w0.127: v1(141.45,87.23) 141.29,87.39 141.29,87.57 140.18,88.68 137.73,88.68 137.37,89.04 136.3,89.04 135.93,89.41 134.83,89.41 133.54,90.7 133.54,91.02 133.18,91.38 132.28,91.38 131.19,92.47 131.19,94.03 130.71,94.5 128.96,94.5 128.56,94.91
  BOTTOM w0.102: v1(120.93,98.78) 121.2,99.06 U25.D13
  BOTTOM w0.127: v1(141.45,87.23) 141.18,86.95 VRAM2.K10
MAA1_4: length 28.4
  TOP w0.102: v1(119.19,97.15) 120.47,97.15 120.68,96.95 122.35,96.95 124.52,94.78
  TOP w0.127: v1(139.17,85.4) 138.59,84.82 136.76,84.82 136.08,85.51 136.08,86.22 135.62,86.68 134.16,86.68 133.67,87.18 133.67,87.32 133.12,87.87 132.49,87.87 130.87,89.49 130.87,90.34 129.71,91.5 127.32,91.5 124.52,94.3 124.52,94.78
  BOTTOM w0.102: v1(119.19,97.15) 118.8,97.54 U25.H11
  BOTTOM w0.127: v1(139.17,85.4) 139.19,85.4 VRAM2.H11
MAA1_5: length 28.2
  TOP w0.102: 127.94,94.32 125.66,94.32 122.63,97.36 121.46,97.36 121.21,97.61 121.21,97.91 120.99,98.12 120.23,98.12 119.61,98.74 v1(119.21,98.74)
  TOP w0.127: 127.94,94.32 128.78,93.49 130.21,93.49 130.47,93.22 130.47,92.17 131.91,90.74 131.91,89.88 132.84,88.95 134.23,88.95 134.55,88.63 135.7,88.63 136.08,88.25 137.09,88.25 137.37,87.97 138.99,87.97 v1(139.91,87.05)
  BOTTOM w0.102: U25.H13 118.8,99.15 v1(119.21,98.74)
  BOTTOM w0.127: v1(139.91,87.05) 139.58,86.72 VRAM2.H10
MAA1_6: length 28.6
  TOP w0.102: 126.06,97 124.73,98.33 124.24,98.33 122.24,100.34 120.3,100.34 120.19,100.45 119.71,100.45 v1(119.28,100.87)
  TOP w0.127: 126.06,97 129.51,97 129.58,97.06 134.14,97.06 134.26,96.94 134.26,96.52 134.17,96.43 133.54,96.43 133.45,96.34 133.45,95.97 134.49,94.93 136.64,94.93 136.89,94.68 136.89,94.05 137.48,93.46 137.48,92.37 138.4,91.44 138.73,91.44 v1(139.18,90.99)
  BOTTOM w0.102: U25.H17 118.8,101.35 v1(119.28,100.87)
  BOTTOM w0.127: VRAM2.H5 v1(139.18,90.99)
MAA1_7: length 28.7
  TOP w0.102: 125.9,97.94 124.27,99.58 123.43,99.58 122.47,100.54 120.39,100.54 120.07,100.85 v1(119.96,100.85)
  TOP w0.127: v1(139.98,90.99) 140.27,91.28 140.27,91.78 139.97,92.09 138.26,92.09 137.94,92.41 137.94,94.57 137.11,95.39 134.91,95.39 134.74,95.55 134.74,97.45 134.62,97.57 129.63,97.57 129.26,97.94 125.9,97.94
  BOTTOM w0.102: v1(119.96,100.85) 119.96,101.16 U25.G17
  BOTTOM w0.127: VRAM2.H4 v1(139.98,90.99)
MAA1_8: length 26.8
  TOP w0.102: v1(121.39,99.85) 122.32,99.85 124.12,98.06 124.62,98.06 126.12,96.56
  TOP w0.127: 126.12,96.56 132.24,96.56 132.5,96.3 132.5,96.13 132.18,95.81 132.18,95.63 132.36,95.45 132.54,95.45 132.86,95.77 133.03,95.77 134.94,93.86 134.94,93.08 134.68,92.82 134.68,92.46 135.08,92.06 136.61,92.06 137.84,90.83 138.45,90.83 138.62,90.66 138.62,90.03 138.9,89.75 139.54,89.75 v1(139.98,90.19)
  BOTTOM w0.102: v1(121.39,99.85) 121.2,100.04 U25.D15
  BOTTOM w0.127: VRAM2.J5 v1(139.98,90.19)
MAIND: length 255.6
  TOP w0.102: v1(28.59,34.28) v1(27.87,34.28)
  TOP w0.254: v1(27.87,34.28) 27.79,34.2 PQ8.2
  IN3 w0.254: v1(26.86,70.6) 27.62,71.36 27.62,72.5 28.76,73.65 28.76,76.59 29.98,77.81 29.98,78.88 29.68,79.18 29.68,93.31 34.56,98.18 41.77,98.18 43.57,96.38 46.75,96.38 47.03,96.66 52.49,96.66 53.78,95.36 57.85,95.36 60.3,92.91 64.21,92.91 65.82,91.3 66.86,91.3 69.02,89.14 v1(69.02,88) ; v1(79.06,15.18) 79.06,14.97 79.94,14.08 81.6,14.08 84.34,11.34 88.12,11.34 90.38,13.59 90.38,17.78 91.23,18.64 92.66,18.64 93.86,17.44 99.33,17.44 99.76,17 103.82,17 104.71,17.89 104.71,19.67 106.11,21.07 107.5,21.07 109.66,23.23 109.66,26.66 111.06,28.05 111.69,28.05 112.96,29.32 v1(113.02,29.32)
  BOTTOM w0.254: v1(79.06,15.18) 78.73,14.85 73.47,14.85 72.5,13.88 61.61,13.88 60.51,14.97 60.51,19.65 60.93,20.06 60.93,21.55 60.01,22.48 60.01,23.23 58.35,24.88 53.15,24.88 51.67,26.35 49.64,26.35 49.34,26.66 36.16,26.66 35.27,27.55 31.72,27.55 31.3,27.96 31.3,29.61 28.38,32.53 28.38,33.77 v1(27.87,34.28) 26.48,34.28 26.1,34.66 26.1,69.84 v1(26.86,70.6) ; PQ26.2 PQ24.3 68.64,87.62 v1(69.02,88) 69.29,88.26 PC184.1 69.29,89.64 69.02,89.9 PR211.2 ; PQ34.4 124.94,37.67 124.33,38.28 124.33,39.04 123.86,39.51 120.48,39.51 120.25,39.28 120.25,34.45 119.95,34.15 115.12,34.15 113.02,32.04 v1(113.02,29.32)
MAINON: length 434
  TOP w0.203: v1(192.11,24.1) 192.08,24.13 PR102.1 ; v1(160.34,13.45) 160.34,13.6 162.12,15.38 R384.1 163.65,15.38 164.57,16.3 164.57,16.41 164.71,16.56 U15.30 ; PR87.2 140.78,27.88 v1(141.36,27.29)
  TOP w0.254: PR83.2 26.83,29.99 25.72,31.1 25.72,33.01 26.22,33.51 v1(27.87,33.51) ; v1(30.29,98.54) 31.56,97.27 41.84,97.27 42.73,96.38 46.8,96.38 50.1,93.08 50.1,92.7 51.62,91.17 58.1,91.17 59.62,89.65 61.28,89.65 62.04,88.89 66.99,88.89 v1(69.86,91.76) ; PR112.2 v1(50.07,21.04) 50.89,21.86 50.89,23.51 v1(50.99,23.61)
  IN1 w0.254: v1(69.96,125.58) 69.96,125.26 69.53,124.83 65.97,124.83 65.21,124.07 65.21,120.76 66.56,119.42 66.56,114.87 65.59,113.91 63.43,113.91 59.24,109.71 59.24,108.32 58.74,107.81 57.44,107.81 57.08,107.45 51.81,107.45 50.13,105.78 49.62,105.78 49.36,105.52 48.58,105.52 48.32,105.27 47.69,105.27 47.31,104.89 47.31,103.75 46.29,102.73 45.15,102.73 44.72,102.3 44.72,101.31 44.11,100.7 44.11,100.08 44.37,99.82 44.37,98.77 43.9,98.3 30.52,98.3 v1(30.29,98.54) ; v1(191.98,18.66) 192.59,18.05 192.59,17.64 190.69,15.73 189.32,15.73 186.41,12.83 183.32,12.83 182.94,13.21 182.94,15.23 182.43,15.73 181.8,15.73 179.49,13.42 168.06,13.42 167.57,12.94 161.33,12.94 160.84,13.42 160.36,13.42 v1(160.34,13.45)
  IN2 w0.254: v1(141.36,27.29) 141.11,27.29 139.08,25.27 131.02,25.27 130.69,24.94 124.07,24.94 v1(122.87,23.74) 122.52,23.38 119.92,23.38 119.54,23.76 115.3,23.76 114.54,23 108.67,23 107.45,21.78 105.52,21.78 104.58,22.72 103.69,22.72 102.93,21.96 99.4,21.96 99.15,22.21 94.84,22.21 91.67,25.39 88.12,25.39 87.39,24.65 76.54,24.65 75.91,25.28 74,25.28 72.69,23.97 70.78,23.97 70.04,23.23 67.83,23.23 67.32,23.74 66.74,23.74 66.48,23.48 65.21,23.48 64.83,23.1 63.18,23.1 62.67,23.61 59.62,23.61 58.99,22.97 56.32,22.97 55.69,23.61 v1(50.99,23.61) ; v1(134.43,19.29) 135.22,18.5 141.11,18.5 142.53,19.93 145.29,19.93 145.86,19.36 147.68,19.36 149.79,17.26 151.32,17.26 151.7,16.88 151.7,16.24 152.33,15.61 158.81,15.61 160.02,14.4 160.02,14.2 160.21,14.01 160.21,13.46 160.24,13.42 160.31,13.42 v1(160.34,13.45)
  IN3 w0.254: v1(26.86,71.36) 26.86,72.5 28.26,73.9 28.26,93.9 29.37,95.02 29.37,97.62 v1(30.29,98.54) ; v1(191.98,18.66) 191.7,18.93 191.7,23.69 v1(192.11,24.1)
  BOTTOM w0.203: v1(69.96,125.58) 69.9,125.52 PR122.1
  BOTTOM w0.254: v1(50.99,23.61) 50.99,23.86 48.7,26.15 43.11,26.15 42.35,25.39 36.89,25.39 35.11,27.16 31.56,27.16 30.92,27.8 30.92,29.45 27.87,32.5 v1(27.87,33.51) 27.49,33.9 26.32,33.9 25.72,34.5 25.72,70.22 v1(26.86,71.36) ; v1(122.87,23.74) 122.87,20.31 123.89,19.29 127.57,19.29 127.95,19.67 134.05,19.67 v1(134.43,19.29) ; v1(141.36,27.29) 141.36,27.37 141.79,27.8 143.44,27.8 143.7,27.55 145.38,27.55 145.93,28.1 151.04,28.1 151.47,28.54 PR335.2 ; PQ21.2 72.06,89.79 71.31,90.54 PR205.1 70.16,91.46 v1(69.86,91.76)
MAINON_ON_G: length 136.7
  TOP w0.254: v1(129.98,40.37) 130.24,40.37 130.26,40.4 131.74,40.4 132.73,39.4 132.73,39.37 133.19,38.91 PQ6.2
  IN3 w0.254: v1(129.98,40.37) 129.42,40.37 128.76,41.03 126.66,41.03 125.54,42.15 125.54,45.83 124.39,46.98 124.39,62.6 125.81,64.01 125.81,66.94 126.11,67.24 126.11,72.46 125.13,73.44 118.61,73.44 117.92,74.14 117.92,77 117.49,77.43 116.01,77.43 111.92,81.52 111.16,81.52 109.99,82.69 109.99,88.68 v1(109.33,89.34)
  BOTTOM w0.254: v1(109.33,89.34) 104.3,89.34 103.44,90.21 94.75,90.21 93.66,91.3 91.5,91.3 90.61,90.41 81.34,90.41 80.66,91.1 80.05,91.1 79.77,90.82 79.77,90.33 78.83,89.39 78.22,89.39 77.19,90.42 PQ20.2 76.81,89.23 76.17,88.59 PR210.1 74.91,88.59 74.36,89.14 PQ21.3 71.53,89.14 70.93,88.54 PR212.2 70.8,87.24 70.99,87.04 PQ25.2 70.99,84.13 70.29,83.43 67.63,83.43 66.64,84.41 PQ24.2 65.79,85.05 62.72,85.05 61.87,85.9 PQ23.2 61.31,86.25 61.53,86.47 62.04,86.47 62.62,87.06 62.62,88.81 62.5,88.94 62.5,90.23 63.28,91.01 PQ19.2
MBCLK: length 94.3
  TOP w0.102: R250.1 174.18,31.96 174.18,30.85 174.42,30.61 U15.110 174.42,28.98 174.2,28.76 174.2,28.31 174.59,27.93 v1(174.64,27.93) ; v1(102.26,22.47) 102.26,21.83 PC126.1 102.18,21.33 102.29,21.22 PR107.2 103.11,21.66 103.21,21.76 103.52,21.76 103.85,22.08 103.85,22.49 104,22.64 105.35,22.64 105.48,22.52 PD4.1
  IN2 w0.089: v1(174.64,27.93) 174.23,27.52 171.8,27.52 171.09,28.23 171.09,28.56 170.6,29.04 169.38,29.04 169.2,29.22 164.37,29.22 163.38,28.23 157.22,28.23 156.58,28.88 153.99,28.88 152.84,27.72 144.17,27.72 143.68,28.21 142.79,28.21 142.28,27.7 141.06,27.7 140.57,27.21 v1(140.09,27.21) 140.09,26.86 138.78,25.55 130.92,25.55 130.57,25.21 123.76,25.21 122.34,23.79 121.04,23.79 120.48,24.34 119.8,24.34 119.51,24.05 115.19,24.05 114.41,23.28 108.44,23.28 107.22,22.06 105.88,22.06 104.84,23.1 102.89,23.1 v1(102.26,22.47)
  BOTTOM w0.102: v1(140.09,27.21) v1(139.08,28.23) 139.08,30.26 138.87,30.47 138.64,30.47 138.42,30.69 138.42,30.92 138.1,31.24 PR327.1
MBDATA: length 85.6
  TOP w0.102: R270.1 173.9,30.75 174.02,30.63 U15.111 174.02,29.03 173.95,28.97 173.95,28.74 v1(173.77,28.56) ; v1(106.87,22.47) 106.5,22.09 PD3.1 105.72,21.1 105.42,20.8 PC127.1 105.37,20.75 105.34,20.72 PR106.2
  IN2 w0.089: v1(173.77,28.56) 173.09,27.88 171.72,27.88 171.28,28.31 171.28,28.63 170.66,29.25 169.44,29.25 169.28,29.41 164.3,29.41 163.32,28.43 160.41,28.43 159.52,29.32 157.16,29.32 156.91,29.07 153.91,29.07 152.77,27.93 144.23,27.93 143.76,28.4 142.71,28.4 142.21,27.9 140.13,27.9 v1(140.09,27.86) 139.69,27.46 139.69,26.83 138.59,25.74 130.84,25.74 130.51,25.41 123.68,25.41 122.26,23.99 121.12,23.99 120.56,24.55 119.77,24.55 119.16,25.16 115.97,25.16 114.3,23.48 108.27,23.48 107.25,22.47 v1(106.87,22.47)
  BOTTOM w0.102: PR325.1 138.5,31.95 139.33,31.13 139.33,28.62 v1(140.09,27.86)
MDI0+: length 18.8
  TOP w0.102: U2.1 42.1,106.8 v1(41.57,107.32)
  IN1 w0.089: v1(30.18,104.35) 30.18,104.71 29.69,105.2 29.69,105.75 30.1,106.16 31.05,106.16 31.86,105.35 32.19,105.35 33.01,106.16 40.03,106.16 40.13,106.26 40.13,106.44 39.75,106.82 39.75,107.23 40.18,107.66 40.98,107.66 41.34,107.29 41.55,107.29 v1(41.57,107.32)
  BOTTOM w0.102: U24.9 29.9,104.07 v1(30.18,104.35)
MDI0+_1: length 24.8
  IN2 w0.089: CN3.1 13.22,99.77 13.52,100.07 16.33,100.07 24.45,108.19 29.04,108.19 30.23,109.38 30.23,109.45 v1(29.96,109.72)
  BOTTOM w0.102: U24.16 29.9,110.96 30.2,110.66 30.2,109.96 v1(29.96,109.72)
MDI0-: length 18.8
  TOP w0.102: U2.2 41.63,106.4 41.56,106.47 v1(41.56,106.68)
  IN1 w0.089: v1(30.9,104.38) 30.69,104.38 30.55,104.53 30.55,104.86 30.06,105.35 30.06,105.6 30.25,105.79 30.9,105.79 31.71,104.98 32.35,104.98 33.16,105.79 40.18,105.79 40.5,106.11 40.5,106.59 40.12,106.97 40.12,107.07 40.33,107.29 40.83,107.29 41.19,106.93 41.46,106.93 41.56,106.83 v1(41.56,106.68)
  BOTTOM w0.102: U24.8 30.9,103.98 31.08,104.15 31.08,104.28 30.97,104.38 v1(30.9,104.38)
MDI0-_1: length 24.8
  IN2 w0.089: v1(30.6,109.72) 30.6,109.23 29.19,107.82 24.6,107.82 16.48,99.71 13.68,99.71 13.45,99.48 CN3.2
  BOTTOM w0.102: U24.17 30.9,110.96 30.6,110.66 v1(30.6,109.72)
MDI1+: length 19.1
  TOP w0.102: v1(40.57,105.37) 40.8,105.59 42.54,105.59 U2.4
  IN3 w0.089: v1(40.57,105.37) 40.57,104.86 40.19,104.48 39.03,104.48 38.42,103.87 37.57,103.87 37.17,103.47 28.71,103.47 28.48,103.24 27.39,103.24 26.99,103.64 v1(26.99,104.38)
  BOTTOM w0.102: v1(26.99,104.38) 26.99,104.1 26.9,104.01 U24.12
MDI1+_1: length 24.8
  TOP w0.102: CN3.3 13.7,97.73 14.67,96.76 14.98,96.76 15.31,97.09 15.31,98.23 21.68,104.6 23.78,104.6 27.1,107.92 27.1,109.59 v1(26.98,109.71)
  BOTTOM w0.102: v1(26.98,109.71) 26.98,109.74 27.12,109.88 27.12,110.74 26.9,110.96 U24.13
MDI1-: length 19.1
  TOP w0.102: v1(39.94,105.37) 39.94,105.17 40.17,104.94 40.88,104.94 41.14,105.2 42.54,105.2 U2.5
  IN3 w0.089: v1(39.94,105.37) 40.09,105.22 40.09,105.06 39.99,104.96 38.83,104.96 38.22,104.35 37.37,104.35 36.97,103.95 28.51,103.95 28.28,103.72 27.59,103.72 27.47,103.84 27.47,104.23 27.62,104.38 v1(27.9,104.38)
  BOTTOM w0.102: v1(27.9,104.38) 27.77,104.38 27.62,104.23 27.62,104.07 27.9,103.8 U24.11
MDI1-_1: length 24.7
  TOP w0.102: CN3.6 15.71,96.93 15.71,98.07 21.85,104.21 23.94,104.21 27.49,107.76 27.49,109.59 v1(27.61,109.71)
  BOTTOM w0.102: v1(27.61,109.71) 27.61,109.74 27.51,109.84 27.51,110.58 27.9,110.96 U24.14
MDI2+: length 10
  TOP w0.102: v1(39.82,103.99) 39.85,103.99 40.45,104.58 41.29,104.58 41.5,104.8 U2.6
  IN1 w0.089: v1(36.62,104.36) 36.46,104.36 36.33,104.48 36.33,104.79 36.43,104.89 36.82,104.89 37.35,104.35 37.88,104.35 38.42,104.89 38.62,104.89 38.95,104.56 39.88,104.56 39.99,104.44 39.99,104.18 39.82,104 v1(39.82,103.99)
  BOTTOM w0.102: v1(36.62,104.36) 36.9,104.08 U24.2
MDI2+_1: length 40.5
  IN1 w0.089: CN3.4 13.45,96.2 13.7,95.95 14.4,95.95 15.19,96.73 15.19,100.11 21.43,106.36 21.43,106.46 20.58,107.32 20.58,107.75 21.04,108.22 21.47,108.22 22.31,107.38 22.46,107.38 22.71,107.64 22.71,107.76 21.93,108.54 21.93,108.97 22.4,109.44 22.83,109.44 23.39,108.88 33.93,108.88 35.43,110.37 36.3,110.37 36.64,110.04 v1(36.64,109.36)
  BOTTOM w0.102: v1(36.64,109.36) 36.57,109.42 36.57,110.64 36.9,110.96 U24.23
MDI2-: length 10
  TOP w0.102: U2.7 42.53,104.4 41.66,104.4 41.45,104.19 40.71,104.19 v1(40.52,104)
  IN1 w0.089: v1(35.9,104.38) 35.96,104.44 35.96,104.94 36.28,105.26 36.97,105.26 37.5,104.72 37.73,104.72 38.26,105.26 38.77,105.26 39.1,104.93 40.03,104.93 40.36,104.6 40.36,104.16 v1(40.52,104)
  BOTTOM w0.102: U24.3 v1(35.9,104.38)
MDI2-_1: length 40.5
  IN1 w0.089: CN3.5 13.44,95.69 13.55,95.58 14.55,95.58 15.56,96.58 15.56,99.96 21.8,106.21 21.8,106.61 20.94,107.47 20.94,107.6 21.2,107.85 21.32,107.85 22.15,107.01 22.61,107.01 23.08,107.48 23.08,107.91 22.3,108.7 22.3,108.82 22.55,109.07 22.67,109.07 23.24,108.51 34.09,108.51 35.58,110.01 36.15,110.01 36.27,109.89 36.27,109.62 v1(36,109.36)
  BOTTOM w0.102: v1(36,109.36) 36,109.38 36.18,109.56 36.18,110.68 35.9,110.96 U24.22
MDI3+: length 17.5
  TOP w0.102: U2.9 43.24,102.73 42.35,101.84 41.67,101.84 40.82,100.99 40.82,100.73 40.53,100.44 39.81,100.44 39.7,100.55 39.7,101.42 v1(39.75,101.47)
  IN1 w0.089: v1(39.75,101.47) 39.56,101.66 39.56,102.88 38.84,103.61 35.2,103.61 34.81,104 34.81,104.84 34.38,105.27 33.77,105.27 33.35,104.86 33.35,104.58 v1(33.18,104.4)
  BOTTOM w0.102: v1(33.18,104.4) 32.9,104.12 U24.6
MDI3+_1: length 32.8
  IN3 w0.089: CN3.7 13.79,93.65 15.58,95.44 15.58,100.37 24.42,109.21 32.73,109.21 32.96,109.44 v1(32.96,110)
  BOTTOM w0.102: U24.19 32.9,111.09 33.15,110.84 33.15,110.19 v1(32.96,110)
MDI3-: length 17.5
  TOP w0.102: v1(39.11,101.47) 39.31,101.28 39.31,100.39 39.65,100.05 40.69,100.05 41.21,100.57 41.21,100.82 41.83,101.45 42.52,101.45 43.63,102.56 43.63,102.64 43.64,102.65 U2.10
  IN1 w0.089: v1(39.11,101.47) 39.19,101.55 39.19,102.73 38.68,103.24 35.05,103.24 34.44,103.85 34.44,104.68 34.22,104.9 33.92,104.9 33.72,104.7 33.72,104.58 33.9,104.4 v1(33.9,104.38)
  BOTTOM w0.102: v1(33.9,104.38) U24.5
MDI3-_1: length 32.8
  IN3 w0.089: CN3.8 16.06,95.24 16.06,100.17 24.62,108.72 32.93,108.72 33.44,109.24 33.44,109.85 v1(33.6,110)
  BOTTOM w0.102: v1(33.6,110) 33.54,110.06 33.54,110.76 33.9,111.12 U24.20
MEM_CALRA: length 1.6
  TOP w0.102: R95.2 118.63,99.83 v1(118.58,99.88)
  BOTTOM w0.102: U25.K15 118.54,99.88 v1(118.58,99.88)
MF_A0: length 3.6
  BOTTOM w0.102: VRAM1.J1 140.39,105.77 140.39,102.61 140.44,102.56 R518.2
MF_A1: length 3.7
  BOTTOM w0.102: VRAM2.J1 140.38,94.58 140.57,94.77 R521.2
MIC2-VREFO: length 12.8
  IN2 w0.381: v1(208.85,32.24) 209.1,32.24 209.28,32.07 209.28,29.88 208.65,29.25 208.65,26.48 v1(208.79,26.34)
  BOTTOM w0.203: v1(208.85,32.24) 208.98,32.37 208.98,33.26 R642.1 R632.1 ; v1(208.79,26.34) 208.79,26.44 207.68,27.55 207.3,27.55 207.01,27.26 U35.29
MSATA_DET: length 116.1
  TOP w0.102: v1(28.51,24.24) 28.51,23.41 26.99,21.89 26.99,16.5 26.48,15.99 26.48,13.44 25.39,12.34 25.39,7.56 25.87,7.07 R431.1 v1(25.16,5.19) ; v1(103.06,32.63) 103.06,32.75 102.93,32.88 102.93,35.55 103.69,36.31 104.33,36.31 104.61,36.59 R236.1 104.33,36.82 103.95,37.2 R235.2
  IN1 w0.089: v1(99.53,22.52) 99.55,22.53 99.57,22.53 102.42,25.39 102.42,25.89 102.86,26.33 102.86,29.96 103.47,30.57 103.47,32.22 v1(103.06,32.63)
  IN2 w0.089: v1(28.51,24.24) 28.66,24.09 33.2,24.09 33.74,24.62 35.69,24.62 37.39,22.92 41.11,22.92 43.17,24.98 43.93,24.98 44.56,25.61 48.6,25.61 50.13,24.09 63.06,24.09 63.11,24.14 69.12,24.14 69.68,24.7 72.97,24.7 73.82,25.55 76.02,25.55 76.64,24.93 86.98,24.93 87.74,25.69 91.75,25.69 94.85,22.59 99.45,22.59 v1(99.53,22.52)
MSATA_DET#_R: length 2.7
  TOP w0.102: v1(24.46,9.38) Q26.2 23.88,8.3 23.84,8.34 R425.1 R423.1
MVREFDA: length 2.6
  TOP w0.203: R90.2 R88.1 118.42,101.11 v1(118.59,100.94) 118.71,101.06 C104.1
  BOTTOM w0.381: v1(118.59,100.94) U25.K17
MVREFDB: length 3.9
  TOP w0.102: v1(115,96.61) 114.64,96.25 C128.1
  TOP w0.203: v1(114.82,97.37) 114.82,97.57 114.62,97.78 R101.1 R102.2 C128.1
  BOTTOM w0.203: v1(114.82,97.37) 114.47,97.72 U25.U10
MX0: length 51
  TOP w0.102: v1(171.26,15.35) 172.27,16.37 174.95,16.37 176.27,15.05 177.02,15.05 177.22,14.85 U15.58
  IN2 w0.089: v1(171.26,15.35) 170.85,14.95 165.96,14.95 164.72,16.19 164.72,16.72 164.24,17.19 162.01,17.19 161.6,17.6 156.45,17.6 153.31,20.74 152.33,20.74 151.24,21.83 148.1,21.83 147.22,22.71 v1(147.22,22.87)
  BOTTOM w0.102: v1(171.26,15.35) 170.62,14.72 168.72,14.72 167.65,15.78 166.56,15.78 166,16.34 CN16.10 166,18.22 166.05,18.27 C684.1 ; v1(146.54,27.6) 146.01,27.6 145.07,26.66 CN10.10 145.07,25.02 v1(147.22,22.87)
MX1: length 44.9
  TOP w0.102: U15.59 177.62,14.91 177.25,15.28 176.37,15.28 175.05,16.6 169.88,16.6 v1(168.07,18.41)
  IN2 w0.089: v1(168.07,18.41) 167.33,18.41 166.93,18.81 163.56,18.81 162.98,19.39 160.69,19.39 159.4,18.1 156.23,18.1 153.39,20.93 152.41,20.93 151.32,22.02 150.66,22.02 v1(149.96,22.72)
  BOTTOM w0.102: C685.1 167.54,18.94 v1(168.07,18.41) 167.38,18.41 167,18.03 CN16.9 ; v1(147.81,27.6) 147.38,27.16 146.42,27.16 146.07,26.82 CN10.9 146.07,24.34 147.06,23.35 149.33,23.35 v1(149.96,22.72)
MX2: length 43.4
  TOP w0.102: v1(178.12,12.8) 178.02,12.9 U15.60 178.02,14.84 177.35,15.51 176.46,15.51 175.14,16.83 170.32,16.83 v1(168.72,18.43)
  IN2 w0.089: v1(168.72,18.43) 168.33,18.81 167.2,18.81 167.01,19 163.64,19 163.07,19.58 160.61,19.58 159.32,18.29 156.31,18.29 153.45,21.14 152.47,21.14 151.4,22.21 151.1,22.21 v1(150.6,22.72)
  BOTTOM w0.102: CN10.8 147.07,25.58 146.87,25.39 146.55,25.39 146.3,25.13 146.3,24.44 147.15,23.58 149.73,23.58 v1(150.6,22.72) ; CN16.8 168,17.71 v1(168.72,18.43) 168.72,18.55 168.33,18.94 C686.1
MX3: length 42.6
  TOP w0.102: U15.61 178.42,14.91 178.28,15.05 178.13,15.05 177.45,15.73 176.56,15.73 175.24,17.05 170.78,17.05 v1(169.38,18.45)
  IN2 w0.089: v1(151.23,22.72) 151.24,22.72 152.61,21.35 153.51,21.35 156.38,18.48 159.24,18.48 160.53,19.77 163.16,19.77 163.73,19.19 167.09,19.19 167.28,19 168.83,19 v1(169.38,18.45)
  BOTTOM w0.102: CN10.7 148.07,25.57 147.64,25.13 146.65,25.13 146.53,25.01 146.53,24.53 147.25,23.81 150.14,23.81 v1(151.23,22.72) ; C687.1 169.2,18.94 169.38,18.76 v1(169.38,18.45) 169.38,18.3 169,17.92 CN16.7
MX4: length 39
  TOP w0.102: U15.62 178.82,14.84 178.37,15.28 178.22,15.28 177.54,15.96 176.65,15.96 175.33,17.28 171.17,17.28 v1(170.03,18.43)
  IN2 w0.089: v1(152.51,22.71) 153.64,21.58 154.09,21.58 157,18.67 159.16,18.67 160.45,19.96 162.57,19.96 163.11,20.5 165.18,20.5 166.27,19.4 167.15,19.4 167.36,19.19 169.26,19.19 v1(170.03,18.43)
  BOTTOM w0.102: v1(152.51,22.71) 151.59,23.63 150.69,23.63 150.1,24.22 150.1,24.76 149.73,25.13 149.41,25.13 149.07,25.48 CN10.6 ; C688.1 169.99,18.46 v1(170.03,18.43) 170,18.4 CN16.6
MX5: length 39.9
  TOP w0.102: U15.63 179.22,14.89 178.59,15.51 178.32,15.51 177.64,16.19 176.75,16.19 175.43,17.51 171.91,17.51 v1(171,18.43)
  IN2 w0.089: v1(171,18.43) 170.59,18.83 169.94,18.83 169.39,19.38 167.48,19.38 167.28,19.59 166.35,19.59 165.25,20.69 163.03,20.69 162.49,20.15 160.38,20.15 159.08,18.86 157.08,18.86 154.16,21.78 154.07,21.78 v1(153.15,22.71)
  BOTTOM w0.102: v1(153.15,22.71) 151.99,23.86 150.79,23.86 150.33,24.32 150.33,24.85 150.07,25.11 CN10.5 150.07,27.57 v1(150.07,27.57) ; C689.1 171,18.43 v1(171,18.43) CN16.5
MX6: length 39.5
  TOP w0.102: U15.64 179.62,14.87 178.75,15.74 178.41,15.74 177.73,16.42 176.84,16.42 175.52,17.74 172.71,17.74 v1(172.02,18.43)
  IN2 w0.089: v1(153.78,22.71) 154.51,21.98 154.51,21.7 157.16,19.05 159,19.05 160.35,20.39 162.37,20.39 163.61,21.64 164.57,21.64 166.43,19.78 167.36,19.78 167.56,19.57 169.47,19.57 170.02,19.02 170.67,19.02 170.79,18.91 171.54,18.91 v1(172.02,18.43)
  BOTTOM w0.102: CN10.4 151.07,25.51 151.45,25.13 153.38,25.13 153.76,24.76 153.76,22.73 v1(153.78,22.71) ; CN16.4 172,18.41 v1(172.02,18.43) C690.1
MX7: length 43.4
  TOP w0.102: v1(173.54,18.43) 173.98,18.86 174.49,18.86 175.15,18.2 175.71,18.2 177.03,16.88 177.92,16.88 178.6,16.2 178.99,16.2 179.1,16.09 180.4,14.79 v1(181.19,14.79) 182.23,14.79 182.46,15.02 182.46,15.45 182.16,15.76 U15.65
  IN2 w0.089: v1(173.54,18.43) 172.87,19.1 170.87,19.1 170.75,19.21 170.1,19.21 169.55,19.76 167.64,19.76 167.37,20.03 167.37,20.23 167.02,20.59 166.61,20.59 165.37,21.83 163.54,21.83 162.29,20.59 160.24,20.59 158.9,19.24 157.23,19.24 154.91,21.56 154.91,22.21 v1(154.42,22.71)
  BOTTOM w0.102: CN16.3 173,17.88 v1(173.54,18.43) 173.03,18.94 C691.1 ; CN10.3 152.07,25.65 152.33,25.39 153.48,25.39 153.99,24.88 153.99,23.14 v1(154.42,22.71)
MY0: length 49.8
  TOP w0.102: v1(166.53,14.08) 166.46,14.08 166.03,13.65 v1(166.03,13.45) 166.52,12.95 167.98,12.95 168.42,13.38 U15.36 ; C463.1 v1(150.43,16.5)
  BOTTOM w0.102: v1(166.03,13.45) 164.15,11.57 155.1,11.57 150.43,16.24 v1(150.43,16.5) 150.36,16.5 150,16.86 CN16.26 150,17.82 149.67,18.15 149.54,18.15 149.11,18.58 144.17,18.58 140.59,22.16 136.52,22.16 135.38,23.3 132.44,23.3 130.44,25.3 129.44,25.3 129.07,25.66 CN10.26
MY1: length 49.1
  TOP w0.102: v1(151.06,16.5) 151.32,16.75 C464.1 ; U15.37 168.82,13.32 168.71,13.21 168.63,13.21 168.14,12.72 166.12,12.72 v1(165.39,13.45)
  BOTTOM w0.102: v1(165.39,13.45) 163.74,11.8 155.38,11.8 151.06,16.12 v1(151.06,16.5) 151.06,16.55 151,16.61 CN16.25 151,17.83 150.49,18.34 150.49,18.46 149.82,19.14 148.96,19.14 148.63,18.81 144.26,18.81 140.68,22.39 136.62,22.39 135.47,23.53 132.53,23.53 130.53,25.53 130.2,25.53 130.07,25.65 CN10.25
MY2: length 48.1
  TOP w0.102: v1(152.33,16.5) 152.21,16.62 C465.1 ; U15.38 169.22,13.19 v1(168.81,12.77) 168.53,12.49 165.71,12.49 v1(164.76,13.45)
  BOTTOM w0.102: CN10.24 131.07,25.7 132.27,24.5 134.83,24.5 136.71,22.62 140.78,22.62 144.36,19.04 148.53,19.04 148.86,19.37 149.92,19.37 151.09,18.2 151.78,18.2 152,17.97 CN16.24 152,16.83 v1(152.33,16.5) 156.81,12.03 163.33,12.03 v1(164.76,13.45)
MY3: length 48.8
  TOP w0.102: v1(164.12,13.45) 165.3,12.27 168.93,12.27 169.62,12.95 U15.39 ; C466.1 153.1,16.62 v1(152.97,16.5)
  BOTTOM w0.102: CN10.23 132.07,25.02 132.36,24.73 134.93,24.73 136.81,22.85 140.87,22.85 144.45,19.26 148.44,19.26 148.77,19.59 152.28,19.59 152.97,18.9 152.97,18.27 153,18.24 CN16.23 153,16.53 v1(152.97,16.5) 155.51,13.96 156.27,13.96 157.97,12.25 162.93,12.25 v1(164.12,13.45)
MY4: length 48.8
  TOP w0.102: v1(163.49,13.45) v1(164.69,12.24) 164.9,12.04 169.06,12.04 170.02,12.99 U15.40 ; C467.1 153.99,16.51 v1(154,16.5)
  BOTTOM w0.102: CN10.22 133.07,25.3 133.41,24.95 135.02,24.95 136.9,23.07 140.97,23.07 144.55,19.49 148.34,19.49 148.8,19.95 153.53,19.95 154.54,18.93 154.54,18.53 154,17.98 CN16.22 v1(154,16.5) 155.83,14.66 157.73,14.66 159.9,12.48 162.52,12.48 v1(163.49,13.45)
MY5: length 47.4
  TOP w0.102: v1(155.36,16.5) 155.36,16.55 C468.1 ; v1(162.85,13.45) 164.49,11.81 169.15,11.81 170.42,13.07 U15.41
  BOTTOM w0.102: CN10.21 134.07,25.41 134.3,25.18 135.12,25.18 137,23.3 141.06,23.3 144.64,19.72 148.25,19.72 148.7,20.18 153.83,20.18 155,19.01 CN16.21 155,16.88 155.36,16.52 v1(155.36,16.5) 155.87,15.99 156.02,15.99 157.03,14.97 157.76,14.97 160.02,12.71 162.11,12.71 v1(162.85,13.45)
MY6: length 46.5
  TOP w0.102: v1(162.22,13.45) v1(163.38,12.28) 164.08,11.58 169.25,11.58 170.82,13.15 U15.42 ; C469.1 155.76,16.73 v1(156,16.5)
  BOTTOM w0.102: CN10.20 135.07,25.55 137.09,23.53 141.15,23.53 144.74,19.95 148.15,19.95 148.61,20.41 153.98,20.41 156,18.39 CN16.20 v1(156,16.5) 156,16.39 157.16,15.23 157.84,15.23 160.13,12.94 161.71,12.94 v1(162.22,13.45)
MY7: length 45.6
  TOP w0.102: C470.1 156.65,16.84 v1(157,16.5) ; v1(161.58,13.45) 163.68,11.35 169.34,11.35 171.22,13.22 U15.43
  BOTTOM w0.102: CN10.19 136.07,24.88 137.19,23.76 141.25,23.76 144.83,20.18 148.06,20.18 148.52,20.64 154.08,20.64 157,17.72 CN16.19 v1(157,16.5) 157.76,15.73 159.29,15.73 v1(161.58,13.45)
MY8: length 45
  TOP w0.102: v1(171.02,12.02) 171.02,12.7 171.62,13.3 U15.44 ; C471.1 157.54,16.95 v1(158,16.5)
  BOTTOM w0.102: CN10.18 137.07,24.78 137.86,23.99 141.34,23.99 144.93,20.41 147.96,20.41 148.42,20.86 154.17,20.86 156.82,18.22 157.8,18.22 158,18.02 CN16.18 v1(158,16.5) 158.51,15.99 159.45,15.99 161.48,13.96 166.81,13.96 168.76,12.01 171.01,12.01 v1(171.02,12.02)
MY9: length 44.9
  TOP w0.102: v1(171.89,11.09) 171.65,11.33 v1(171.65,12.04) 171.65,12.83 172.02,13.19 U15.45 ; v1(159,16.5) 158.46,17.03 C472.1
  BOTTOM w0.102: v1(171.65,12.04) 171.13,12.56 168.53,12.56 166.91,14.18 161.63,14.18 159.32,16.5 v1(159,16.5) CN16.17 159,17.65 158.47,18.19 158.16,18.19 157.89,18.45 156.91,18.45 154.27,21.09 148.14,21.09 147.97,21.27 144.39,21.27 141.44,24.22 139,24.22 138.07,25.15 CN10.17
MY10: length 45.1
  TOP w0.102: v1(160,16.5) 159.46,17.03 C473.1 ; U15.46 172.42,12.17 v1(172.3,12.05) 173.11,11.24 v1(173.32,11.24)
  BOTTOM w0.102: v1(172.3,12.05) 171.56,12.79 168.63,12.79 167,14.41 162.08,14.41 v1(160,16.5) CN16.16 160,18.1 159.93,18.18 158.8,18.18 158.56,18.41 158.25,18.41 157.99,18.68 157,18.68 154.36,21.32 148.24,21.32 148.06,21.5 144.48,21.5 141.53,24.45 139.76,24.45 139.07,25.14 CN10.16
MY11: length 46
  TOP w0.102: v1(175.07,12.05) 175.07,12.31 174.42,12.96 U15.51 ; v1(160.84,16.5) 160.31,17.03 C474.1
  BOTTOM w0.102: CN10.15 140.07,25.13 140.52,24.67 141.63,24.67 144.58,21.73 148.16,21.73 148.33,21.55 154.46,21.55 157.1,18.91 158.08,18.91 158.35,18.64 158.66,18.64 158.9,18.4 160.84,18.4 161,18.25 CN16.15 161,16.65 v1(160.84,16.5) 162.7,14.64 167.1,14.64 168.72,13.02 174.1,13.02 v1(175.07,12.05)
MY12: length 47.3
  TOP w0.102: v1(175.7,12.05) 174.82,12.94 U15.52 ; v1(161.53,16.5) 161.53,16.55 162.02,17.03 C475.1
  BOTTOM w0.102: v1(140.68,27.57) 140.68,27.14 141.07,26.74 CN10.14 141.07,25.56 144.67,21.96 148.25,21.96 148.43,21.78 154.55,21.78 157.19,19.14 158.18,19.14 158.44,18.87 158.75,18.87 158.99,18.63 161.17,18.63 162,17.8 CN16.14 162,16.97 v1(161.53,16.5) 162.44,15.58 164.98,15.58 165.69,14.87 167.19,14.87 168.82,13.24 174.51,13.24 v1(175.7,12.05)
MY13: length 42.5
  TOP w0.102: v1(163.43,16.5) 163.43,16.95 163.36,17.03 C476.1 ; v1(174.69,15.35) 174.81,15.35 175.22,14.95 U15.53
  BOTTOM w0.102: v1(174.69,15.35) 172.81,13.47 168.91,13.47 167.29,15.1 165.78,15.1 165.07,15.81 164.12,15.81 v1(163.43,16.5) 163,16.93 CN16.13 163,18.02 162.83,18.2 162.24,18.2 v1(161.68,18.76) 161.58,18.86 159.09,18.86 158.85,19.1 158.54,19.1 158.27,19.37 157.29,19.37 154.65,22.01 148.52,22.01 148.35,22.19 144.76,22.19 142.07,24.88 CN10.13
MY14: length 43.4
  TOP w0.102: v1(172.53,15.35) 173.09,15.91 174.76,15.91 175.62,15.06 U15.54 ; v1(164.08,16.5) 164.02,16.55 C477.1
  BOTTOM w0.102: CN10.12 143.07,24.2 144.86,22.41 148.44,22.41 148.62,22.24 156.37,22.24 157.29,21.32 157.29,19.85 157.54,19.59 158.36,19.59 158.63,19.33 158.94,19.33 159.16,19.11 161.43,19.11 161.5,19.19 163.36,19.19 v1(163.76,18.78) 164,18.55 CN16.12 164,16.57 164.07,16.5 v1(164.08,16.5) 164.08,16.49 164.53,16.04 165.17,16.04 165.88,15.33 167.38,15.33 168.48,14.23 171.4,14.23 v1(172.53,15.35)
MY15: length 50.8
  TOP w0.102: U15.55 176.02,14.98 174.86,16.14 172.68,16.14 v1(171.89,15.35)
  IN2 w0.089: v1(171.89,15.35) 171.16,14.62 166.03,14.62 164.53,16.12 164.53,16.64 164.16,17 161.93,17 161.52,17.41 156.37,17.41 153.23,20.55 152.25,20.55 151.23,21.58 147.72,21.58 146.59,22.71 v1(146.59,22.87)
  BOTTOM w0.102: CN10.11 144.07,25.76 143.95,25.64 143.95,24.71 145.8,22.86 146.59,22.86 v1(146.59,22.87) ; C683.1 165.03,18.53 165,18.49 CN16.11 165,16.53 165.97,15.56 167.48,15.56 168.58,14.46 171,14.46 v1(171.89,15.35)
MY16: length 60.5
  TOP w0.102: v1(176.74,11.52) 176.74,11.9 176.36,12.28 176.36,13.19 176.42,13.25 U15.56 ; C461.1 149.03,16.78 v1(149.03,16.5)
  BOTTOM w0.102: v1(176.74,11.52) 176.34,11.11 154.74,11.11 151.08,14.77 150.49,14.77 149.03,16.22 v1(149.03,16.5) 148.78,16.5 148,17.28 CN16.28 148,18.02 147.9,18.12 143.98,18.12 140.4,21.7 136.33,21.7 135.19,22.85 132.25,22.85 130.25,24.84 127.88,24.84 127.07,25.65 CN10.28
MY17: length 60.3
  TOP w0.102: v1(149.67,16.5) 149.54,16.62 C462.1 ; v1(177.38,11.52) 177.38,11.9 176.82,12.46 v1(176.82,12.79) U15.57
  BOTTOM w0.102: v1(177.38,11.52) 176.85,12.05 176.64,12.05 175.93,11.34 154.83,11.34 151.17,15 151.17,15 v1(149.67,16.5) 149,17.16 CN16.27 149,18.05 148.7,18.35 144.07,18.35 140.49,21.93 136.43,21.93 135.28,23.07 132.34,23.07 130.35,25.07 128.65,25.07 128.07,25.65 CN10.27
NBSWON#: length 56.4
  TOP w0.102: R247.1 C372.1 174.91,31.38 175.62,30.68 U15.107 175.62,28.73 v1(175.51,28.62) ; v1(158.15,27.27) 158.05,27.37 158.05,29.02 160.13,31.1 160.13,33.18 160.46,33.51 162.74,33.51 163.59,34.36 163.59,35.65 163.87,35.93 v1(167.07,35.93)
  IN3 w0.089: v1(167.07,35.93) 167.55,35.93 168.9,34.58 171.65,34.58 172.8,33.43 173.64,33.43 174.11,32.96 174.11,32.41 173.42,31.72 172.76,31.72 172.4,31.36 172.4,30.99 174.19,29.2 174.94,29.2 v1(175.51,28.62)
  BOTTOM w0.102: v1(158.15,27.27) 158.15,27.14 157.26,26.25 CN10.1 ; SW3.1 163.73,35.44 165.83,35.44 SW3.2 167.01,35.87 v1(167.07,35.93) ; R697.2 173.45,19.64 172.53,20.56 172.53,21.11 D34.2 171.89,23.35 172.43,23.89 172.43,25.8 174.2,27.58 174.2,28.76 174.51,29.07 175.07,29.07 v1(175.51,28.62)
NVME_SSD_AUX_RST#: length 139.6
  TOP w0.102: R429.2 22.19,6.11 22.29,6.21 ; 22.29,6.21 22.41,6.08 23.18,6.08 25.16,8.06 25.16,12.44 26.2,13.48 26.2,16.12 26.76,16.67 26.76,21.98 28,23.23 28,25.13 28.15,25.28 28.15,28.26 27.95,28.46 27.95,29.91 28.13,30.09 v1(28.13,30.97) ; 22.29,6.21 22.29,8.75 22.16,8.88 20.13,8.88 19.63,8.38 U21.1
  IN1 w0.089: v1(92.64,30.34) 91.22,28.92 81.85,28.92 80.07,27.14 77.04,27.14 76.7,27.48 56.39,27.48 54.99,26.08 51.81,26.08 51.52,26.38 50.55,26.38 48.85,28.08 40.46,28.08 38.46,26.08 33.22,26.08 29.73,29.58 29.53,29.58 v1(28.13,30.97)
  IN2 w0.089: v2(98.86,46.46) 98.91,46.46 101.51,49.06 109,49.06 109.43,48.63 v2(109.54,48.63)
  IN3 w0.089: v1(92.64,30.34) 93.03,30.34 93.15,30.47 93.91,30.47 96.4,32.96 96.4,34.23 97.04,34.86 97.04,39.69 98.36,41.01 98.36,43.86 99.12,44.63 99.12,44.94 99.38,45.2 99.38,45.96 98.88,46.46 v2(98.86,46.46)
  BOTTOM w0.102: v2(98.86,46.46) 98.86,46.63 U30.AP7 ; R748.1 R586.1 TP61.1 v2(109.54,48.63)
OCP_DET: length 23.6
  TOP w0.102: v1(24.57,16.24) 24.45,16.12 23.81,16.12 23.43,15.73 23.43,15.18 23.73,14.87 R392.2 23.94,14.72 23.84,14.62 23.01,14.62 R391.1 22.68,14.71 21.53,15.86 U19.16
  IN1 w0.089: v1(24.57,16.24) 23.84,16.24 22.76,17.33 22.76,18.4 22.92,18.57 22.92,22.34 21.78,23.48 16.95,23.48 v1(16.19,24.24)
  BOTTOM w0.102: v1(14.99,26.05) U36.3 15.37,25.07 v1(16.19,24.24)
ODD_PRSNT#: length 64.6
  TOP w0.102: v1(112.71,13.58) 113.22,14.08 122.87,14.08 124.52,15.73 125.8,15.73 C487.1 126.55,15.23 126.78,15 R388.2
  BOTTOM w0.099: 91.44,39.38 91.44,40.62 U30.BD15
  BOTTOM w0.102: 91.44,39.38 91.44,39.19 91.58,39.05 91.58,36.77 90.55,35.74 90.55,35.23 90.41,35.09 90.23,35.09 89.57,34.43 89.57,33.79 89.88,33.49 89.88,31.76 89.55,31.43 89.55,30.75 90.74,29.55 90.74,20.43 93.33,17.84 93.33,14.92 95.06,13.19 112.33,13.19 v1(112.71,13.58)
ODD_PRSNT#_C: length 10.8
  TOP w0.102: C489.1 127.79,15.16 127.5,15.45 R388.1 127.19,15.61 126.5,16.29 R375.1 126.64,16.62 127.6,16.62 128.13,16.09 v1(128.13,15.99)
  BOTTOM w0.102: v1(128.13,15.99) 128.38,15.73 132.27,15.73 133.08,16.55 133.08,16.67 133.35,16.94 CN17.8
ODDPWRON: length 42.7
  TOP w0.102: v1(168.84,21.88) 168.39,21.42 167.93,21.42 167.19,20.69 166.43,20.69 166.3,20.56 U15.20 ; v1(147.86,22.87) 147.86,22.71 147.25,22.11 147.25,20.71 146.2,19.66 146.2,14.03 145.73,13.56 145.73,12.05 145.99,11.79 R413.2 R414.1 147.53,11.94 Q22.2
  IN2 w0.089: v1(168.84,21.88) 168.44,21.48 168.15,21.48 167.71,21.04 166.7,21.04 165.53,22.21 163.38,22.21 162.21,21.04 157.81,21.04 155.73,23.13 149.69,23.13 149.54,22.97 149.54,22.59 149.39,22.44 148.28,22.44 v1(147.86,22.87)
PBA_FP_PWREN#: length 145.3
  TOP w0.102: U15.76 179.79,20.16 177.61,22.34 v1(177.61,22.72)
  IN3 w0.089: v1(177.61,22.72) 177.86,22.97 177.86,23.96 176.68,25.14 172.67,25.14 171.7,24.17 168.92,24.17 168.24,24.85 165.14,24.85 161.98,21.7 140.01,21.7 136.74,24.97 134.7,24.97 134.34,25.33 131.75,25.33 131.45,25.63 125.35,25.63 121.9,22.19 119.7,22.19 119.4,21.89 111.75,21.89 105.48,15.62 100.26,15.62 98.94,16.95 93.1,16.95 91.25,15.1 91.25,13.94 88.37,11.06 84.11,11.06 82.08,13.09 60.95,13.09 60.67,12.81 59.98,12.81 59.7,13.09 55.15,13.09 54.98,13.27 54.98,13.98 v1(54.85,14.11)
  BOTTOM w0.102: v1(54.85,14.11) 54.14,14.11 53.49,14.76 R694.1
PBA_PWR: length 7.5
  TOP w0.508: v1(52,16.78) 51.14,17.64 R692.1
  BOTTOM w0.508: Q34.1 52.17,20.25 51.79,19.86 C698.2 51.79,18.32 52.38,17.72 R711.2 52.38,17.15 v1(52,16.78)
PBA_PWR_C:
  vias: v1(55.23,22.67)
PBA_PWR_R: length 12.4
  TOP w0.508: R692.2 51.14,20.13 51.75,20.74 v1(51.75,20.99) v1(51.75,22.08) 51.78,22.11 52.26,22.11 52.56,22.41 52.56,23.35 51.89,24.03 C414.2 52.39,24.37 52.9,24.89 C410.2
  BOTTOM w0.508: R688.1 53.72,21.27 52.16,21.27 51.75,21.68 v1(51.75,22.08) 51.22,21.55 50.76,21.55 Q34.3
PCBEEP_EC: length 48.8
  TOP w0.102: v1(170.62,15.35) 170.42,15.15 167.93,15.15 167.62,14.84 U15.34
  IN2 w0.089: v1(193.15,18.66) 192.7,19.11 191.5,19.11 190.31,20.31 188.5,20.31 187.25,19.05 187.25,17.75 186.12,16.62 185.35,16.62 185.15,16.83 182.51,16.83 181.04,15.35 175.58,15.35 175.18,15.75 171.02,15.75 v1(170.62,15.35)
  IN3 w0.089: v1(193.15,18.66) 192.85,18.96 192.85,25.77 192.24,26.38 192.24,27.03 192.36,27.15 192.36,27.83 192.24,27.95 192.24,29.48 192.71,29.95 192.71,30.45 193.6,31.34 195.25,31.34 195.69,31.79 195.69,32.73 v1(195.26,33.16)
  BOTTOM w0.102: v1(195.26,33.16) 195.29,33.13 195.97,33.13 D31.2
PCBEEP_EC_C: length 8.3
  BOTTOM w0.102: C643.2 198.92,32.04 198.79,32.16 198.79,32.47 198.82,32.5 198.82,33.9 v1(199.12,34.2) 201.03,34.2 201.37,34.54 R634.1 202.24,34.68 R633.2 202.25,34.4 202.13,34.28 C636.2 202.13,33.14 202.12,33.13 C639.2
PCH_AZ_CODEC_BITCLK: length 127.1
  TOP w0.102: v2(109.15,46.85) 109.54,46.85 110.07,47.38 113.08,47.38 C610.2 113.11,47.62 112.97,47.76 111.62,47.76 110.86,48.53 110.86,51.62 112,52.77 114.03,52.77 115.1,51.7 v1(119.44,51.7) v1(120.33,51.7)
  IN1 w0.089: v1(198.82,26.4) 197.8,27.42 196.53,27.42 195.18,28.76 193.63,28.76 193.28,28.42 191.31,28.42 190.14,27.25 190.14,26.74 189.8,26.4 186.4,26.4 185.42,27.38 181.82,27.38 181.15,28.05 178.13,28.05 177.46,27.38 175.33,27.38 175.02,27.06 167.73,27.06 166.77,26.11 159.12,26.11 158.68,26.55 157.89,26.55 157.63,26.29 146.4,26.29 145.97,25.86 144.4,25.86 143.77,25.23 140.14,25.23 138.38,26.99 138.38,29.16 136.12,31.42 136.12,32.69 135.73,33.08 132.01,33.08 130.81,34.28 130.36,34.28 130.03,34.61 130.03,35.09 130.36,35.42 130.49,35.42 131.05,35.98 131.05,36.38 130.44,36.99 130.44,38 125.66,42.79 123.51,42.79 123.04,43.25 123.04,49.99 121.85,51.17 120.86,51.17 v1(120.33,51.7)
  BOTTOM w0.102: U35.6 198.87,26.46 v1(198.82,26.4) 198.31,25.89 198.31,25.5 C653.2 ; v2(109.15,46.85) 109.03,46.72 108.85,46.72 108.72,46.6 R588.1
PCH_AZ_CODEC_RST#: length 125.4
  TOP w0.102: v1(120.97,51.68) 120.97,51.8 120.58,52.18 115.3,52.18 114.23,53.25 111.8,53.25 110.35,51.8 110.35,48.42 109.41,47.48 v2(109.15,47.48)
  IN1 w0.089: v1(120.97,51.68) 122.18,51.68 124.29,49.57 124.29,44.82 131.32,37.79 131.32,37.01 131.63,36.69 131.63,35.8 131.38,35.55 131.38,35.04 132.4,34.02 136.46,34.02 137.06,33.42 137.06,32.18 137.72,31.52 138.86,31.52 140.5,29.89 140.5,26.96 141.28,26.17 143.38,26.17 144.01,26.8 145.58,26.8 146.01,27.23 153.48,27.23 154.31,28.05 156.86,28.05 156.92,27.99 157.61,27.99 157.84,28.22 160.06,28.22 160.63,27.65 165.03,27.65 165.7,28.31 168.08,28.31 168.38,28.01 173,28.01 173.29,28.31 173.29,28.69 173.7,29.09 184.69,29.09 186.37,27.42 189.64,27.42 191.12,28.89 193.09,28.89 193.43,29.23 195.4,29.23 196.07,28.56 v1(197.04,28.56) 197.42,28.56 197.93,28.05 199.07,28.05 199.22,27.9 199.22,25.08 197.9,23.76 v1(197.9,22.64)
  BOTTOM w0.102: Q38.1 197.73,21.64 197.9,21.8 v1(197.9,22.64) ; v2(109.15,47.48) 109.03,47.36 R587.1 ; R656.2 197.29,28.82 v1(197.04,28.56)
PCH_AZ_CODEC_SDIN0: length 127.3
  TOP w0.102: v1(121.4,53.94) 121.32,53.94 120.25,52.87 115.58,52.87 114.24,54.22 110.04,54.22 109.76,53.94 107.25,51.42 107.2,51.42 107.2,51.42 104.58,51.42 102.9,49.73 101.62,49.73 101.19,50.16 99.88,50.16 99.77,50.05 99.43,50.05 v2(98.89,49.5)
  IN1 w0.089: v1(121.4,53.94) 121.85,53.48 121.85,52.61 124.73,49.74 124.73,44.99 131.75,37.97 131.75,37.41 133.03,36.13 133.03,35.75 134.33,34.45 136.64,34.45 137.49,33.6 137.49,32.36 137.86,31.99 139.01,31.99 140.96,30.04 140.96,27.11 141.46,26.61 143.21,26.61 143.83,27.23 145.4,27.23 145.83,27.66 153.31,27.66 154.13,28.48 157.04,28.48 157.1,28.42 157.44,28.42 157.67,28.66 160.23,28.66 160.75,28.14 163.38,28.14 164.21,28.98 165.61,28.98 165.77,29.14 173.11,29.14 173.51,29.54 184.86,29.54 186.55,27.85 189.46,27.85 190.94,29.32 192.91,29.32 194.03,30.44 196.05,30.44 v1(197.04,29.45)
  BOTTOM w0.102: U30.AL6 99.21,49.82 v2(98.89,49.5) ; v1(197.04,29.45) 196.28,28.69 196.28,27.42 v1(196.4,27.29) R662.2
PCH_AZ_CODEC_SDIN0_R: length 2.1
  BOTTOM w0.102: R662.1 198.44,27.29 198.61,27.11 199.27,27.11 199.42,27.26 U35.8
PCH_AZ_CODEC_SDOUT: length 126.3
  TOP w0.102: v1(121.4,53.3) 121.19,53.3 120.53,52.64 115.49,52.64 114.14,53.99 110.14,53.99 109.99,53.84 109.99,53.02 110.12,52.89 110.12,52.52 108.44,50.84 108.44,49.08 v2(108.9,48.63)
  IN1 w0.089: v1(121.4,53.3) 121.07,53.3 119.92,52.16 119.92,50.43 120.97,49.39 120.97,48.37 121.22,48.12 121.98,48.12 122.57,47.53 122.57,42.96 123.25,42.28 125.5,42.28 129.97,37.81 129.97,35.76 129.2,34.99 129.2,34.55 129.94,33.81 130.62,33.81 131.81,32.61 135.53,32.61 135.65,32.5 135.65,31.23 137.45,29.42 137.45,28.16 137.74,27.87 137.74,26.96 139.94,24.76 144.55,24.76 145.17,25.39 146.16,25.39 146.59,25.82 157.87,25.82 158.05,25.64 166.97,25.64 167.55,26.22 175.14,26.22 175.83,26.91 177.66,26.91 178.32,27.57 180.96,27.57 181.62,26.91 185.23,26.91 186.27,25.87 190.03,25.87 190.61,26.45 190.61,26.96 191.6,27.95 193.48,27.95 193.82,28.29 194.77,28.29 196.4,26.66 197.67,26.66 198.56,25.77 v1(198.82,25.77)
  BOTTOM w0.102: v1(198.82,25.77) 198.94,25.89 199.32,25.89 199.49,26.06 U35.5 ; R585.1 108.62,48.34 v2(108.9,48.63)
