# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HWPG_1.8VS5: length 122
  TOP w0.102: v1(154.49,13.45) 154.33,13.61 D19.1 ; v1(48.45,22.34) 48.19,22.59 47.31,22.59 46.8,23.1 44.13,23.1 44,23.23 44,24.5 43.29,25.21 43.29,25.46 42.99,25.77 42.86,25.77 42.76,25.87 PR96.2 PR94.1
  IN1 w0.089: v1(154.49,13.45) 153.99,12.94 147.81,12.94 147.22,13.52 113.92,13.52 113.04,14.4 98.55,14.4 v1(96.45,16.5)
  IN2 w0.089: v1(96.45,16.5) 96.45,18.02 95.59,18.88 93.02,18.88 90.51,21.4 79.07,21.4 78.28,20.61 69.96,20.61 69.53,20.18 64.45,20.18 63.89,20.74 50.05,20.74 v1(48.45,22.34)
HWPG_VDDPS5: length 49.8
  TOP w0.102: v1(144.08,28.69) 144.08,27.93 145.4,26.61 145.4,21.75 145.73,21.42 145.73,14.21 145.22,13.7 145.22,11.72 145.83,11.11 153.81,11.11 v1(154.72,12.03) 155.31,12.61 D20.1
  IN1 w0.089: v1(145.4,44.54) 146.49,43.45 146.49,36.82 145.22,35.55 145.22,34.4 142.68,31.86 142.68,30.24 144.08,28.84 v1(144.08,28.69)
  BOTTOM w0.203: PR296.2 146.17,45.26 146.14,45.22 PR298.1 145.78,44.92 v1(145.4,44.54)
HWPG_VDDR: length 200.7
  TOP w0.102: v1(135.85,19.21) 135.85,19.44 136.08,19.67 136.08,20.18 135.8,20.46 135.8,26.63 v1(136.46,27.29) ; D23.1 159.51,12.57 159.78,12.84 159.78,13.91 160.64,14.77 v1(160.64,14.85) 162.16,16.37 v1(162.16,16.5)
  IN1 w0.089: v1(136.46,27.29) 136.04,26.87 135.48,26.87 135.19,27.16 135.19,27.93 134.68,28.43 132.19,28.43 129.09,31.53 129.09,32.12 127.38,33.83 127.38,35.86 127.04,36.2 124.88,36.2 124.52,36.56 124.52,38.59 120.97,42.15 120.97,45.33 119.95,46.34 119.7,46.34 118.59,47.45 118.59,53.1 122.78,57.29 122.78,63.68 123.54,64.44 123.54,67.26 122.82,67.98 122.82,70.01 122.49,70.34 112.84,70.34 111.44,71.74 111.44,74.49 110.18,75.76 110.18,79.25 107.91,81.52 107.91,85.2 104.96,88.14 104.96,89.9 v1(104.58,90.28)
  IN2 w0.089: v1(162.16,16.5) 161.44,17.22 156.3,17.22 153.46,20.05 152.48,20.05 151.19,21.35 142.23,21.35 140.88,20 136.64,20 v1(135.85,19.21) ; v1(64.72,112.89) 64.32,112.49 64.32,108.57 65.31,107.58 65.31,105.83 67.14,104 67.14,103.97 68.39,102.73 68.39,100.06 75.09,93.36 81.23,93.36 82.84,91.74 85.34,91.74 88.12,94.52 93.23,94.52 93.69,94.98 96.45,94.98 99.88,91.55 102.68,91.55 103.95,90.28 v1(104.58,90.28)
  BOTTOM w0.102: PR134.1 PR133.2 66.45,121.12 65.59,120.26 65.59,119.64 65.37,119.42 65.37,118.02 64.72,117.37 64.72,112.89 v1(64.72,112.89)
I2C_C0_CLK: length 46.6
  TOP w0.102: v1(73.57,16.12) 73.42,16.27 R377.1
  IN1 w0.089: v2(92.01,47.48) 92.77,46.72 92.77,41.67 92.92,41.52 92.92,39.76 92.57,39.41 92.57,38.52 92.47,38.42 92.47,37.4 92.39,37.32 92.39,33.65 92.28,33.55 92.28,33.03 92.01,32.75 91.12,32.75 89.06,30.69 86.65,30.69 v1(85.66,29.7)
  BOTTOM w0.102: v1(73.57,16.12) 73.72,15.96 77.26,15.96 78.02,16.72 79.16,16.72 83.4,20.96 83.4,20.97 86.32,23.89 86.32,28.66 86.2,28.79 R658.2 85.91,29.2 85.66,29.45 v1(85.66,29.7) ; U30.AP14 92.21,47.48 v2(92.01,47.48)
I2C_C0_DATA: length 49.7
  TOP w0.102: v1(71.69,16.12) 71.54,16.27 R376.1
  IN1 w0.089: v1(86.93,29.7) 87.56,30.34 89.98,30.34 90.49,30.85 90.49,31.63 91.26,32.41 92.15,32.41 92.63,32.88 92.63,33.4 92.75,33.53 92.75,37.17 92.81,37.24 92.81,38 93.03,38.21 93.03,39.31 93.28,39.56 93.28,41.77 93.03,42.02 93.03,47.28 v2(92.01,48.3)
  BOTTOM w0.102: v1(71.69,16.12) 72.2,15.61 77.4,15.61 78.17,16.37 79.31,16.37 86.68,23.74 86.68,28.56 86.9,28.79 R659.2 87.06,29.58 v1(86.93,29.7) ; v2(92.01,48.3) 92.32,47.99 U30.AN14
I2C_C1_CLK: length 128.1
  TOP w0.102: v2(105.6,44.82) 106.11,44.31 107,44.31 107.28,44.03 R210.1
  IN3 w0.089: v1(47.1,102.09) 46.49,102.7 46.49,106.77 47.38,107.66 54.65,107.66 55.85,108.86 61.77,108.86 68.51,102.12 68.51,99.35 75.93,91.93 78.29,91.93 78.8,91.43 84.39,91.43 85.51,90.31 88.74,90.31 90.16,88.89 91.27,88.89 92.61,87.55 95.21,87.55 95.89,86.88 96.93,86.88 99.53,84.28 99.53,80.16 101.84,77.85 101.84,75.23 102.61,74.46 102.61,72.72 107.18,68.15 107.18,63.21 109.56,60.83 109.56,53.4 111,51.96 111,49.21 109.96,48.18 108.19,48.18 105.85,45.85 105.85,45.07 v2(105.6,44.82)
  BOTTOM w0.102: U30.AP2 101.55,47.49 101.72,47.32 102.26,47.32 102.88,46.7 104.1,46.7 105.34,45.45 105.34,45.07 v2(105.6,44.82) ; R514.1 46.8,103.82 47.1,103.52 v1(47.1,102.09)
I2C_C1_DATA: length 131.4
  TOP w0.102: R211.1 108.32,44.03 107.78,44.56 106.61,44.56 106.36,44.82 v2(106.18,44.82)
  IN3 w0.089: v1(45.4,101.94) 46.29,102.83 46.29,106.83 49.04,109.59 55.18,109.59 55.71,109.05 61.86,109.05 68.77,102.14 68.77,99.46 76.04,92.19 78.5,92.19 79.06,91.63 84.69,91.63 85.81,90.51 88.81,90.51 90.24,89.08 91.36,89.08 92.7,87.74 95.29,87.74 95.97,87.07 97.02,87.07 99.73,84.36 99.73,80.22 102.04,77.91 102.04,75.3 102.8,74.54 102.8,72.88 107.38,68.31 107.38,63.28 109.76,60.9 109.76,53.47 111.19,52.04 111.19,49.14 110.04,47.99 108.27,47.99 107.76,47.48 107.76,45.71 106.87,44.82 v2(106.18,44.82)
  BOTTOM w0.102: v2(106.18,44.82) 106.18,44.99 104.25,46.93 102.96,46.93 102.33,47.55 101.81,47.55 101.37,47.99 U30.AN3 ; v1(45.4,101.94) 45.02,102.32 45.02,103.45 45.39,103.82 R513.1
I2C_SEL_PIN: length 2.7
  TOP w0.102: R136.2 21.14,82.51 v1(21.19,82.46) 21.19,82.08 20.99,81.88 v1(20.74,81.88)
  BOTTOM w0.102: v1(20.74,81.88) 20.73,81.87 U28.31
ICMNT: length 60.8
  TOP w0.102: C484.2 182.81,15.95 182.2,16.56 U15.67 179.78,16.56 179.28,17.05 178.89,17.05 178.26,17.69 177.42,17.69 176.49,18.62 176.49,19.41 175.32,20.59 173.05,20.59 171.82,21.82 171.82,24.83 170.62,26.02 169.86,26.02 169.51,26.38 169.51,26.93 169.02,27.42 168.33,27.42 167.39,28.36 166.9,28.36 166.45,28.82 165.21,28.82 163.81,30.22 v1(163.66,30.22)
  TOP w0.254: v1(138.57,34.53) 138.88,34.22 PC84.2
  IN1 w0.089: v1(163.66,30.22) 162.96,29.53 159.07,29.53 158.58,30.01 156.66,30.01 156.02,29.36 152.39,29.36 151.55,28.52 145.47,28.52 145.04,28.09 143.57,28.09 138.78,32.88 138.24,32.88 138.04,33.07 138.04,34.01 v1(138.57,34.53)
  BOTTOM w0.198: PR322.1 138.19,34.91 v1(138.57,34.53)
IDCHG_R: length 57
  TOP w0.102: v1(163.59,30.9) 164.25,30.23 164.25,30.19 165.2,29.25 v1(165.47,29.25) 166.34,29.25 167,28.59 167.48,28.59 168.29,27.77 168.99,27.77 169.62,27.14 170.2,27.14 172.05,25.29 172.05,21.91 173.15,20.81 175.41,20.81 176.72,19.51 176.72,18.71 177.51,17.92 178.35,17.92 178.99,17.28 179.38,17.28 179.71,16.96 U15.68
  TOP w0.254: v1(138.52,33.34) 137.81,33.34 PC86.2
  IN1 w0.089: v1(163.59,30.9) 163.41,30.72 162.88,30.72 162.57,30.42 162.57,29.91 162.38,29.72 159.14,29.72 158.66,30.2 156.56,30.2 155.92,29.55 152.31,29.55 151.47,28.71 145.39,28.71 144.96,28.28 143.65,28.28 138.59,33.34 v1(138.52,33.34)
  BOTTOM w0.198: PR323.1 138.15,33.86 138.52,33.49 v1(138.52,33.34)
IFDET: length 7.8
  TOP w0.102: R235.1 102.96,37.88 v1(102.78,38.06) 102.55,38.29 102.55,39.1 100.26,41.39 99.88,41.39 99.01,42.27 v2(99.01,42.52)
  BOTTOM w0.102: U30.BA6 v2(99.01,42.52)
ILIM_HI: length 2.1
  TOP w0.102: U10.16 18.11,47.88 17.61,47.38 v1(17.36,47.38) 17.33,47.41 R199.2
ILIM_LO: length 2.1
  TOP w0.102: U10.15 17.63,48.38 v1(17.36,48.65) 16.56,48.65 R192.2
IN_CLK: length 119.2
  TOP w0.102: C203.1 26.45,76.19 26.55,76.09 26.72,76.09 v1(27.01,76.38)
  IN1 w0.089: v1(27.01,76.38) 27.01,76.76 26.92,76.85 26.67,76.85 26.58,76.76 26.58,76.15 25.34,74.92 24.57,74.92 23.76,75.73 23.76,79.69 24.06,80 24.06,83.55 22.54,85.08 22.54,86.85 21.27,88.12 21.27,94.02 24.69,97.45 27.82,97.45 28,97.27 44.26,97.27 45.48,98.49 49.12,98.49 52.57,101.94 57.82,101.94 57.9,102.02 62.24,102.02 63.18,101.08 65.4,101.08 76.86,89.62 82.01,89.62 85.86,85.78 85.86,85.01 86.6,84.26 86.6,82.96 87.08,82.48 87.08,79.68 87.99,78.78 88.88,78.78 89.77,77.88 89.77,77.25 89.01,76.49 89.01,72.95 88.45,72.39 88.45,70.91 88.3,70.76 88.17,70.76 v2(87.98,70.95)
  BOTTOM w0.102: v2(87.98,70.95) 87.76,70.95 U30.F20
IN_CLK#: length 119.2
  TOP w0.102: C205.1 26.64,75.87 26.88,75.87 v1(27.01,75.74)
  IN1 w0.089: v2(87.98,70.34) 88.19,70.55 88.38,70.55 88.66,70.82 88.66,72.31 89.22,72.87 89.22,76.41 89.98,77.17 89.98,77.96 88.96,78.98 88.07,78.98 87.29,79.77 87.29,82.56 86.8,83.04 86.8,84.35 86.06,85.09 86.06,85.86 82.1,89.83 76.94,89.83 65.49,101.28 63.27,101.28 62.33,102.22 57.81,102.22 57.74,102.14 52.49,102.14 49.03,98.69 45.39,98.69 44.17,97.47 28.09,97.47 27.91,97.65 24.61,97.65 21.07,94.11 21.07,88.04 22.34,86.77 22.34,84.99 23.86,83.47 23.86,80.08 23.56,79.78 23.56,75.64 24.49,74.71 25.43,74.71 26.45,75.74 v1(27.01,75.74)
  BOTTOM w0.102: v2(87.98,70.34) 87.85,70.34 U30.G20
IN_D0: length 106
  TOP w0.102: C196.1 23.33,77.23 23.23,77.13 22.74,77.13 21.91,77.96 21.91,85.66 22.29,86.05 23.01,86.05 23.12,85.94 23.12,85.64 23.3,85.46 v1(23.43,85.46)
  IN1 w0.089: v2(86.03,70.39) 85.97,70.33 85.97,70.2 86.06,70.12 86.32,70.12 86.4,70.2 86.4,71.5 85.58,72.33 85.58,78.93 85.08,79.44 85.08,80.71 84.26,81.52 84.26,82.37 84.39,82.49 84.39,82.76 83.91,83.24 83.91,85.79 81.44,88.25 76.23,88.25 74.27,90.21 72.27,90.21 67.3,95.19 67.3,96.58 65.19,98.69 61.98,98.69 61.24,99.43 59.24,99.43 58.89,99.78 57.38,99.78 57.08,100.09 53.17,100.09 52.26,99.17 51.94,99.17 49.45,96.68 48.88,96.68 47.61,95.41 29.32,95.41 24.32,90.41 24.32,86.27 24.09,86.04 23.81,86.04 23.63,85.86 23.52,85.86 23.43,85.77 v1(23.43,85.46)
  BOTTOM w0.102: U30.G21 86.57,70.05 86.57,70.19 86.47,70.29 86.13,70.29 v2(86.03,70.39)
IN_D0#: length 106
  TOP w0.102: C202.1 23.11,76.92 22.65,76.92 21.69,77.87 21.69,85.75 22.2,86.26 v1(23.43,86.26)
  IN1 w0.089: v2(86.03,69.72) 86.22,69.91 86.4,69.91 86.61,70.12 86.61,71.59 85.79,72.41 85.79,79.01 85.28,79.52 85.28,80.79 84.47,81.6 84.47,82.28 84.59,82.41 84.59,82.84 84.11,83.32 84.11,85.87 81.53,88.45 76.31,88.45 74.36,90.41 72.36,90.41 67.5,95.27 67.5,96.67 65.27,98.89 62.06,98.89 61.33,99.63 59.33,99.63 58.97,99.99 57.47,99.99 57.16,100.29 53.09,100.29 52.17,99.38 51.85,99.38 49.36,96.89 48.8,96.89 47.53,95.62 29.24,95.62 24.12,90.49 24.12,86.35 24.03,86.26 v1(23.43,86.26)
  BOTTOM w0.112: v2(86.03,69.72) 86.03,69.66 U30.H21
IN_D1: length 101.7
  TOP w0.102: v1(26.99,78.95) 26.99,78.69 26.87,78.57 26.81,78.57 26.72,78.48 26.55,78.48 26.45,78.59 C187.1
  IN1 w0.089: v2(85.02,70.27) 85.02,70.02 85.1,69.94 85.3,69.94 85.43,70.07 85.43,71.43 84.95,71.91 84.95,78.68 83.17,80.45 83.17,84.84 80.37,87.64 74.81,87.64 73.19,89.25 71.42,89.25 66.13,94.54 66.13,95.85 63.89,98.08 61.57,98.08 60.86,98.79 58.86,98.79 58.48,99.17 57,99.17 56.7,99.48 53.43,99.48 52.51,98.56 52.18,98.56 49.85,96.23 49.85,95.11 49.21,94.47 47.31,94.47 47,94.78 29.7,94.78 25.59,90.66 25.59,86.09 24.7,85.2 24.7,82.41 26.38,80.73 26.38,78.45 26.47,78.36 26.64,78.36 26.85,78.56 26.9,78.56 26.99,78.65 v1(26.99,78.95)
  BOTTOM w0.102: v2(85.02,70.27) 85.28,70.27 85.51,70.5 U30.F22
IN_D1#: length 101.9
  TOP w0.102: v1(27.01,78.15) 26.9,78.27 26.63,78.27 C193.1
  IN1 w0.089: v2(85.02,69.57) 85.18,69.73 85.38,69.73 85.63,69.99 85.63,71.51 85.15,72 85.15,78.76 83.37,80.54 83.37,84.92 80.45,87.84 74.89,87.84 73.28,89.46 71.5,89.46 66.33,94.63 66.33,95.93 63.98,98.28 61.66,98.28 60.95,99 58.95,99 58.57,99.38 57.08,99.38 56.78,99.68 53.34,99.68 52.43,98.77 52.1,98.77 49.64,96.31 49.64,95.19 49.13,94.68 47.39,94.68 47.09,94.98 29.62,94.98 25.39,90.75 25.39,86.18 24.5,85.29 24.5,82.32 26.17,80.65 26.17,78.36 26.38,78.15 v1(27.01,78.15)
  BOTTOM w0.102: v2(85.02,69.57) 85.44,69.99 U30.G22
IN_D2: length 95.6
  TOP w0.102: C181.1 25.5,81.91 25.5,82.5 25.75,82.75 26.17,82.75 v1(26.38,82.96)
  IN1 w0.089: v2(84.04,70.33) 83.79,70.33 83.65,70.19 83.65,70.01 83.72,69.95 84.34,69.95 84.44,70.05 84.44,71.18 84.11,71.51 84.11,72.75 83.83,73.03 83.83,75.79 84.19,76.14 84.19,78.51 82.54,80.17 82.54,84.61 80.24,86.9 73.64,86.9 72.42,88.12 71.56,88.12 64.37,95.31 64.37,95.91 63.53,96.76 61.66,96.76 60.96,97.45 60.96,97.67 60.48,98.16 58.61,98.16 58.2,98.56 56.62,98.56 56.31,98.87 53.68,98.87 52.77,97.95 52.44,97.95 50.61,96.13 50.61,94.73 49.72,93.84 43.88,93.84 43.57,94.14 30.75,94.14 27.37,90.76 27.37,85.46 25.41,83.5 25.41,83.02 25.77,82.66 26.08,82.66 v1(26.38,82.96)
  BOTTOM w0.102: U30.G23 84.38,69.99 v2(84.04,70.33)
IN_D2#: length 95.6
  TOP w0.102: v1(26.38,82.33) 26.17,82.54 25.84,82.54 25.72,82.41 25.72,81.87 C182.1
  IN1 w0.089: v1(26.38,82.33) 26.24,82.46 25.68,82.46 25.21,82.93 25.21,83.59 27.16,85.54 27.16,90.84 30.67,94.35 43.66,94.35 43.96,94.04 49.63,94.04 50.4,94.81 50.4,96.21 52.35,98.16 52.68,98.16 53.6,99.07 56.4,99.07 56.7,98.77 58.29,98.77 58.69,98.36 60.56,98.36 61.17,97.76 61.17,97.54 61.74,96.96 63.61,96.96 64.58,96 64.58,95.4 71.65,88.33 72.5,88.33 73.72,87.11 80.33,87.11 82.74,84.7 82.74,80.25 84.39,78.6 84.39,76.06 84.03,75.7 84.03,73.11 84.31,72.83 84.31,71.6 84.64,71.27 84.64,69.97 84.42,69.75 84.19,69.75 v2(84.02,69.58)
  BOTTOM w0.102: U30.H23 84.4,69.19 v2(84.02,69.58)
INT_AMIC-VREFO: length 4.6
  BOTTOM w0.102: C646.1 208.33,30.47 v1(208.04,30.77)
  BOTTOM w0.203: C646.1 R657.2 208.21,28.56 207.38,28.56 206.87,28.06 U35.27
INT_EDP_AUXN: length 62.9
  IN3 w0.089: v2(93.03,74.76) 92.88,74.62 92.6,74.62 92.5,74.71 92.5,82.41 89.63,85.28 89.02,85.28 87.88,86.42 83.55,86.42 82.08,87.9 74.84,87.9 74.15,88.58 72.92,88.58 70.47,91.03 70.47,92.01 67.88,94.6 65.75,94.6 65.09,95.27 65.09,97.56 63.05,99.59 63.05,100.73 61.86,101.92 61.86,102.53 60.89,103.49 55.65,103.49 54.51,102.34 54.51,101.69 v1(54.29,101.47)
  BOTTOM w0.102: v2(93.03,74.76) 93.41,74.38 93.41,74.23 94.03,73.61 94.03,72.92 U30.B12 ; C560.1 54.4,102.12 54.53,102 54.53,101.7 v1(54.29,101.47)
INT_EDP_AUXN_C: length 5.4
  BOTTOM w0.102: CN2.22 54.22,106.53 54.36,106.39 54.36,104.59 R510.1 54.54,103.76 54.54,102.7 54.41,102.57 C560.2
INT_EDP_AUXP: length 62.9
  IN3 w0.089: v2(93.03,74.13) 92.74,74.41 92.51,74.41 92.3,74.63 92.3,82.32 89.55,85.08 88.94,85.08 87.79,86.22 83.47,86.22 81.99,87.69 74.76,87.69 74.07,88.38 72.83,88.38 70.27,90.94 70.27,91.93 67.8,94.4 65.67,94.4 64.88,95.19 64.88,97.47 62.85,99.5 62.85,100.65 61.66,101.84 61.66,102.44 60.81,103.29 55.74,103.29 54.71,102.26 54.71,101.69 v1(54.93,101.47)
  BOTTOM w0.102: C561.1 54.87,102.12 54.74,102 54.74,101.65 v1(54.93,101.47) ; U30.D12 94.01,72.46 93.7,72.76 93.7,73.05 93.81,73.16 93.81,73.52 93.2,74.13 v2(93.03,74.13)
INT_EDP_AUXP_C: length 5.3
  BOTTOM w0.102: C561.2 54.95,102.57 54.75,102.78 54.75,103.83 R511.1 54.58,104.86 54.58,106.39 54.72,106.53 CN2.23
INT_EDP_TXN0: length 64.1
  IN1 w0.089: v2(93.91,74.92) 94.19,75.19 94.31,75.19 94.55,75.42 94.55,75.93 94.3,76.19 93.03,76.19 92.64,76.57 92.64,78.85 92.06,79.44 91.71,79.44 90.67,80.48 90.67,80.7 89.72,81.65 89.72,84.4 82.32,91.81 77.09,91.81 68.26,100.64 68.26,101.99 66.03,104.23 57.14,104.23 56.79,104.58 53.06,104.58 52.92,104.44 52.92,104.21 v1(52.68,103.97)
  BOTTOM w0.089: 94.99,73.9 94.99,73.88 95.01,73.87 U30.B11
  BOTTOM w0.102: v2(93.91,74.92) 93.91,75.04 94.05,75.18 94.33,75.18 94.41,75.11 94.41,74.65 94.99,74.07 94.99,73.9 ; C554.1 52.87,105.17 52.93,105.1 52.93,104.23 v1(52.68,103.97)
INT_EDP_TXN0_C: length 1.7
  BOTTOM w0.102: CN2.19 52.72,106.58 52.87,106.44 52.87,105.85 C554.2
INT_EDP_TXN1: length 67.3
  IN1 w0.089: v2(95.06,75.55) 95.06,75.65 95.57,76.16 95.57,77.11 94.61,78.07 94.61,78.29 90.87,82.03 90.87,84.12 88.33,86.66 88.33,88.56 84.12,92.77 77.96,92.77 69.61,101.13 69.61,101.75 66.39,104.96 61.16,104.96 60.88,105.24 52.12,105.24 51.12,104.24 51.12,103.79 51.32,103.59 51.32,103.54 v1(51.13,103.35)
  BOTTOM w0.089: 95.46,73.9 95.46,73.88 95.48,73.87 95.48,73.66 95.62,73.52 95.62,73.41 U30.A11
  BOTTOM w0.102: C552.1 51.32,105.17 51.5,104.99 51.5,104.69 51.1,104.29 51.1,103.7 51.24,103.57 51.24,103.46 v1(51.13,103.35) ; v2(95.06,75.55) 95.15,75.64 95.29,75.64 95.46,75.47 95.46,73.9
INT_EDP_TXN1_C: length 1.7
  BOTTOM w0.102: CN2.16 51.22,106.69 51.36,106.54 51.36,105.87 C552.2
INT_EDP_TXN2: length 71.1
  IN1 w0.089: v2(96.58,75.68) 96.58,75.55 96.47,75.44 96.31,75.44 96.18,75.58 96.18,77.39 95.39,78.18 95.39,78.56 91.5,82.44 91.5,84.34 89.17,86.68 89.17,88.72 84.42,93.46 78.29,93.46 71.56,100.19 71.56,101.84 68.85,104.56 68.85,105.45 68.41,105.88 65.27,105.88 64.28,106.87 62.33,106.87 61.32,105.85 51.87,105.85 50.6,104.58 50.09,104.58 49.87,104.36 49.87,104.12 v1(49.66,103.91)
  BOTTOM w0.089: U30.B10 96.01,73.74 95.99,73.75 95.99,73.77
  BOTTOM w0.102: v2(96.58,75.68) 96.58,75.65 95.91,74.98 95.91,74.16 95.99,74.07 95.99,73.77 ; C550.1 49.87,104.9 49.87,104.12 v1(49.66,103.91)
INT_EDP_TXN2_C: length 1.7
  BOTTOM w0.102: C550.2 49.86,105.89 49.86,106.52 49.72,106.66 CN2.13
INT_EDP_TXN3: length 80.5
  IN1 w0.089: v1(49.21,102.09) 49.54,102.42 49.54,102.62 48.35,103.81 48.35,104.44 48.87,104.96 49.61,104.96 49.86,105.22 50.38,105.22 52.06,106.89 59.16,106.89 59.77,107.5 64.49,107.5 65.13,108.14 68.06,108.14 71.31,104.89 72.48,104.89 73.67,103.69 73.67,99.78 79.36,94.09 84.72,94.09 89.93,88.89 89.93,86.76 92.13,84.55 92.13,82.79 96.07,78.85 96.07,78.35 97.22,77.2 97.22,75.46 97.3,75.38 97.37,75.38 v2(97.65,75.65)
  BOTTOM w0.102: v1(49.21,102.09) 49.34,102.22 49.34,102.35 49.17,102.51 48.84,102.51 48.33,103.02 48.33,104.57 48.36,104.6 48.36,104.88 C548.1 ; U30.B9 96.96,72.93 96.96,73.52 97,73.56 97,75.21 97.18,75.39 97.54,75.39 97.65,75.49 v2(97.65,75.65)
INT_EDP_TXN3_C: length 1.7
  BOTTOM w0.102: CN2.10 48.22,106.53 48.36,106.39 48.36,105.92 C548.2
INT_EDP_TXP0: length 64.1
  IN1 w0.089: v2(93.91,75.55) 94.07,75.39 94.23,75.39 94.35,75.51 94.35,75.85 94.21,75.98 92.94,75.98 92.44,76.48 92.44,78.77 91.97,79.24 91.62,79.24 90.47,80.39 90.47,80.61 89.52,81.56 89.52,84.31 82.23,91.6 77.01,91.6 68.06,100.56 68.06,101.91 65.94,104.02 57.06,104.02 56.7,104.38 53.15,104.38 53.12,104.35 53.12,104.16 v1(53.31,103.97)
  BOTTOM w0.089: 95.21,73.9 95.21,73.88 95.2,73.87 95.2,73.13 95.33,73 95.33,72.77 95.01,72.45 U30.D11
  BOTTOM w0.102: v2(93.91,75.55) 94.07,75.4 94.42,75.4 94.63,75.2 94.63,74.74 95.21,74.16 95.21,73.9 ; v1(53.31,103.97) 53.15,104.14 53.15,105.02 53.3,105.17 C555.1
INT_EDP_TXP0_C: length 1.7
  BOTTOM w0.102: CN2.20 53.22,106.53 53.08,106.39 53.08,105.94 C555.2
INT_EDP_TXP1: length 67.3
  IN1 w0.089: v2(95.06,76.19) 95.3,76.19 95.36,76.24 95.36,77.02 94.41,77.98 94.41,78.2 90.66,81.94 90.66,84.03 88.12,86.57 88.12,88.48 84.03,92.57 77.88,92.57 69.4,101.04 69.4,101.66 66.31,104.76 61.07,104.76 60.79,105.04 52.21,105.04 51.32,104.15 51.32,103.88 51.52,103.68 51.52,103.59 v1(51.76,103.35)
  BOTTOM w0.089: U30.C11 95.66,72.64 95.66,73 95.81,73.15 95.81,73.6 95.67,73.74 95.67,73.87 95.68,73.88 95.68,73.9
  BOTTOM w0.102: v2(95.06,76.19) 95.68,75.56 95.68,73.9 ; C553.1 51.71,105.01 51.71,104.6 51.32,104.2 51.32,103.79 v1(51.76,103.35)
INT_EDP_TXP1_C: length 1.7
  BOTTOM w0.102: C553.2 51.58,105.92 51.58,106.5 51.72,106.64 CN2.17
INT_EDP_TXP2: length 71.1
  IN1 w0.089: v1(50.29,103.91) 50.07,104.12 50.07,104.28 50.18,104.38 50.68,104.38 51.95,105.65 61.4,105.65 62.42,106.67 64.2,106.67 65.19,105.68 68.33,105.68 68.64,105.36 68.64,104.47 71.36,101.76 71.36,100.1 78.21,93.25 84.34,93.25 88.96,88.63 88.96,86.59 91.3,84.26 91.3,82.36 95.18,78.47 95.18,78.09 95.97,77.3 95.97,75.49 96.23,75.24 96.39,75.24 v2(96.58,75.04)
  BOTTOM w0.089: 96.21,73.77 96.21,73.75 96.2,73.74 96.2,73.16 96.33,73.03 96.33,72.76 96.01,72.43 U30.D10
  BOTTOM w0.102: 96.21,73.77 96.21,74.16 96.12,74.25 96.12,74.89 96.28,75.04 v2(96.58,75.04) ; v1(50.29,103.91) 50.08,104.12 50.08,104.9 C551.1
INT_EDP_TXP2_C: length 1.7
  BOTTOM w0.102: CN2.14 50.22,106.66 50.08,106.52 50.08,105.89 C551.2
INT_EDP_TXP3: length 80.6
  IN1 w0.089: v2(97.65,75.02) 97.49,75.17 97.21,75.17 97.01,75.37 97.01,77.12 95.87,78.26 95.87,78.77 91.93,82.71 91.93,84.47 89.72,86.68 89.72,88.8 84.64,93.89 79.28,93.89 73.47,99.7 73.47,103.61 72.39,104.68 71.22,104.68 67.97,107.94 65.21,107.94 64.58,107.3 59.85,107.3 59.24,106.69 52.14,106.69 50.46,105.02 49.95,105.02 49.69,104.76 48.96,104.76 48.55,104.35 48.55,103.9 49.74,102.7 49.74,102.2 v1(49.85,102.09)
  BOTTOM w0.102: C549.1 48.58,104.92 48.58,104.51 48.55,104.48 48.55,103.11 48.93,102.73 49.26,102.73 49.59,102.4 49.59,102.35 v1(49.85,102.09) ; U30.D9 97.01,72.44 97.33,72.77 97.33,73 97.18,73.15 97.18,73.43 97.22,73.47 97.22,75.12 97.27,75.17 97.5,75.17 v2(97.65,75.02)
INT_EDP_TXP3_C: length 1.7
  BOTTOM w0.102: C549.2 48.58,105.87 48.58,106.39 48.72,106.53 CN2.11
ISOLATEB: length 4.8
  TOP w0.102: U2.20 48.55,105.2 v1(48.75,104.99) 50.13,104.99 50.2,104.92 R78.1 50.73,104.58 R77.2
JTAG_TCK: length 6.8
  BOTTOM w0.102: U25.AE41 110.11,115.33 110.11,116.66 110.29,116.85 110.29,121.27 TP42.1
JTAG_TDI: length 9.7
  BOTTOM w0.102: U25.AD40 110.35,114.21 110.66,114.52 110.66,114.82 110.58,114.89 110.58,115.71 110.75,115.88 110.75,120.2 111.95,121.4 111.95,121.65 112.2,121.91 112.2,122.16 TP41.1
JTAG_TDO: length 5.2
  TOP w0.102: TP9.1 110.93,116.45 110.17,115.68 v1(109.41,115.68)
  BOTTOM w0.102: v1(109.41,115.68) 109.41,115.35 109.25,115.2 U25.AF41
JTAG_TESTEN: length 6.2
  BOTTOM w0.102: R467.2 R475.1 110.02,118.83 109.84,118.65 109.84,118.56 TP47.1 109.81,118.05 109.89,117.96 109.89,115.54 109.48,115.13 109.48,114.87 109.56,114.8 109.56,114.57 U25.AE40
JTAG_TMS: length 7.4
  BOTTOM w0.102: TP43.1 110.52,120.86 110.52,116.79 110.31,116.58 110.31,114.72 U25.AD41
JTAG_TRSTB: length 6.7
  BOTTOM w0.102: R466.1 R474.1 108.17,118.7 108.27,118.6 TP46.1 108.27,116.32 108.9,115.68 108.9,115.47 109.05,115.32 109.05,114.92 108.93,114.8 108.93,114.56 109.25,114.24 U25.AF40
JW5222LX1.5V:
  vias: v1(196.48,23.63)
KB_BL_LED: length 37.1
  TOP w0.102: v1(175.47,23.71) 175.07,24.12 175.07,25.89 173.09,27.88 173.09,28.94 173.22,29.07 U15.113
  IN1 w0.089: v1(193.48,25.26) 192.97,24.75 191.83,24.75 190.71,23.63 189.04,23.63 188.99,23.58 187.56,23.58 187.51,23.63 183.81,23.63 182.87,24.57 181.98,24.57 180.91,25.64 178.62,25.64 177.53,24.55 176.31,24.55 v1(175.47,23.71)
  BOTTOM w0.102: Q40.2 193.57,17.98 193.4,18.15 192.82,18.15 192.72,18.25 192.72,18.83 192.9,19.01 192.9,20.92 v1(192.64,21.17) 192.34,21.17 191.98,21.53 191.98,22.19 192.64,22.84 192.64,23.47 192.8,23.62 192.8,23.82 192.87,23.89 192.87,24.65 v1(193.48,25.26)
KL_NO_EC: length 153.6
  TOP w0.102: v1(143.22,27.21) 142.63,27.8 141.79,27.8 141.54,28.05 PR88.1 ; v1(168.77,28.43) 168.97,28.43 169.81,27.6 170.39,27.6 172.55,25.43 172.55,22.05 173.33,21.27 175.6,21.27 177.18,19.7 177.18,18.93 177.71,18.4 179.89,18.4 180.54,17.76 U15.70 ; PR114.1 50.48,16.52 50.48,20.56 51.19,21.27 51.19,22.39 51.55,22.74 v1(51.88,22.74)
  IN2 w0.089: v1(168.77,28.43) 168.77,28.18 167.52,26.93 165.05,26.93 164.64,26.51 158.99,26.51 158.92,26.58 157.8,26.58 156.3,28.08 154.27,28.08 153.11,26.92 143.81,26.92 143.52,27.21 v1(143.22,27.21) 143.22,26.94 141.91,25.63 140.89,25.63 139.68,24.42 131.63,24.42 130.61,23.4 123.97,23.4 122.63,22.06 109.15,22.06 107.98,20.89 104.84,20.89 104.81,20.92 98,20.92 97.79,21.13 94.73,21.13 92.09,23.77 76.14,23.77 75.49,23.13 71.13,23.13 70.19,22.19 56.18,22.19 55.65,22.72 51.9,22.72 v1(51.88,22.74)
L_SPK+: length 95.7
  IN3 w1.016: 115.43,14.16 116.04,13.55 143.6,13.55 145.88,11.26 169.02,11.26 170.67,12.91 179.54,12.91 180.55,11.9 186.07,11.9 187.79,13.63 189.22,13.63 190.31,12.53 199.81,12.53 202.68,15.4 202.68,17.84 202.63,17.89
  BOTTOM w0.203: U35.42 203.33,22.41 v1(203.24,22.31)
  vias: v1(115.12,15.86) v1(115.76,15.86)
L_SPK+_1:
  vias: v1(115.45,19.8) v1(116.27,20.28) v1(116.27,19.65)
L_SPK-: length 94.4
  IN3 w1.016: 201.23,19.8 201.23,17.39 201.36,17.26 201.36,15.95 199.26,13.85 190.87,13.85 189.77,14.95 187.23,14.95 185.51,13.22 181.14,13.22 180.12,14.24 170.13,14.24 168.48,12.58 146.43,12.58 144.14,14.87 117,14.87
  BOTTOM w0.203: U35.43 202.94,22.9 202.78,22.74 202.78,21.73 v1(202.63,21.58)
  vias: v1(116.52,15.86) v1(117.16,15.86)
L_SPK-_1:
  vias: v1(117.26,20.28) v1(117.26,19.65)
LAD0: length 8.9
  BOTTOM w0.089: 91.76,39.36 91.64,39.48 91.64,40.36 91.81,40.54 91.81,40.82 91.64,40.98
  BOTTOM w0.099: U30.BA16 91.54,41.89 91.82,41.61 91.82,41.36 91.64,41.17 91.64,40.98
  BOTTOM w0.102: 91.76,39.36 91.86,39.25 91.86,36.69 90.75,35.58 90.75,35.14 90.61,35 90.61,34.9 90.33,34.62 R635.1
LAD1: length 6.3
  BOTTOM w0.089: 92.14,39.74 92.03,39.84 92.03,40.2 92.2,40.37 92.2,40.84 92.34,40.97
  BOTTOM w0.099: 92.34,40.97 92.34,41.19 92.13,41.4 92.13,41.77 U30.BA15
  BOTTOM w0.102: R616.1 92.64,36.31 92.52,36.44 92.52,39.36 92.14,39.74
LAD2: length 9.5
  BOTTOM w0.089: U30.BC13 93.01,40.46 93.12,40.35
  BOTTOM w0.099: 93.12,40.35 93.12,39.74
  BOTTOM w0.102: R644.1 93.66,32.24 93.58,32.32 v1(93.58,32.85) 93.58,33.08 93.48,33.18 93.48,35.11 93.79,35.42 93.79,36.33 93.12,37 93.12,39.74
LAD3: length 5.7
  BOTTOM w0.089: 92.69,40.93 92.81,40.82 92.81,40.36 92.89,40.27
  BOTTOM w0.099: U30.BB14 92.69,41.3 92.69,40.93 ; 92.89,40.27 92.89,39.85
  BOTTOM w0.102: 92.89,39.85 92.89,36.67 R617.1
LAN_AMBLED#: length 1.3
  TOP w0.102: U2.27 45.24,108.33 TP12.1
LAN_LED1: length 3.3
  TOP w0.102: TP11.1 46.09,109.87 46.09,108.95 45.99,108.85 45.99,108.49 45.64,108.15 U2.26
LAN_LED2: length 6.5
  TOP w0.102: TP10.1 49.46,111.11 49.19,111.39 48.09,111.39 47.69,110.98 47.69,110.78 46.98,110.07 46.9,110.07 46.32,109.49 46.32,108.82 46.21,108.72 46.21,108.39 46.04,108.22 U2.25
LAN_MCTG0: length 4.8
  TOP w0.102: R61.2 v1(38.82,110.48)
  TOP w0.508: v1(37.53,109.56) R61.2
  BOTTOM w0.508: v1(37.53,109.56) 37.53,110.4 37.9,110.77 U24.24
LAN_MCTG1: length 5.1
  TOP w0.508: v1(35.11,108.85) 34.73,109.23 R60.2
  BOTTOM w0.508: U24.21 34.9,109.93 35.11,109.71 v1(35.11,108.85)
LAN_MCTG2: length 3.6
  TOP w0.508: R57.2 31.68,109.85 v1(31.9,109.64)
  BOTTOM w0.508: U24.18 v1(31.9,109.64)
LAN_MCTG3: length 3.4
  TOP w0.508: R58.2 28.76,109.77 v1(28.9,109.64)
  BOTTOM w0.508: v1(28.9,109.64) U24.15
LAN_XTAL1: length 3.9
  TOP w0.102: Y1.1 46.11,113.02 46.11,111.8 46,111.53 45.8,111.33 C26.2 45.8,110.75 45.78,110.73 45.74,110.73 45.65,110.65 R64.1
LANPWR#: length 203.6
  TOP w0.102: R55.2 55.95,112.12 56.2,111.87 v1(56.45,111.87) ; R55.2 R56.1 ; R55.2 v1(56.83,112.38) ; v1(170.12,24.95) 170.12,24.48 169.35,23.71 169.35,22.97 168.72,22.34 166.56,22.34 166.38,22.16 U15.16
  IN3 w0.089: v1(170.12,24.95) 169.92,24.95 169.63,25.23 169.63,26.39 169.54,26.49 169.54,26.85 167.7,28.69 165.28,28.69 165.01,28.97 163.66,28.97 162.9,28.21 159.84,28.21 159.14,27.5 159.14,26.4 158.47,25.74 154.73,25.74 154.24,26.22 143.26,26.22 142.62,26.86 142.62,27.62 139.93,30.31 138.64,30.31 138.39,30.57 138.39,31.16 137.44,32.12 137.44,35.51 137.73,35.8 137.73,36.29 136.9,37.12 132.44,37.12 132.37,37.19 131.9,37.19 131.17,37.92 130.14,37.92 128.38,39.67 125.53,39.67 123.14,42.06 123.14,63.28 124.52,64.66 124.52,67.62 123.47,68.67 123.47,71.38 122.7,72.16 118.09,72.16 114.16,76.1 114.16,77.48 112.53,79.11 110.77,79.11 107.94,81.93 107.94,82.99 107.57,83.36 107.44,83.36 106.89,83.91 106.89,89.7 106.42,90.18 106.42,91.66 105.55,92.52 102.89,92.52 100.6,94.81 99.88,94.81 98.61,96.08 97.6,96.08 96.82,96.86 93.76,96.86 93.22,96.32 89.27,96.32 89.03,96.07 78.31,96.07 76.05,98.34 76.05,102.91 74.74,104.23 74.74,105.78 74.1,106.41 72.59,106.41 71.11,107.89 69.97,107.89 67.18,110.68 67.18,111.32 64.21,114.29 60.13,114.29 59.14,115.28 59.14,117.05 v1(58.74,117.46)
  BOTTOM w0.102: v1(56.45,111.87) 57.21,111.87 58.74,113.4 v1(58.74,117.46)
LCD_BL_PWM: length 7.2
  TOP w0.102: R45.1 113.73,117.86 111.45,115.59 111.45,114.04 111.45,114.04 v1(111.45,113.11)
  BOTTOM w0.102: U25.AC38 111.26,112.92 v1(111.45,113.11)
LCD_BLEN: length 8
  TOP w0.102: v1(111.47,112.43) 111.01,112.89 111.01,115.47 112.96,117.42 R44.1
  BOTTOM w0.102: v1(111.47,112.43) 111.16,112.12 U25.AC37
LCD_VDD: length 6.9
  BOTTOM w0.102: R458.1 112.23,120.33 111.85,119.95 111.49,119.95 111.21,119.67 111.21,114.9 110.9,114.59 U25.AC40
LDO_3V3: length 27.7
  TOP w0.254: U19.20 19.61,18.54 19.49,18.66 v1(19.49,18.78)
  TOP w0.381: R401.2 13.27,14.08 v1(12.76,13.58) ; v1(17.64,10.88) 17.48,10.88 R416.2 ; R341.2 R342.2 v1(18.73,21.32) ; R415.2 v1(15.07,11.28) 14.8,11.28 v1(14.41,11.67) 14.41,12.56 14.15,12.82 R408.2
  IN1 w0.381: v1(14.41,11.67) 16.85,11.67 v1(17.64,10.88)
  IN1 w0.508: v1(19.49,18.78) 19.49,20.18 18.73,20.94 v1(18.73,21.32)
  IN3 w0.508: 12.89,13.58 13.52,14.21 13.52,15.1 14.03,15.61 15.94,15.61 19.11,18.78 v1(19.49,18.78) ; 12.89,13.58 13.4,13.58 14.41,12.56 v1(14.41,11.67) ; 12.89,13.58 v1(12.76,13.58)
  BOTTOM w0.381: v1(19.49,18.78) 19.37,18.78 19.24,18.91 C680.2
LID#: length 218.7
  TOP w0.102: R62.2 55.95,110.99 55.81,110.86 55.81,110.22 55.48,109.89 54.29,109.89 54.16,109.76 54.16,109.08 53.15,108.06 v1(53.01,108.06) D4.1 ; v1(151.97,39.37) 155.54,35.8 159.05,35.8 160.35,34.5 R239.2 ; HE1.1 33.95,123.2 34.56,122.59 v1(35.52,122.59) 36.21,121.91 38.03,121.91 38.8,122.67 44,122.67 v1(44.26,122.41) 44.35,122.51 HE2.1
  IN1 w0.089: v1(45.27,115.43) 45.27,115.18 46.54,113.91 46.92,113.91 47.4,114.38 49.62,114.38 50.1,113.91 50.1,110.98 51.12,109.97 52.51,109.97 53.27,109.21 53.27,108.32 v1(53.01,108.06)
  IN2 w0.089: v1(53.01,108.06) 53.01,106.29 53.59,105.71 53.69,105.71 54.75,104.65 54.75,103.35 53.49,102.09 52.35,102.09 52,101.75 52,100.82 52.28,100.54 59.22,100.54 59.62,100.95 62.04,100.95 64.45,98.54 64.45,98.03 66.43,96.05 66.43,95.29 68.77,92.95 68.77,91.43 71.06,89.14 79.31,89.14 81.21,87.24 85.02,87.24 86.04,86.22 93.92,86.22 95.01,85.13 109.61,85.13 109.89,84.85 110.92,84.85 112.15,83.62 112.15,82.48 112.66,81.96 115.2,81.96 115.63,82.39 115.63,83.17 116.52,84.06 122.12,84.06 125.17,81.01 128.52,81.01 129.69,82.17 132.12,82.17 133.79,80.5 135.44,80.5 136.87,79.08 139.03,79.08 142.81,75.3 142.81,71.74 142.3,71.23 142.3,67.3 143.19,66.41 146.62,66.41 149.18,63.85 149.18,62.94 150.07,62.05 150.07,60.72 151.06,59.73 151.06,56.63 151.97,55.72 152.41,54.66 152.41,49.97 151.57,49.14 151.57,47.01 150.56,45.99 150.56,45.12 150.18,44.74 150.18,41.16 v1(151.97,39.37)
  BOTTOM w0.102: v1(35.52,122.59) 35.62,122.49 C538.1 36.03,122 36.12,121.91 D26.1 ; v1(44.26,122.41) 44.89,122.41 45.27,122.8 46.54,122.8 46.92,122.41 46.92,120.64 44.89,118.6 44.89,115.81 v1(45.27,115.43)
LID#_C: length 16.8
  TOP w0.102: R239.1 161.09,34.05 161.18,34.14 D6.1 C353.1 162.63,34.14 163.36,34.87 163.36,35.77 164.02,36.44 167.5,36.44 168.34,35.6 168.92,35.6 v1(170.5,34.02) 170.5,32.89 170.88,32.51 170.88,31.71 171.05,31.53 171.05,30.92 171.22,30.76 U15.118
LINE1-L: length 6.7
  BOTTOM w0.203: U35.22 204.54,30.47 204.79,30.72 205.42,30.72 v1(206.16,31.46)
  BOTTOM w0.381: v1(206.16,31.46) 206.18,31.48 206.18,33.39 206.73,33.93 C631.1
LINE1-R: length 6.6
  BOTTOM w0.203: U35.21 204.13,30.65 204.69,31.21
  BOTTOM w0.381: C626.1 206.44,34.53 v1(205.98,34.07) 205.55,33.64 205.55,31.48 205.28,31.21 204.69,31.21
LINE1-VREFO-L: length 13.6
  IN3 w0.381: v1(209.1,36.94) 209.1,34.94 208.88,34.71 208.88,33.16 208.16,32.45 208.16,30.52 208.42,30.26 208.42,26.78 208.09,26.45 v1(208.09,26.4)
  BOTTOM w0.203: R612.1 v1(209.1,36.94) ; v1(208.09,26.4) 207.83,26.4 207.78,26.46 U35.31
LINE1-VREFO-R: length 14.9
  IN3 w0.381: v1(205.73,37.32) 206.22,37.53 207.5,37.53 208.09,36.94 208.09,35.19 207.99,35.09 207.99,33.54 207.28,32.83 207.28,30.15 207.53,29.89 207.53,27.11 v1(207.45,27.04)
  BOTTOM w0.203: v1(205.73,37.32) 205.8,37.32 205.93,37.45 R609.1 ; v1(207.45,27.04) 207.27,26.86 U35.30
LPC_LAD0: length 149
  TOP w0.102: U15.10 166.35,24.56 166.53,24.37 166.53,23.2 v1(166.94,22.8)
  IN3 w0.102: v1(93.91,15.61) 93.91,14.96 95.68,13.19 107.25,13.19 111.47,17.42 116.65,17.42 117.35,18.12 119.9,18.12 121.07,19.29 122.29,19.29 122.74,19.74 123.38,19.74 124.07,20.43 124.97,20.43 125.33,20.79 126.02,20.79 127.06,21.83 127.44,21.83 128.67,20.6 132.25,20.6 133.37,21.72 137.12,21.72 139.2,19.65 145.03,19.65 145.43,19.24 146.04,19.24 146.34,18.93 148.75,18.93 149.57,18.12 153.53,18.12 153.91,17.74 163.99,17.74 165.8,19.54 165.8,21.65 v1(166.94,22.8) 167.04,22.8 167.78,22.06 167.78,21.5 167.93,21.35 172.17,21.35 173.29,22.47 174.33,22.47 175.91,20.89 178.8,20.89 179.51,20.18 182.31,20.18 182.94,20.81 185.23,20.81 185.63,20.41 188.5,20.41 189.29,21.2 v1(189.29,21.83)
  BOTTOM w0.102: R635.2 90.23,34.05 90.23,33.77 90.36,33.64 90.36,31.23 91.25,30.34 91.25,20.61 93.91,17.94 v1(93.91,15.61) ; v1(189.29,21.83) 189.29,20.94 188.3,19.95 188.3,18.83 189.75,17.39 189.75,15.66 190.03,15.38 CN11.64 191.93,15.38 192.39,14.92 192.39,14.41 192.59,14.21 v1(193.86,14.21) 194.12,14.46 194.12,14.82 193.41,15.54 193.41,16.73 192.97,17.16 R702.2
LPC_LAD1: length 142.7
  TOP w0.102: U15.9 166.35,24.96 167.04,24.27 167.04,23.37 v1(167.62,22.8)
  IN3 w0.102: v1(189.29,22.47) 188.86,22.03 188.86,21.35 188.33,20.81 185.99,20.81 185.56,21.25 182.8,21.25 182.14,20.59 179.67,20.59 178.96,21.3 177.12,21.3 175.95,22.47 174.91,22.47 173.89,23.48 172.73,23.48 171.53,22.29 168.12,22.29 v1(167.62,22.8) 167.21,23.2 166.67,23.2 162.25,18.78 155,18.78 154.37,19.42 146.44,19.42 146.21,19.65 145.59,19.65 145.19,20.05 139.36,20.05 136.57,22.85 132.4,22.85 131.25,21.7 128.14,21.7 127.61,22.24 125.86,22.24 124.46,20.84 123.91,20.84 123.21,20.14 122.5,20.14 122.49,20.15 120.53,20.15 120.31,19.93 120.31,19.24 119.59,18.53 117.18,18.53 116.48,17.82 111.2,17.82 106.98,13.6 99.1,13.6 98.39,14.31 95.21,14.31 v1(94.55,14.97)
  BOTTOM w0.102: CN11.66 189.95,14.88 189.34,15.49 189.34,17.22 187.89,18.66 187.89,20.12 188.85,21.07 188.85,22.02 v1(189.29,22.47) ; v1(94.55,14.97) 95.03,15.45 95.03,18.17 92.19,21.01 v1(92.19,28.43) 92.19,30.52 92.67,31 92.67,35.68 R616.2
LPC_LAD2: length 137.4
  TOP w0.102: v1(168.27,22.8) 168.24,22.8 167.57,23.46 167.57,24.23 166.45,25.36 U15.8
  IN3 w0.102: v1(95.44,14.97) 95.69,14.72 98.61,14.72 99.33,14.01 106.67,14.01 110.89,18.23 116.31,18.23 117.12,19.04 119.49,19.04 119.9,19.44 119.9,20.09 120.37,20.56 122.62,20.56 125.41,23.35 127.27,23.35 128.51,22.11 131.08,22.11 132.23,23.25 136.74,23.25 139.53,20.46 145.36,20.46 145.76,20.06 146.39,20.06 146.62,19.82 154.54,19.82 155.17,19.19 161.19,19.19 165.63,23.63 167.4,23.63 168.24,22.8 v1(168.27,22.8) 168.37,22.69 171.36,22.69 172.66,23.99 173.96,23.99 175.08,22.87 176.12,22.87 177.27,21.72 179.24,21.72 179.97,20.99 181.97,20.99 183.19,22.21 186.75,22.21 187.08,22.54 187.72,22.54 188,22.26 188,22.11 v1(188.4,21.7)
  BOTTOM w0.102: v1(188.4,21.7) 188.4,21.2 187.49,20.29 187.49,18.5 188.94,17.05 188.94,15.32 189.88,14.38 CN11.68 ; v1(95.44,14.97) 95.57,14.97 95.95,15.35 95.95,18.4 93.99,20.36 93.99,24.83 94.42,25.26 v1(94.42,30.85) 93.66,31.61 R644.2
LPC_LAD3: length 140.8
  TOP w0.102: v1(168.05,23.6) 168.05,24.33 166.62,25.76 U15.7
  IN3 w0.102: v1(188.4,22.34) 188.4,22.47 187.92,22.95 186.88,22.95 186.57,22.64 183.05,22.64 182.61,22.21 177.35,22.21 176.08,23.48 176.08,23.99 175.33,24.74 172.84,24.74 171.7,23.61 169.61,23.61 169.1,23.1 168.55,23.1 v1(168.05,23.6) 167.61,24.04 165.47,24.04 162.24,20.81 157.54,20.81 156.78,20.05 155.43,20.05 155.18,20.31 146.75,20.31 146.59,20.46 145.93,20.46 145.53,20.86 139.7,20.86 136.4,24.16 134.37,24.16 134,24.52 132.4,24.52 131.25,23.38 127.81,23.38 127.43,23.76 125.21,23.76 122.41,20.97 120.18,20.97 119.9,20.69 112.62,20.69 106.35,14.41 99.55,14.41 98.36,15.61 v1(95.46,15.61)
  BOTTOM w0.102: CN11.70 189.8,13.88 188.53,15.15 188.53,16.88 187.06,18.35 187.06,20.43 187.97,21.34 187.97,21.91 v1(188.4,22.34) ; R617.2 93.08,35.37 93.08,31.3 93.28,31.1 93.28,28.82 93.03,28.56 93.03,20.75 95.46,18.31 v1(95.46,15.61)
LPC_LFRAME#: length 146.3
  TOP w0.102: v1(163.02,30.21) 163.66,29.58 164.02,29.58 165.06,28.54 166.4,28.54 166.81,28.13 167.29,28.13 168.26,27.16 168.95,27.16 169.28,26.84 169.28,26.28 169.97,25.59 v1(170.11,25.59) 170.63,25.07 170.63,24.13 170.47,23.96 170.47,21.6 171.13,20.94 171.38,20.94 171.77,20.56 171.77,19.42 173.21,17.97 175.62,17.97 176.94,16.65 177.83,16.65 178.51,15.97 178.89,15.97 179.01,15.86 179.92,14.95 179.92,13.09 179.18,12.36 v1(179.18,12.03) ; v1(168.17,25.47) 167.48,26.16 U15.6
  IN1 w0.089: v1(192.85,14.72) 191.83,13.7 191.83,11.19 191.25,10.6 187.92,10.6 186.5,12.03 v1(179.18,12.03) ; v1(168.17,25.47) 168.61,25.03 169.12,25.03 169.68,25.59 v1(170.11,25.59)
  IN2 w0.089: v2(93.58,39.14) 92.89,38.45 92.89,32.57 94.01,31.45 94.45,31.45 95.82,30.09 95.82,29.02 97.38,27.46 99.41,27.46 100.29,28.33 102.89,28.33 105.61,25.61 107.42,25.61 107.89,25.14 111.8,25.14 112.24,25.58 113.41,25.58 113.85,26.02 113.85,27.29 114.74,28.18 118.17,28.18 118.68,27.67 127.32,27.67 128.38,26.61 130.08,26.61 130.36,26.88 137.02,26.88 140.5,30.36 153.14,30.36 153.78,31 158.08,31 159.04,31.96 159.22,31.96 159.23,31.97 159.72,31.97 160.06,31.63 160.06,31.12 160.46,30.72 162.51,30.72 v1(163.02,30.21)
  BOTTOM w0.089: 93.39,40.36 93.2,40.54 93.2,40.84
  BOTTOM w0.099: 93.39,40.36 93.39,39.36 ; U30.BA13 93.14,41.75 93.14,41.39 93.31,41.23 93.31,40.95 93.2,40.84
  BOTTOM w0.102: R712.1 192.59,15.3 192.85,15.05 v1(192.85,14.72) ; R719.1 180.4,13.96 179.18,12.74 v1(179.18,12.03) ; 93.39,39.36 93.39,39.33 v2(93.58,39.14)
LPC_LFRAME#_C: length 2.6
  BOTTOM w0.102: CN11.73 181.63,13.13 v1(181.58,13.18) 181.14,13.62 R719.2
LPC_PD#: length 8.6
  BOTTOM w0.089: 93.64,40.98 93.81,40.82 93.81,40.54 ; 93.79,39.76 94.2,39.36
  BOTTOM w0.099: 93.64,40.98 93.64,41.35 U30.BB13 ; 93.81,40.54 93.79,40.52 93.79,39.76
  BOTTOM w0.102: R640.1 94.14,34.5 94.34,34.7 94.72,34.7 94.88,34.86 94.88,35.29 94.55,35.62 94.55,36.31 93.91,36.94 93.91,38.09 94.23,38.4 94.23,39.33 94.2,39.36
LPC_RST#: length 5.4
  BOTTOM w0.089: 94.46,39.38 94.01,39.83 U30.BC12
  BOTTOM w0.102: 94.46,39.38 94.46,38.69 95.06,38.09 95.06,36.56 95.03,36.54 R619.2
LPC_RST#_EC: length 5.7
  TOP w0.102: R352.2 160.97,18.53 161.09,18.41 C443.1 162.33,18.41 v1(162.34,18.43) 162.34,18.76 162.65,19.06 164.04,19.06 164.74,19.76 U15.22
LPCCLK0: length 6.4
  BOTTOM w0.089: 91.31,40.97 91.19,40.85 91.19,40.51 91.23,40.47 91.23,39.58 91.12,39.46
  BOTTOM w0.099: U30.BB15 91.31,41.3 91.31,40.97
  BOTTOM w0.102: R614.2 90.35,35.87 90.66,36.18 90.67,36.18 91.32,36.84 91.32,38.9 91.12,39.1 91.12,39.46
LPCCLK1: length 7.2
  BOTTOM w0.089: 94.68,39.44 94.2,39.92 94.2,40.84
  BOTTOM w0.099: 94.2,40.84 94.31,40.95 94.31,41.23 94.01,41.53 U30.BA12
  BOTTOM w0.102: R620.2 95.41,35.87 95.41,36.59 95.29,36.71 95.29,38.24 94.7,38.82 94.7,39.42 94.68,39.44
M0_5441: length 4.3
  TOP w0.102: R341.1 17.71,19.54 17.97,19.29 v1(18.23,19.29) 18.23,18.52 18.61,18.14 U19.22
  BOTTOM w0.102: v1(18.23,19.29) 18.48,19.04 18.48,18.23 18.56,18.15 R700.2
M1_5441: length 2.2
  TOP w0.102: U19.21 19.11,18.28 18.73,18.66 v1(18.73,18.88) R342.1
M2_SSD_CLKREQ#: length 5.3
  TOP w0.102: v1(26.6,3.29) 26.35,3.54 R432.1 R433.2 27.76,3.95 27.89,4.08 Q28.3
  BOTTOM w0.102: CN19.52 27.1,2.79 v1(26.6,3.29)
M2_SSD_RST#: length 12.1
  TOP w0.102: v1(27.6,3.27) 27.11,2.78 26.22,2.78 25.97,3.03 25.97,3.42 23.71,5.68 22.46,5.68 v1(22.16,5.37) 21.98,5.37 21.52,5.83 21.52,6.46 21.62,6.56 R429.1 R428.1 21.55,7.13 21.51,7.08 U21.4
  BOTTOM w0.102: CN19.50 v1(27.6,3.27)
M2SSD_PWREN#: length 180.2
  TOP w0.102: R421.1 17.44,9.13 17.62,8.95 19.54,8.95 20.48,9.89 21.91,9.89 22.67,10.65 23.87,10.65 24.47,11.26 24.47,12.4 25.59,13.52 25.59,14.77 v1(25.46,14.9) 25.59,15.02 25.59,16.75 24.29,18.05 24.29,18.69 24.74,19.13 24.98,19.13 26,20.15 26,22.25 26.81,23.06 26.81,26.22 v1(27.24,26.66) ; U15.126 168.02,30.91 v1(167.7,31.23) 167.96,31.48 167.96,31.99 168.18,32.22 R263.1
  IN2 w0.089: v1(167.7,31.23) 165.29,31.23 165.16,31.36 164.53,31.36 164.15,30.97 164.15,30.09 163.87,29.81 160.39,29.81 159.98,30.21 156.58,30.21 156.03,29.67 152.72,29.67 151.57,28.51 146.24,28.51 145.27,29.48 140.42,29.48 137.25,26.31 130.6,26.31 130.31,26.02 123.47,26.02 122.2,24.75 121.35,24.75 120.71,25.39 120.71,25.51 120.43,25.79 115.28,25.79 113.57,24.09 101.43,24.09 99.99,25.54 96.56,25.54 94.78,27.32 84.92,27.32 84.16,26.55 73.48,26.55 72.69,25.77 65.59,25.77 65.21,25.39 62.12,25.39 61.61,24.88 50.58,24.88 48.8,26.66 43.37,26.66 41.08,24.37 37.03,24.37 34.74,26.66 v1(27.24,26.66)
M_A_A0: length 42.6
  TOP w0.102: 79.46,50.34 80.72,50.34 81.28,50.9 81.71,50.9 82.11,50.51 v2(82.11,50.49)
  TOP w0.165: 79.46,50.34 78.89,49.77 78.17,49.77 77.48,50.46 72.11,50.46 65.88,56.69 65.88,57.17 65.63,57.42 62.57,57.42 62.29,57.69 62.29,58.35 62.11,58.53 61.77,58.53 61.61,58.37 61.61,57.79 61.44,57.63 61.11,57.63 60.95,57.79 60.95,58.37 60.78,58.53 60.45,58.53 60.29,58.37 60.29,57.79 60.12,57.63 59.79,57.63 59.62,57.79 59.62,58.37 59.46,58.53 58.23,58.53 57.34,57.64 55.52,57.64 55.39,57.52 v2(55.39,57.09)
  BOTTOM w0.165: CN5.144 50.97,60.46 54.34,57.09 v2(55.39,57.09) ; U30.AK26 82.51,50.89 v2(82.11,50.49)
M_A_A1: length 42.3
  TOP w0.102: v2(83.58,52.49) 83.12,52.95 82.23,52.95 82.1,52.82 81.21,52.82 81.09,52.69
  TOP w0.165: v2(55.69,63.57) 55.45,63.57 55.18,63.84 55.18,64.37 55.29,64.49 55.83,64.49 56.09,64.23 56.43,64.23 56.69,64.49 57.53,64.49 57.91,64.11 57.91,63.87 57.66,63.62 57.66,63.38 57.89,63.15 58.12,63.15 58.38,63.41 58.62,63.41 58.89,63.13 58.89,62.35 59.4,61.85 59.4,61.85 59.79,61.45 65.95,61.45 69.02,58.37 69.02,57.26 69.53,56.76 71.44,56.76 72.86,55.33 73.37,55.33 73.7,55 73.7,54.45 73.98,54.17 73.98,53.2 74.18,53 74.61,53 75.04,52.56 75.7,52.56 76.13,53 79.77,53 80.22,52.54 80.94,52.54 81.09,52.69
  BOTTOM w0.165: U30.AG24 84.08,52.99 v2(83.58,52.49) ; CN5.133 57.44,63.21 57.34,63.11 55.94,63.11 55.69,63.36 v2(55.69,63.57)
M_A_A2: length 43.2
  TOP w0.102: v2(84.49,53.58) 83.98,53.07 83.98,52.16
  TOP w0.165: 83.98,52.16 83.81,51.98 81.9,51.98 81.48,51.56 81.48,51.55 74.74,51.55 74.23,52.06 73.09,52.06 72.38,52.77 71.9,52.77 67.38,57.29 67.38,57.76 65.09,60.06 58.48,60.06 56.68,61.86 55.15,61.86 54.34,61.05 54.34,61.02 v2(54.16,60.84)
  BOTTOM w0.165: v2(84.49,53.58) 84.91,53.17 U30.AG23 ; CN5.132 51.78,63.46 52.21,63.02 53.21,63.02 54.16,62.07 v2(54.16,60.84)
M_A_A3: length 42.4
  TOP w0.165: v2(57.08,63.57) 57.08,62.85 56.88,62.65 56.88,62.42 57.22,62.08 57.46,62.08 57.92,62.54 58.15,62.54 58.42,62.26 58.42,62.03 58.03,61.63 58.03,61.4 58.3,61.13 58.54,61.13 58.93,61.52 59.14,61.52 59.61,61.05 65.79,61.05 66.75,60.08 66.75,59.85 66.46,59.55 66.46,59.32 66.69,59.09 66.92,59.09 67.22,59.38 67.45,59.38 67.69,59.15 67.69,58.92 67.39,58.62 67.39,58.39 67.63,58.15 67.86,58.15 68.16,58.45 68.39,58.45 68.61,58.23 68.61,58 68.13,57.52 68.13,57.09 70.09,55.13 70.33,55.13 70.83,55.63 71.06,55.63 71.29,55.4 71.29,55.16 70.8,54.66 70.8,54.43 71.03,54.2 71.26,54.2 71.76,54.7 72,54.7 72.23,54.46 72.23,54.23 71.73,53.73 71.73,53.5 72.05,53.18 72.6,53.18 73.28,52.5 74.29,52.5 74.84,51.95 75.91,51.95 76.52,52.56 79.64,52.56 80.25,51.96 81.3,51.96 81.46,52.12 v2(81.46,52.43)
  BOTTOM w0.165: v2(81.46,52.43) 81.6,52.56 82.08,52.56 U30.AG26 ; v2(57.08,63.57) 57.08,63.59 57.2,63.71 CN5.131
M_A_A4: length 39.6
  IN1 w0.102: 71.56,55.21 71.56,55.18 71.57,55.18 71.57,55.16 73.78,52.95 79.37,52.95 79.88,53.45 v2(81.46,53.45)
  IN1 w0.14: 71.56,55.21 71.08,55.69 69.65,55.69 65.43,59.9 62.45,59.9 60.18,62.17 60.18,62.94 59.94,63.17 59.18,63.17 57.47,64.88 52.92,64.88 52.67,64.63 52.67,63.95 v2(53.08,63.53)
  BOTTOM w0.165: CN5.128 52.16,64.46 v2(53.08,63.53) ; v2(81.46,53.45) 81.46,53.33 U30.AG27
M_A_A5: length 43.1
  IN1 w0.102: 79.63,52.18 80.63,52.18 81.27,52.82 82.61,52.82 82.74,52.95 85.45,52.95 v2(86.05,53.55)
  IN1 w0.14: v2(54.8,63.57) 55.22,63.99 57.3,63.99 62.12,59.17 65.13,59.17 69.37,54.93 70.79,54.93 71.76,53.96 71.8,53.96 73.83,51.93 76.35,51.93 76.64,51.64 79.08,51.64 79.63,52.18
  BOTTOM w0.165: U30.AF21 86.49,53.99 v2(86.05,53.55) ; CN5.126 52.39,64.96 52.61,64.73 53.63,64.73 v2(54.8,63.57)
M_A_A6: length 39.8
  IN1 w0.102: 74.36,55.36 74.84,54.88 76.11,54.88 77.4,53.58 78.8,53.58 79.31,54.09 83.5,54.09 83.63,53.96 84.94,53.96 v2(85.33,53.57)
  IN1 w0.14: 74.36,55.36 74.36,55.74 73.37,56.73 71.81,56.73 71.61,56.92 69.61,56.92 64.13,62.39 61.79,62.39 60.27,63.91 59.49,63.91 57.49,65.9 55.92,65.9 v2(55.43,65.41)
  BOTTOM w0.165: U30.AF22 85.7,53.94 v2(85.33,53.57) ; v2(55.43,65.41) 55.43,65.26 55.99,64.71 CN5.127
M_A_A7: length 43.2
  IN1 w0.102: v2(82.91,53.49) 82.46,53.05 81.19,53.05 80.7,52.55 73.89,52.55 72.16,54.28 71.96,54.28 71.56,54.68
  IN1 w0.14: 71.56,54.68 70.93,55.31 69.51,55.31 65.28,59.54 62.29,59.54 57.33,64.5 54.24,64.5 54.04,64.29 54.04,63.99 54.29,63.74 54.29,63.18 54.09,62.98 52.13,62.98 51.98,63.13 51.98,65.17 v2(52.22,65.41)
  BOTTOM w0.165: v2(52.22,65.41) 51.67,65.96 CN5.122 ; U30.AF25 83.31,53.89 v2(82.91,53.49)
M_A_A8: length 39.1
  IN1 w0.102: v2(83.7,53.49) 83.31,53.88 79.74,53.88 79.18,53.33 77.28,53.33 76.64,53.96 74.99,53.96 73.85,55.1
  IN1 w0.14: 73.85,55.1 72.59,56.36 71.65,56.36 71.46,56.55 69.45,56.55 64.76,61.25 63.49,61.25 62.67,60.44 62.43,60.44 62.19,60.68 62.19,60.88 62.94,61.63 62.94,61.82 62.74,62.02 62.54,62.02 61.79,61.28 61.6,61.28 61.4,61.47 61.4,61.67 61.6,61.87 61.6,62.06 61.4,62.26 61.2,62.26 61,62.07 60.81,62.07 60.55,62.33 60.55,63.09 60.1,63.54 59.33,63.54 57.48,65.39 56.72,65.39 v2(56.7,65.41)
  BOTTOM w0.165: U30.AF24 84.1,53.89 v2(83.7,53.49) ; v2(56.7,65.41) 56.91,65.21 CN5.125
M_A_A9: length 44
  TOP w0.102: 77.91,53.96 78.29,53.58 79.06,53.58 79.36,53.88 84.19,53.88 84.35,54.05 85.67,54.05 v2(86.1,54.49)
  TOP w0.165: v1(56.07,67.07) 56.07,66.74 55.9,66.58 54.15,66.58 53.97,66.39 53.97,66.01 54.13,65.85 57.29,65.85 58.61,64.53 58.79,64.53 61.08,62.24 66.27,62.24 70.26,58.25 71.44,58.25 73.44,56.25 73.84,56.25 74.98,55.1 76.39,55.1 77.53,53.96 77.91,53.96
  BOTTOM w0.165: v1(56.07,67.07) 56.86,66.28 57.27,66.28 57.34,66.21 CN5.121 ; v2(86.1,54.49) 86.51,54.89 U30.AE21
M_A_A10: length 42.4
  IN1 w0.102: 78.96,48.2 79.26,48.5 80.56,48.5 81.14,49.08 83.6,49.08 83.63,49.06 85.75,49.06 v2(86.22,49.53)
  IN1 w0.14: v2(54.16,55.99) 54.8,56.63 57.08,56.63 58.35,55.36 58.35,55.23 60.13,53.45 62.93,53.45 64.94,51.45 69.31,51.45 73.1,47.66 78.42,47.66 78.96,48.2
  BOTTOM w0.165: v2(54.16,55.99) 54.16,56.25 53.15,57.26 52.77,57.26 52.07,57.96 CN5.146 ; v2(86.22,49.53) 86.51,49.81 U30.AL21
M_A_A11: length 42.3
  TOP w0.102: 77.91,53.45 78.04,53.33 79.82,53.33 79.94,53.45 80.83,53.45 81.24,53.05 81.8,53.05 v2(82.2,53.44)
  TOP w0.165: v2(52.85,65.41) 52.51,65.07 52.51,64.73 53.2,64.05 53.43,64.05 53.53,64.15 53.53,64.88 53.63,64.98 53.94,64.98 54.42,64.5 54.67,64.5 55.05,64.88 57.7,64.88 59.29,63.29 59.29,62.51 59.96,61.84 66.11,61.84 69.42,58.53 69.42,57.42 69.69,57.15 71.6,57.15 73.01,55.74 73.59,55.74 74.19,55.14 74.19,54.56 74.79,53.96 76.52,53.96 77.02,53.45 77.91,53.45
  BOTTOM w0.165: v2(82.2,53.44) 82.2,53.6 U30.AF27 ; CN5.120 51.81,66.46 v2(52.85,65.41)
M_A_A12: length 42.4
  TOP w0.102: v2(84.51,54.49) 84.28,54.49 83.9,54.1 81.2,54.1 81.09,54.22 80.58,54.22
  TOP w0.165: v1(55.66,68.08) 55.66,67.72 55.83,67.55 56.41,67.55 56.7,67.26 56.7,66.51 56.92,66.29 57.58,66.29 61.23,62.64 66.42,62.64 70.42,58.64 71.61,58.64 73.09,57.16 73.49,57.16 74.49,58.16 74.73,58.16 74.96,57.93 74.96,57.7 74.2,56.93 74.2,56.44 74.52,56.12 76.22,56.12 76.52,55.83 76.52,55.61 77.64,54.49 79.54,54.49 79.82,54.22 80.58,54.22
  BOTTOM w0.165: v1(55.66,68.08) 55.71,68.08 57.09,66.71 CN5.119 ; v2(84.51,54.49) 84.51,54.59 U30.AE23
M_A_A13: length 39.8
  IN1 w0.102: v2(84.51,48.49) 84.11,48.09 81.32,48.09 80.58,47.36
  IN1 w0.14: v1(53.78,53.33) 58.35,53.33 59.37,52.31 62.51,52.31 65.69,49.14 66.23,49.14 66.36,49.01 66.36,48.13 66.5,47.99 71.2,47.99 72.78,46.42 77.4,46.42 77.46,46.47 79.31,46.47 80.07,47.23 80.45,47.23 80.58,47.36
  BOTTOM w0.165: CN5.158 52.15,54.96 v1(53.78,53.33) ; v2(84.51,48.49) 84.9,48.89 U30.AM23
M_A_ACT#: length 42.8
  IN1 w0.14: v1(52.26,68.31) 53.15,69.2 57.06,69.2 57.9,68.37 57.9,67.58 60.1,65.38 60.89,65.38 62.4,63.87 65.21,63.87 70.19,58.89 71.81,58.89 72.5,58.2 75.2,58.2 77.15,56.25 77.4,56.25 78.16,55.49 79.68,55.49 80.03,55.83 82.23,55.83 82.39,55.99 84.93,55.99 v2(85.3,56.36)
  BOTTOM w0.165: CN5.114 51.22,67.96 51.37,67.8 51.88,67.8 52.26,68.19 v1(52.26,68.31) ; v2(85.3,56.36) 85.67,55.99 U30.AD22
M_A_ALERT#: length 43.4
  TOP w0.102: TP19.1 84,55.99 84,54.81 v2(83.68,54.49)
  TOP w0.165: v1(52.17,67.03) 52.1,67.1 R173.2
  IN1 w0.102: v2(83.68,54.49) 83.19,54.98 82.14,54.98 81.88,55.23 81.29,55.23 80.66,54.6 80.07,54.6 79.91,54.76 78.08,54.76 77.91,54.6 77.15,54.6 76.39,55.36 76.39,55.74 76.01,56.12 75.12,56.12
  IN1 w0.14: v1(52.17,67.03) 52.19,67.03 52.71,67.55 56.89,67.55 59.79,64.64 60.58,64.64 62.09,63.13 64.91,63.13 69.89,58.15 71.5,58.15 72.19,57.46 73.77,57.46 75.12,56.12
  BOTTOM w0.165: U30.AE24 84.1,54.92 v2(83.68,54.49) ; CN5.116 51.27,67.46 51.33,67.51 51.79,67.51 52.17,67.13 v1(52.17,67.03)
M_A_BG#0: length 42.9
  TOP w0.165: v1(57.03,68.08) 57.21,67.91 57.21,66.85 57.38,66.69 57.81,66.69 57.97,66.85 57.97,68.95 58.1,69.07 58.3,69.07 58.74,68.64 58.74,65.77 61.46,63.05 66.58,63.05 67.36,62.26 67.59,62.26 67.76,62.43 67.99,62.43 68.23,62.2 68.23,61.97 68.06,61.8 68.06,61.56 68.29,61.33 68.53,61.33 68.69,61.5 68.93,61.5 69.16,61.26 69.16,61.03 68.99,60.86 68.99,60.63 69.23,60.4 69.46,60.4 69.62,60.55 69.85,60.55 70.09,60.32 70.09,60.09 69.93,59.93 69.93,59.7 70.59,59.04 71.77,59.04 72.99,57.82 73.37,57.82 73.57,58.03 73.57,58.51 73.74,58.68 75.1,58.68 75.25,58.53 75.25,58.28 77.28,56.25 77.4,56.25 78.04,55.61 78.04,54.92 78.21,54.76 78.6,54.76 78.76,54.92 78.76,55.45 78.93,55.61 79.26,55.61 79.42,55.45 79.42,54.92 79.59,54.76 80.14,54.76 80.35,54.55 81.35,54.55 v2(81.4,54.5)
  BOTTOM w0.165: v1(57.03,68.08) 57.06,68.06 57.06,67.96 57.31,67.71 CN5.115 ; v2(81.4,54.5) 81.4,54.59 U30.AE27
M_A_BG#1: length 45.1
  IN1 w0.102: 74.74,55.36 74.94,55.15 76.21,55.15 77.15,54.22 78.15,54.22 78.41,54.47 79.68,54.47 79.81,54.34 80.71,54.34 81.35,54.98 81.74,54.98 v2(82.22,54.49)
  IN1 w0.14: 74.74,55.36 74.61,55.49 74.61,55.87 73.38,57.1 71.96,57.1 71.77,57.29 69.76,57.29 69.32,57.73 69.32,58.2 64.76,62.76 61.94,62.76 60.43,64.27 59.64,64.27 57.63,66.28 55.31,66.28 54.93,65.9 52.36,65.9 52.21,66.05 52.21,66.38 52.36,66.53 54.16,66.53 v1(54.67,67.04)
  BOTTOM w0.165: v1(54.67,67.04) 54.67,67.3 55.05,67.68 55.05,68.19 55.56,68.69 57.09,68.69 57.57,68.21 CN5.113 ; v2(82.22,54.49) 82.22,54.71 U30.AE26
M_A_BS#0: length 42.6
  TOP w0.102: 77.53,46.47 79.31,46.47 80.94,48.09 84.72,48.09 84.89,48.26 84.89,49.17 v2(85.32,49.6)
  TOP w0.165: v2(54.8,54.47) 54.8,54.24 55.47,53.57 56.2,53.57 56.56,53.2 57.97,53.2 59.12,52.06 65.34,52.06 66.05,52.77 66.46,52.77 72.88,46.34 77.4,46.34 77.53,46.47
  BOTTOM w0.165: CN5.150 51.93,56.96 53.78,55.1 54.16,55.1 v2(54.8,54.47) ; v2(85.32,49.6) U30.AL22
