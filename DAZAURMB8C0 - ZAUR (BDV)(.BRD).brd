# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_TXP3: length 49.8
  IN1 w0.089: v1(107.01,115.85) 107.01,115.72 106.89,115.61 106.28,115.61 104.61,113.93 102.29,113.93 101.84,113.48 101.84,110.43 100.8,109.39 100.8,108.38 100.57,108.15 100.57,105.62 100.75,105.44 100.75,97.29 101.53,96.51 101.53,88.84 105.32,85.05 105.32,81.04 108.19,78.17 108.19,77.54 108.03,77.38 107.76,77.38 107.65,77.49 v1(107.65,77.67)
  BOTTOM w0.102: v1(107.01,115.85) 107.01,115.7 106.96,115.64 106.35,115.64 105.95,115.25 U25.AM41 ; v1(107.65,77.67) 107.65,77.5 107.57,77.42 107.13,77.42 C587.1
PEGX_RST#: length 120.8
  TOP w0.102: v1(95.69,95.62) 94.56,95.62 R103.1 93.53,95.63 93.42,95.73 U3.4 ; v1(105.95,118.02) 106.36,117.61 106.36,116.7 106.74,116.32 107.17,116.32 107.35,116.14 107.96,116.14 108.01,116.19 109.79,116.19 110.3,116.7 110.3,118.99 110.68,119.37 111.19,119.37 111.47,119.09 111.9,119.09 113.6,120.79 113.6,122.54 112.43,123.71 v1(111.81,123.71)
  IN1 w0.089: v1(105.95,118.02) 105.34,117.41 101.48,117.41 101.03,116.95 100.26,116.95 98.68,115.37 98.68,112 97.34,110.67 97.34,100.14 96.63,99.43 96.63,96.43 95.82,95.62 v1(95.69,95.62) ; v1(90.61,123.68) 89.75,122.82 86.24,122.82 86.02,123.05 78.42,123.05 75.63,125.84 72.83,125.84 71.18,124.19 71.18,122.8 67.04,118.65 67.04,114.64 65.8,113.4 64.58,113.4 v1(64.07,112.89)
  IN3 w0.089: v1(90.61,123.68) 93.15,123.68 94.29,122.55 94.29,121.61 95.89,120 99,120 101.26,122.26 105.98,122.26 107.43,123.71 v1(111.81,123.71)
  BOTTOM w0.102: v1(111.81,123.71) 111.69,123.59 R439.1 ; U23.2 62.37,119.54 62.75,119.17 62.75,117.78 62.76,117.77 62.75,117.76 62.75,117.28 63,117.03 63.3,117.03 63.74,116.59 63.74,115.33 63.64,115.23 63.64,114.59 64.07,114.16 v1(64.07,112.89) ; v1(105.95,118.02) 106,118.07 R489.2
PEGX_RST#_R: length 6.6
  BOTTOM w0.102: U25.AV41 102.65,115.24 102.41,115.48 102.41,116.81 102.86,117.26 104.63,117.26 105.55,118.18 R489.1
PLLCHARZ_H: length 8.2
  TOP w0.102: TP15.1 98.11,99.55 99.18,100.63 100.07,100.63 100.95,101.51 103.39,101.51 v1(103.97,100.93)
  BOTTOM w0.102: v1(103.97,100.93) 103.6,100.56 U25.AU15
PLLCHARZ_L: length 8.7
  TOP w0.102: TP16.1 97.54,98.67 99.09,100.22 99.98,100.22 101.05,101.28 102.91,101.28 v1(103.26,100.93)
  BOTTOM w0.102: v1(103.26,100.93) 102.8,100.47 U25.AV15
PLTRST#: length 101.3
  TOP w0.102: R352.1 160.06,18.53 159.96,18.63 R351.1 159.57,19 v1(158.76,19.82) ; R308.1 124.75,24.98 124.9,24.83 128.41,24.83 v1(128.43,24.8) 128.59,24.65 128.59,24.37 128.46,24.24 v1(128.1,24.24)
  IN1 w0.089: v1(128.1,24.24) 128.08,24.22 128.08,22.54 130.87,19.75 134.17,19.75 135.11,20.69 136.43,20.69 138.38,18.74 145.39,18.74 146.39,19.75 149.72,19.75 149.85,19.62 158.56,19.62 v1(158.76,19.82)
  IN3 w0.089: v1(128.1,24.24) 127.72,24.62 124.9,24.62 122.05,21.78 119.85,21.78 119.56,21.49 111.91,21.49 105.64,15.23 100.01,15.23 98.74,16.5 v1(97.09,16.5)
  BOTTOM w0.102: R619.1 95.16,35.7 95.24,35.62 95.24,34.58 94.94,34.28 C634.1 94.32,33.85 94.32,33.23 95.06,32.5 95.06,25.13 94.4,24.47 94.4,20.53 97.09,17.84 v1(97.09,16.5)
PMON: length 4.4
  TOP w0.203: TP25.1 137.95,31.55 PR77.1 ; v1(138.58,32.4) 138.22,32.05 137.95,32.05 137.85,31.94 PC89.2
  TOP w0.254: PR77.1 PC89.2
  BOTTOM w0.198: v1(138.58,32.4) 138.58,32.6 138.03,33.15 PR324.1
PP: length 2.2
  TOP w0.102: R333.2 129.6,20.56 v1(129.47,20.43) 129.42,20.43 128.76,21.1 U16.4
PRE_SEL: length 3.9
  BOTTOM w0.102: U28.27 19.13,81.57 18.22,82.49 R535.1 18.4,82.56 18.73,82.89 18.73,83.4 18.2,83.93 v1(18.2,84.01)
PROCHOT_EC: length 7.3
  TOP w0.102: U15.17 164.71,21.76 164.4,21.45 164.4,20.94 163.99,20.53 v1(163.89,20.53) 163.82,20.46 C676.2 R691.2 162.8,19.9 162.52,20.18 160.64,20.18 Q35.2
PS_0: length 14.9
  BOTTOM w0.102: R512.2 R517.1 C563.1 97.34,101.59 98.23,102.48 98.23,104.38 100.26,106.41 100.52,106.41 101.01,106.9 101.01,107.05 101.28,107.33 101.53,107.33 101.58,107.27 101.88,107.27 102.16,107.56 102.42,107.56 102.55,107.68 103.82,107.68 103.87,107.73 105.61,107.73 U25.AM29
PS_1: length 9.4
  BOTTOM w0.102: C547.1 R501.1 R507.2 ; C547.1 97.1,107.21 v1(97.37,107.48) ; C547.1 99.67,106.67 100.91,107.9 101.19,107.9 101.31,107.78 101.51,107.78 101.64,107.91 101.87,107.91 101.97,107.81 102.22,107.81 102.53,108.12 U25.AV29
PS_2: length 15.5
  BOTTOM w0.102: v1(95.17,111.53) 95.46,111.82 96.2,111.82 96.32,111.94 R498.2 R496.1 C543.1 96.32,114.91 96.45,115.05 97.47,115.05 98.23,114.29 98.23,112 100.26,109.97 100.78,109.97 100.9,110.1 101.16,110.1 101.25,110 101.56,110 101.63,110.08 101.88,110.08 102.11,109.84 102.99,109.84 U25.AU31
PS_3: length 9.9
  BOTTOM w0.102: R499.2 R500.1 C546.1 96.37,108.78 v1(96.63,108.52) 97.55,108.52 98.55,109.53 100.83,109.53 100.94,109.41 101.12,109.41 101.28,109.58 101.52,109.58 101.63,109.47 101.88,109.47 101.96,109.55 102.48,109.55 U25.AV31
PWRLED#: length 74.6
  TOP w0.102: v1(167.79,20.18) 167.79,20.15 166.75,19.11 166.51,19.11 166.35,18.96 U15.24
  IN2 w0.089: v1(167.79,20.18) 168.4,20.79 170.01,20.79 171.26,19.54 175.59,19.54 177.92,17.22 180.24,17.22 182.11,19.09 185.86,19.09 188.06,21.3 190.67,21.3 191.89,20.08 193.72,20.08 197.37,16.43 205.61,16.43 207.83,18.66 210.42,18.66 212.53,20.76 212.53,22.08 211.77,22.85 211.77,25.13 213.68,27.04 213.68,32.63 214.18,33.13 215.58,33.13 v1(216.34,32.37)
  BOTTOM w0.102: CN8.19 214.81,33.9 v1(216.34,32.37)
PX_EN: length 6.8
  BOTTOM w0.102: R449.1 112.23,121.17 111.57,120.51 TP44.1 110.98,119.79 110.98,115.1 U25.AC41
R_SPK+: length 91
  IN3 w1.016: 201.36,23.74 200.98,23.74 200.34,24.37 199.45,24.37 198.69,23.61 196.02,23.61 195.26,22.85 195.26,21.45 195.01,21.2 195.01,17.5 194.44,16.93 191.53,16.93 190.87,17.59 188.56,17.59 186.7,19.44 182.97,19.44 180.4,16.88 176.3,16.88 175.62,17.56 169.69,17.56 167.76,15.63 147.12,15.63 145.24,17.51 143.56,17.51 143.15,17.92 137.64,17.92 137.22,18.34 133.98,18.34 133.44,18.88 127.21,18.88 126.66,18.32 125.13,18.32 124.32,17.51 122.79,17.51
  BOTTOM w0.203: v1(202.01,22.59) 202.13,22.72 U35.45
  vias: v1(121.63,17.31) v1(121.68,16.47) v1(122.34,17.31)
R_SPK+_1:
  vias: v1(119.31,20.28) v1(119.31,19.65)
R_SPK-: length 89
  IN3 w1.016: 119.65,16.19 124.88,16.19 125.69,17 127.21,17 127.77,17.56 132.86,17.56 133.39,17.02 136.67,17.02 137.09,16.6 142.61,16.6 143.01,16.19 144.69,16.19 146.57,14.31 168.31,14.31 170.24,16.24 175.07,16.24 175.75,15.56 180.99,15.56 183.55,18.12 186.14,18.12 188,16.27 190.32,16.27 190.99,15.6 192.71,15.6 192.72,15.61 195.01,15.61 196.4,17 196.4,19.93 197.61,21.13
  BOTTOM w0.203: U35.44 202.54,23.01 202.47,22.95 202.47,22.3 v1(202.01,21.83)
  vias: v1(118.07,15.89) v1(118.88,15.89)
R_SPK-_1:
  vias: v1(118.3,20.28) v1(118.3,19.65)
RAM_ID0: length 17.9
  TOP w0.102: v1(104.33,34.02) 104.71,34.02 104.86,33.87 104.86,32.73 105.09,32.5 105.7,32.5 v1(105.88,32.32) 106.03,32.32 106.41,31.94 107.06,31.94 R266.2 R267.1
  BOTTOM w0.102: U30.BB7 98.61,41.38 98.61,41.03 98.97,40.68 98.97,39.69 99.81,38.85 101.36,38.85 102.55,37.65 102.55,35.04 102.37,34.86 102.37,34.4 103.15,33.62 104.18,33.62 104.33,33.77 v1(104.33,34.02)
RAM_ID1: length 23.6
  TOP w0.102: v1(109.74,38.85) 110.2,38.85 110.61,39.26 R604.2 110.81,39.69 111.34,39.15 R601.1
  IN1 w0.089: v2(108.27,48.68) 108.8,48.14 109.28,48.14 109.59,47.84 109.59,46.67 110.17,46.09 110.17,45.2 109.54,44.56 109.54,43.5 110.35,42.68 110.35,39.46 v1(109.74,38.85)
  BOTTOM w0.102: v2(108.27,48.68) 107.86,48.27 107.52,48.27 107.22,48.58 105.27,48.58 103.06,50.79 102.04,50.79 101.92,50.67 101.68,50.67 101.53,50.81 101.28,50.81 100.96,50.49 U30.AL4
RAM_ID2: length 22.1
  TOP w0.102: R672.1 R664.2 87.89,24.21 88.05,24.37 88.81,24.37 v1(89.32,24.88)
  BOTTOM w0.089: 90.84,39.81 90.84,40.21 90.81,40.25 90.81,40.82 90.64,40.98
  BOTTOM w0.099: 90.64,40.98 90.64,41.35 U30.BB16
  BOTTOM w0.102: 90.84,39.81 90.1,39.07 90.1,36.82 89.85,36.56 89.85,35.39 89.09,34.63 89.09,34.06 88.2,33.17 v1(88.2,30.85) 88.2,30.8 88.43,30.57 89.06,30.57 89.72,29.91 89.72,28.69 89.32,28.28 v1(89.32,24.88)
RAM_ID3: length 16
  TOP w0.102: R243.1 R242.2 93.53,34.28 v1(93.28,34.53) 92.64,35.17 v2(91.91,35.17)
  IN1 w0.089: v2(92.01,46.72) 92.33,46.72 92.52,46.53 92.52,42.28 92.01,41.77 92.01,39.23 92,39.22 92,37.62 91.91,37.53 v2(91.91,35.17)
  BOTTOM w0.102: v2(92.01,46.72) 91.68,46.39 U30.AR15
RASA0B: length 24.8
  TOP w0.102: 123.68,101.89 123.15,102.42 122.75,102.42 122.1,103.07 v1(121.53,103.07)
  TOP w0.127: 123.68,101.89 136.03,101.89 139.79,105.65 140.3,105.65 140.42,105.78 140.42,106.63 v1(141.58,107.78)
  BOTTOM w0.102: U25.D21 121.2,103.4 v1(121.53,103.07)
  BOTTOM w0.127: VRAM1.G3 v1(141.58,107.78)
RASA1B: length 28.7
  TOP w0.102: 122.24,102.5 121.26,102.5 v1(120.89,102.12)
  TOP w0.127: 122.24,102.5 123.99,100.75 135.01,100.75 135.59,100.17 135.77,100.17 135.98,100.38 136.16,100.38 136.34,100.21 136.34,100.03 136.13,99.81 136.13,99.63 136.31,99.45 136.49,99.45 136.7,99.67 136.88,99.67 137.06,99.49 137.06,99.31 136.85,99.09 136.85,98.91 141.26,94.49 141.26,92.91 v1(141.58,92.59)
  BOTTOM w0.102: v1(120.89,102.12) 120.89,102.31 U25.D19
  BOTTOM w0.127: VRAM2.L3 v1(141.58,92.59)
REGN6V: length 9.7
  TOP w0.305: v1(131.11,30.78) 131.3,30.97 PC95.1 131.99,31.49 131.84,31.64 131.84,34.07 131.25,34.66 131.25,35.42 131.68,35.85 132.81,35.85 133.38,35.27 PR65.1
  BOTTOM w0.198: PU14.24 v1(131.11,30.78)
REQ_WLAN#: length 12.7
  BOTTOM w0.102: Q44.1 179.16,20.76 179.61,20.31 180.4,20.31 180.77,20.68 R704.2 ; Q44.1 178.29,21.35 R698.1 ; Q44.1 177.76,19.64 C700.1 177.76,18.63 179.13,17.26 v1(180.91,17.26) 181.78,18.13 CN11.53
RF_EN: length 12.2
  TOP w0.102: R412.2 183.8,12.98 184.47,13.64 v1(184.47,14.08)
  IN1 w0.089: v1(184.47,14.08) 184.59,14.21 186.43,14.21 188.84,16.62 190.79,16.62 v1(191.96,17.79)
  BOTTOM w0.102: CN11.56 191.55,17.38 v1(191.96,17.79)
RING2: length 8
  IN1 w1.016: 208.85,35.04 208.09,34.28 206.56,34.28 204.4,32.12 203.9,32.12
  BOTTOM w0.203: v1(202.88,31.36) 202.47,30.95 202.47,30.36 202.54,30.3 U35.17
  vias: v1(209.48,34.53) v1(210.12,34.53) v1(212.15,40.25) v1(212.15,39.61)
ROMCSB: length 1.7
  TOP w0.102: R6.2 109.15,124.83 109.28,124.7 U1.1
ROMSCK: length 2.1
  TOP w0.102: U1.6 116.77,122.16 117,121.93 R25.2
ROMSI: length 3.2
  TOP w0.102: v1(116.39,119.9) 115.95,120.34 U1.5 117.52,120.89 117.55,120.92 R32.2
ROMSO: length 1.7
  TOP w0.102: R17.2 109.03,123.18 109.28,123.43 U1.2
RSET: length 2.8
  TOP w0.102: U2.31 43.64,107.97 42.99,108.62 42.99,108.98 42.25,109.71 R65.2
RSMRST#: length 85.3
  TOP w0.102: v1(173.77,27.93) 173.32,28.38 173.32,28.74 173.62,29.04 U15.112 ; v1(116.9,38.59) 116.77,38.72 v1(115.63,38.72) 114.74,38.72 114.49,38.47 113.51,38.47 113.22,38.76 113.22,39.1 113.24,39.13 114.22,40.11 D5.1
  IN1 w0.089: v1(173.77,27.93) 173.38,27.53 168.1,27.53 167.83,27.8 166.05,27.8 164.83,26.58 159.57,26.58 158.49,27.67 157.95,27.67 157.74,27.46 156.59,27.46 156.46,27.58 154.53,27.58 153.71,26.76 146.2,26.76 145.77,26.33 144.2,26.33 143.58,25.7 140.33,25.7 139.51,26.53 139.51,29.2 138.42,30.29 138.42,30.87 138.24,31.05 137.52,31.05 136.59,31.98 136.59,32.89 135.92,33.55 132.2,33.55 130.97,34.78 v1(130.49,34.78)
  IN3 w0.089: v1(116.9,38.59) 116.9,37.98 117.56,37.32 118.58,37.32 120.23,35.67 120.74,35.67 123.28,33.13 129.32,33.13 130.49,34.3 v1(130.49,34.78)
  BOTTOM w0.102: R679.1 171.1,21.17 171.38,21.45 171.38,23.61 172.02,24.24 172.02,26.17 v1(173.77,27.93)
RSMRST#_1V8S5: length 24.5
  TOP w0.102: D5.2 114.07,41.81 113.65,42.23 C342.1 ; v2(109.87,42) 109.87,42.43 110.14,42.7 113.17,42.7 113.41,42.47 C342.1 ; C342.1 R223.2 C344.2
  IN2 w0.089: v2(109.87,42) 109.97,42.1 109.97,42.96 109.55,43.38 107.75,43.38 107.15,42.79 106.49,42.79 105.37,41.67 105.37,41.54 104.96,41.13 104.71,41.13 103.82,42.02 103.82,42.53 102.93,43.42 102.04,43.42 100.39,45.07 98.67,45.07 v2(98.22,45.52)
  BOTTOM w0.102: v2(98.22,45.52) 97.75,45.99 U30.AR8
RSVD_ID0: length 21.8
  TOP w0.102: R151.1 98.99,78.48 R158.2 98.92,77.9 98.92,76.77 99.12,76.57 99.12,76.15 v1(98.64,75.68)
  IN3 w0.089: v1(98.64,75.68) 98.06,75.09 98.06,74.23 96.72,72.9 96.19,72.9 94.61,71.33 94.61,66.61 95.63,65.6 95.63,63.75 96.4,62.98 96.86,62.98 v2(97.34,62.5)
  BOTTOM w0.102: v2(97.34,62.5) 97.34,62.35 U30.T8
RSVD_ID1: length 18.8
  TOP w0.102: v1(98.64,75.04) 99.27,75.67 R166.2 R167.1
  IN3 w0.089: v2(98.11,63.49) 97.72,63.49 96.96,64.25 96.65,64.25 96.01,64.88 96.01,65.76 94.99,66.77 94.99,71.17 96.07,72.25 97.07,72.25 99.12,74.3 99.12,74.56 v1(98.64,75.04)
  BOTTOM w0.102: U30.P8 97.7,63.89 v2(98.11,63.49)
RSVD_ID2: length 18.4
  TOP w0.102: R168.1 101.4,75.28 R172.2 v1(100.54,74.66) 98.89,74.66 v1(98.64,74.41)
  IN3 w0.089: v1(98.64,74.41) 96.86,72.63 96.19,72.63 94.8,71.25 94.8,66.69 95.82,65.68 95.82,64.12 96.44,63.5 v2(96.65,63.5)
  BOTTOM w0.102: v2(96.65,63.5) 96.91,63.25 U30.R9
RSVD_ID3: length 20.4
  TOP w0.102: v1(98.64,76.31) 98.61,76.31 98.49,76.44 R163.1 R162.2
  IN3 w0.089: v1(98.64,76.31) 98.49,76.31 98.11,76.69 97.22,76.69 97.09,76.57 97.09,74.07 94.42,71.41 94.42,66.53 95.44,65.52 95.44,63.67 v2(96.6,62.51)
  BOTTOM w0.102: U30.T9 96.6,62.3 v2(96.6,62.51)
RTC_CLK_APU: length 10.7
  BOTTOM w0.089: 98.33,39.74 98.21,39.87 98.21,40.85 98.35,41
  BOTTOM w0.102: 98.33,39.74 98.61,39.74 99.71,38.64 101.26,38.64 102.17,37.73 R627.2 ; 98.35,41 98.35,41.18 97.98,41.55 97.91,41.55 97.08,42.38 97.08,42.71 U30.AW10
RTC_CLK_APU_C: length 4.2
  BOTTOM w0.102: R627.1 102.3,35.57 102.3,35.17 102.14,35.01 102.14,34.3 102.8,33.64 102.8,33.01 102.42,32.63 U33.2
S0A3_GPIO: length 33.5
  TOP w0.102: v1(106.61,27.8) 106.74,27.67 v1(106.74,26.63) 106.74,26.48 106.03,25.77 105.09,25.77 104.83,25.5 C413.1 R313.2 104.58,23.99 104.08,24.5 U14.2
  IN2 w0.089: v1(106.61,27.8) 106.49,27.93 104.46,27.93 103.57,28.82 99.38,28.82 98.61,29.58 97.66,29.58 96.9,30.34 96.9,32.06 96.61,32.35 95.16,32.35 93.48,34.02 93.48,36.44 93.53,36.49 93.53,37.58 94.3,38.34 94.3,39.48 93.99,39.79 v2(93.99,42.91)
  BOTTOM w0.102: U30.AW13 93.61,43.29 v2(93.99,42.91)
S5_ON: length 192.2
  TOP w0.102: R255.1 180.81,32.02 180.4,31.61 179.89,31.61 179.03,30.75 178.57,30.75 178.42,30.59 U15.100 178.42,28.8 177.77,28.15 176.64,28.15 v1(176.16,28.64) ; PR93.1 27.39,27.29 27.67,27.01 27.67,26.3 27.39,26.02 v1(27.24,26.02)
  TOP w0.508: PR103.2 v1(39.82,23.74)
  IN2 w0.089: v1(176.16,28.64) 175.73,29.07 173.67,29.07 173.23,28.62 173.23,28.37 172.93,28.08 171.79,28.08 171.47,28.4 171.47,28.71 170.73,29.45 169.51,29.45 169.36,29.6 164.22,29.6 163.24,28.62 160.49,28.62 159.54,29.58 v1(156.81,29.58) 156.49,29.26 153.83,29.26 152.69,28.12 146.09,28.12 145.11,29.09 140.74,29.09 139.49,27.84 139.49,26.9 138.51,25.93 130.76,25.93 130.44,25.61 123.6,25.61 122.23,24.24 121.19,24.24 120.69,24.75 119.9,24.75 119.26,25.39 115.63,25.39 113.93,23.68 100.94,23.68 99.46,25.16 96.3,25.16 94.55,26.91 86.9,26.91 86.14,26.15 73.61,26.15 72.76,25.3 69.47,25.3 68.9,24.73 61.73,24.73 61.69,24.69 50.5,24.69 48.72,26.47 43.46,26.47 40.73,23.74 v1(39.82,23.74) 39.81,23.74 39.38,24.17 36.96,24.17 35.1,26.02 v1(27.24,26.02)
  IN3 w0.089: v1(156.81,29.58) 156.81,30.11 157.67,30.97 157.67,31.69 156.88,32.47 156.88,33.76 154.04,36.6 151.95,36.6 150.47,38.08 150.47,42.75 149.67,43.55 v1(149.67,44.18)
  BOTTOM w0.203: PR299.1 v1(149.67,44.18)
SATA_RXN0_CN: length 6.7
  TOP w0.102: v1(209.99,11.54) 209.59,11.95 209.59,12.23 209.69,12.33 C506.1
  BOTTOM w0.102: HD1.8 213.54,12.82 213.37,12.99 210.81,12.99 210.5,12.69 210.12,12.69 209.69,12.25 209.69,11.85 v1(209.99,11.54)
SATA_RXN0_HDD: length 164.3
  TOP w0.102: v1(209.99,21.22) 209.87,21.09 209.87,20.79 C437.2
  IN1 w0.089: v1(209.99,21.22) 209.79,21.02 209.79,19.06 207.71,16.98 207.71,16.22 207.22,15.73 206.47,15.73 206.25,15.51 201.52,15.51 200.88,16.14 198.09,16.14 196.4,17.82 196.4,18.35 193.79,20.97 190.66,20.97 189.87,20.18 188.27,20.18 187.66,19.57 182.71,19.57 179.01,15.86 146.4,15.86 146.12,16.14 137,16.14 136.54,16.6 133.06,16.6 132.52,17.13 125.76,17.13 124.87,16.24 121.66,16.24 119.98,17.93 119.98,22.37 118.99,23.35 116.27,23.35 113.75,25.87 113.75,29.94 112.1,31.59 112.1,42.43 112.25,42.58 112.25,46.8 111.19,47.86 111.19,51.67 109.69,53.17 109.69,57.42 102.31,64.8 99.77,64.8 99.54,65.04 97.5,65.04 96.61,65.93 96.61,66.31 v2(96.45,66.47)
  BOTTOM w0.102: U30.L10 96.1,66.81 v2(96.45,66.47)
SATA_RXN0_IN: length 2.2
  TOP w0.102: C437.1 209.82,20.03 209.82,19.37 209.59,19.14 209.59,18.93 209.75,18.77 U18.4
SATA_RXN1A_C: length 3.5
  TOP w0.102: C456.1 134.04,17.38 133.92,17.26 133.92,17 134.4,16.52 134.4,16.27 v1(134.58,16.09)
  BOTTOM w0.102: CN17.5 134.85,17.17 134.68,17 134.68,16.67 134.43,16.42 134.43,16.24 v1(134.58,16.09)
SATA_RXN1A_ODD: length 76.7
  TOP w0.102: v1(134.35,20.81) 134.33,20.79 134.33,19.92 133.92,19.52 133.92,18.54 C456.2
  IN1 w0.089: v2(96.02,68.13) 96.18,67.98 96.53,67.98 96.73,67.78 98.01,67.78 98.28,68.05 101.27,68.05 101.53,68.31 103.19,68.31 104.96,66.53 104.96,65.43 112.23,58.17 112.23,55.71 115.58,52.35 115.58,42.96 116.52,42.02 116.52,39.76 116.24,39.48 116.24,37.73 116.9,37.07 116.9,31.23 120.86,27.27 123.66,27.27 125.92,25.01 128.46,25.01 128.81,24.65 128.81,23.76 130.36,22.21 132.9,22.21 133.49,21.63 133.97,21.63 134.15,21.45 134.15,21.01 v1(134.35,20.81)
  BOTTOM w0.102: U30.J11 95.76,68.13 v2(96.02,68.13)
SATA_RXN_OUT: length 1.8
  TOP w0.102: U18.12 209.75,13.8 209.62,13.67 209.62,13.03 C506.2
SATA_RXP0_CN: length 6.7
  TOP w0.102: C505.1 209.33,12.11 209.33,11.57 v1(209.36,11.54)
  BOTTOM w0.102: v1(209.36,11.54) 209.43,11.62 209.43,12.36 210.01,12.94 210.4,12.94 210.7,13.24 213.35,13.24 213.42,13.32 HD1.7
SATA_RXP0_HDD: length 164.2
  TOP w0.102: C436.2 209.52,20.66 209.61,20.75 209.61,20.97 v1(209.36,21.22)
  IN1 w0.089: v2(97.15,66.46) 96.84,66.15 96.84,66.03 97.6,65.26 99.63,65.26 99.87,65.03 102.4,65.03 109.92,57.51 109.92,53.27 111.42,51.77 111.42,47.96 112.48,46.89 112.48,42.49 112.33,42.33 112.33,31.69 113.98,30.03 113.98,25.96 116.36,23.58 119.09,23.58 120.2,22.47 120.2,18.02 121.75,16.47 124.78,16.47 125.66,17.36 132.62,17.36 133.15,16.83 136.64,16.83 137.09,16.37 146.21,16.37 146.49,16.09 178.91,16.09 182.62,19.8 187.56,19.8 188.17,20.41 189.77,20.41 190.56,21.2 193.88,21.2 196.63,18.44 196.63,17.92 198.18,16.37 200.98,16.37 201.61,15.73 206.15,15.73 206.38,15.96 207.12,15.96 207.48,16.32 207.48,17.07 209.56,19.16 209.56,21.02 v1(209.36,21.22)
  BOTTOM w0.102: v2(97.15,66.46) 97.34,66.65 97.34,66.87 97.22,66.99 U30.L9
SATA_RXP0_IN: length 2.2
  TOP w0.102: C436.1 209.56,19.88 209.56,19.47 209.33,19.24 209.33,18.88 209.25,18.8 U18.5
SATA_RXP1A_C: length 3.6
  TOP w0.102: C455.1 133.55,17.38 133.67,17.26 133.67,16.9 134.15,16.42 134.15,16.29 v1(133.95,16.09)
  BOTTOM w0.102: CN17.6 134.35,17.08 134.43,17 134.43,16.78 134.17,16.52 134.17,16.32 v1(133.95,16.09)
SATA_RXP1A_ODD: length 76.7
  TOP w0.102: v1(133.69,20.81) 134.07,20.43 134.07,20.03 133.67,19.62 133.67,18.26 133.56,18.16 C455.2
  IN1 w0.089: v1(133.69,20.81) 133.87,20.81 133.92,20.86 133.92,21.35 133.88,21.4 133.39,21.4 132.81,21.98 130.27,21.98 128.59,23.67 128.59,24.55 128.36,24.78 125.82,24.78 123.56,27.04 120.77,27.04 116.67,31.13 116.67,36.98 116.01,37.64 116.01,39.58 116.29,39.86 116.29,41.93 115.35,42.87 115.35,52.26 112,55.61 112,58.08 104.74,65.34 104.74,66.44 103.09,68.08 101.63,68.08 101.37,67.82 98.38,67.82 98.11,67.55 96.64,67.55 96.44,67.75 96.28,67.75 v2(96.07,67.55)
  BOTTOM w0.102: v2(96.07,67.55) 95.54,67.55 U30.K11
SATA_RXP_OUT: length 1.8
  TOP w0.102: U18.11 209.25,13.8 209.37,13.67 209.37,13.05 C505.2
SATA_TXN0_CN: length 5
  TOP w0.102: C507.1 210.88,12.08 210.88,11.92 v1(210.63,11.67)
  BOTTOM w0.102: HD1.10 213.02,11.82 212.33,12.51 211.23,12.51 210.81,12.08 210.81,11.85 v1(210.63,11.67)
SATA_TXN0_HDD: length 159.3
  TOP w0.102: v1(210.76,21.2) 210.96,20.99 210.96,20.86 C438.2
  IN1 w0.089: v1(210.76,21.2) 210.96,21.4 210.96,22.01 210.48,22.49 209.64,22.49 208.85,21.7 208.85,20.97 207.81,19.93 207.81,18.76 205.36,16.32 202.04,16.32 201.08,17.28 199.74,17.28 198.59,18.43 197.65,18.43 193.71,22.36 190.84,22.36 189.44,20.97 179.8,20.97 179.63,21.13 177.8,21.13 177.1,20.43 177.1,20.2 175.93,19.04 166.3,19.04 165.21,17.94 149.39,17.94 148.3,19.04 146.67,19.04 145.68,18.05 138.09,18.05 137.6,18.53 133.92,18.53 133.41,19.04 124.07,19.04 123.53,19.58 123.53,25.04 122.49,26.08 120.53,26.08 114.77,31.84 114.77,37.1 114.39,37.48 114.39,38.18 114.9,38.69 114.9,39.39 114.64,39.64 114.64,51.96 111.29,55.31 111.29,57.8 103.31,65.78 103.31,66.34 102.99,66.66 102.04,66.66 101.72,66.98 v2(100.51,66.98)
  BOTTOM w0.102: v2(100.51,66.98) 100.61,67.07 U30.K4
SATA_TXN0_IN: length 2.2
  TOP w0.102: C438.1 211.01,19.95 211.01,19.65 210.88,19.52 210.88,19.04 210.75,18.9 U18.2
SATA_TXN1A_C: length 3.2
  TOP w0.102: v1(136.31,16.14) 136.13,16.32 136.13,16.88 135.95,17.06 135.95,17.26 136.07,17.38 C458.1
  BOTTOM w0.102: v1(136.31,16.14) 136.16,16.29 136.16,16.29 136.16,16.83 136.35,17.02 CN17.2
SATA_TXN1A_ODD: length 75
  TOP w0.102: v1(134.94,22.34) 134.72,22.12 134.72,21.89 135.09,21.53 135.09,19.67 135.19,19.57 135.19,19.25 135.8,18.64 135.8,18.3 135.94,18.16 C458.2
  IN1 w0.089: v1(134.94,22.34) 134.76,22.52 134.76,22.79 134.55,23 132.01,23 129.24,25.77 126.24,25.77 123.96,28.05 121.16,28.05 118.43,30.79 118.43,38.47 117.28,39.61 117.28,42.51 116.75,43.04 116.75,52.18 112.94,55.99 112.94,59.19 110.36,61.77 109.85,61.77 106.11,65.52 106.11,67.8 104.33,69.58 103.9,69.58 103.59,69.28 103.59,69.1 v1(103.31,68.82)
  BOTTOM w0.102: v1(103.31,68.82) 103.61,69.12 103.61,69.26 103.44,69.43 103.09,69.43 102.08,68.43 101.47,68.43 U30.J2
SATA_TXN_OUT: length 1.8
  TOP w0.102: U18.14 210.75,13.8 210.87,13.67 210.87,13.03 C507.2
SATA_TXP0_CN: length 5
  TOP w0.102: v1(211.39,11.67) 211.26,11.67 211.14,11.8 211.14,12.08 C508.1
  BOTTOM w0.102: HD1.11 213.41,11.32 213.16,11.57 212.91,11.57 212.22,12.25 211.34,12.25 211.06,11.97 211.06,11.75 211.14,11.67 v1(211.39,11.67)
SATA_TXP0_HDD: length 159.4
  TOP w0.102: v1(211.39,21.2) 211.21,21.02 211.21,20.79 211.34,20.66 C439.2
  IN1 w0.089: v1(211.39,21.2) 211.19,21.4 211.19,22.11 210.58,22.72 209.54,22.72 208.62,21.8 208.62,21.07 207.58,20.03 207.58,18.86 205.27,16.55 202.14,16.55 201.17,17.51 199.83,17.51 198.69,18.66 197.74,18.66 193.81,22.59 190.75,22.59 189.35,21.2 179.89,21.2 179.73,21.36 177.7,21.36 176.87,20.53 176.87,20.3 175.84,19.26 166.21,19.26 165.12,18.17 149.48,18.17 148.39,19.26 146.58,19.26 145.59,18.27 138.18,18.27 137.7,18.76 134.01,18.76 133.51,19.26 124.17,19.26 123.76,19.67 123.76,25.13 122.58,26.31 120.62,26.31 115,31.93 115,37.2 114.62,37.58 114.62,38.09 115.12,38.59 115.12,39.48 114.87,39.74 114.87,52.06 111.52,55.41 111.52,57.89 103.54,65.87 103.54,66.44 103.08,66.89 102.14,66.89 101.98,67.05 101.98,67.48 v2(102.19,67.69)
  BOTTOM w0.102: U30.K2 101.5,67.59 102.09,67.59 v2(102.19,67.69)
SATA_TXP0_IN: length 2.1
  TOP w0.102: C439.1 211.26,19.95 211.26,19.54 211.14,19.42 211.14,19.04 211.25,18.92 U18.1
SATA_TXP1A_C: length 3.2
  TOP w0.102: C457.1 135.58,17.38 135.7,17.26 135.7,16.95 135.88,16.78 135.88,16.34 v1(135.67,16.14)
  BOTTOM w0.102: v1(135.67,16.14) 135.91,16.38 135.91,16.92 135.85,16.98 CN17.3
SATA_TXP1A_ODD: length 75
  TOP w0.102: v1(134.3,22.34) 134.47,22.17 134.47,21.79 134.83,21.42 134.83,19.57 134.94,19.46 134.94,19.14 135.55,18.53 135.55,18.38 C457.2
  IN1 w0.089: v1(103.95,68.82) 103.82,68.95 103.82,69.18 103.99,69.35 104.23,69.35 105.88,67.71 105.88,65.42 109.76,61.54 110.27,61.54 112.71,59.1 112.71,55.89 116.52,52.08 116.52,42.94 117.05,42.41 117.05,39.52 118.2,38.37 118.2,30.69 121.07,27.82 123.86,27.82 126.15,25.54 129.14,25.54 131.91,22.77 134.45,22.77 134.53,22.69 134.53,22.57 v1(134.3,22.34)
  BOTTOM w0.102: U30.J4 101.35,68.8 101.54,68.8 101.66,68.68 101.98,68.68 102.98,69.68 103.55,69.68 103.86,69.37 103.86,68.9 v1(103.95,68.82)
SATA_TXP_OUT: length 1.8
  TOP w0.102: U18.15 211.25,13.8 211.12,13.67 211.12,13.05 C508.2
SCL: length 19.8
  TOP w0.102: v1(111.47,111.7) 111.87,112.1 111.87,115.68 115.5,119.32 117.46,119.32 118.02,119.87 v1(118.02,120.18) 118.32,120.18 118.86,120.71 118.86,120.94 119.11,121.19 119.11,122.92 118.88,123.15 118.38,123.15 118.22,123.31 118.22,125.13 118.4,125.31 R2.2
  BOTTOM w0.102: U25.AC35 111.09,111.32 v1(111.47,111.7)
SDA: length 18.1
  TOP w0.102: R9.2 118.93,123.43 119.34,123.02 119.34,121.1 119.09,120.85 119.09,120.62 117.55,119.09 115.99,119.09 v1(115.71,118.81) 115.47,118.57 115.09,118.57 112.33,115.81 112.33,113.85 112.1,113.63 112.1,111.54 v1(111.49,110.93)
  BOTTOM w0.102: U25.AC34 111.08,110.52 v1(111.49,110.93)
SEN_A0: length 3.9
  TOP w0.102: R59.1 142.61,111.38 v1(142.48,111.26)
  BOTTOM w0.102: VRAM1.J10 140.58,112.78 140.58,112.17 141.49,111.26 v1(142.48,111.26)
SEN_A1: length 4.3
  TOP w0.102: R120.1 142.84,87.42 v1(142.71,87.55)
  BOTTOM w0.102: v1(142.71,87.55) 142.38,87.88 140.7,87.88 140.38,87.56 VRAM2.J10
SENSEA:
  vias: v1(200.14,30.49)
SERIRQ: length 117
  TOP w0.102: v1(168.7,23.6) 168.7,23.97 169.35,24.62 169.35,25.54 168.33,26.56 U15.5
  IN3 w0.102: v1(168.7,23.6) 168.7,23.71 167.96,24.45 165.3,24.45 162.15,21.3 139.84,21.3 136.57,24.57 134.53,24.57 134.17,24.93 132.23,24.93 131.08,23.79 127.98,23.79 127.6,24.17 125,24.17 122.21,21.37 120.01,21.37 119.73,21.09 112.08,21.09 105.8,14.82 99.78,14.82 98.59,16.01 96.18,16.01 95.95,16.24 95.18,16.24 v1(94.55,15.61)
  BOTTOM w0.099: U30.BC15 92.01,40.45 91.83,40.28 91.83,39.66
  BOTTOM w0.102: 91.83,39.66 92.14,39.36 92.14,36.41 R615.1 91.65,36.15 91.02,35.52 91.02,34.66 90.87,34.5 90.87,31.33 91.76,30.44 v1(91.76,27.16) 91.76,20.87 94.55,18.07 v1(94.55,15.61)
SI_SS_SEL: length 3.8
  BOTTOM w0.102: U22.5 104.58,120.51 104.46,120.64 103.57,120.64 v1(103.36,120.43) 103.19,120.26 R479.1 R478.1
SI_VDD: length 0.8
  BOTTOM w0.203: FB1.1 103.69,121.19 103.75,121.14 U22.1
SI_XTALIN: length 6.7
  TOP w0.102: R18.1 104.84,122.44 v1(104.23,121.83)
  BOTTOM w0.102: Y2.1 103.95,124.27 103.95,122.91 C535.1 R442.2 v1(104.23,121.83) 104.23,121.75 104.58,121.4 U22.2
SI_XTALOUT: length 5.7
  TOP w0.102: R27.2 105.42,122.31 105.29,122.31 104.96,121.98 v1(104.96,121.86)
  BOTTOM w0.102: U22.3 104.98,121.42 105.07,121.5 105.07,121.75 v1(104.96,121.86) 104.76,121.86 104.68,121.93 R442.1 104.96,122.41 105.12,122.26 105.31,122.26 C536.1 105.46,122.7 105.34,122.82 104.71,122.82 104.58,122.95 104.58,123.05 Y2.3
SIO_EXT_SCI#: length 104.2
  TOP w0.102: v1(170.04,23.13) 170.04,22.26 168.92,21.14 167.97,21.14 167.32,20.49 167.32,20 166.67,19.36 U15.23
  IN1 w0.089: v1(123.76,38.72) 124.27,38.21 124.27,35.04 125.55,33.75 127.19,33.75 128.9,32.04 128.9,31.44 132.1,28.24 134.6,28.24 135,27.85 135,27.09 135.4,26.68 136.14,26.68 139.39,23.43 145.15,23.43 145.74,24.03 157.74,24.03 157.97,24.26 162.45,24.26 162.81,23.9 167.16,23.9 167.86,23.2 169.97,23.2 v1(170.04,23.13)
  IN2 w0.089: v1(123.76,38.72) 123.25,39.23 119.31,39.23 117.41,41.13 117.41,42.84 117.33,42.91 117.33,49.47 116.24,50.56 115.78,50.56 114.49,49.26 114.49,47.61 113.32,46.44 110.83,46.44 109.92,47.36 109.92,47.64 109.5,48.06 108.71,48.06 107.25,46.6 v2(107.25,46.47) 107.11,46.33 101.12,46.33 100.46,46.99 v2(100.46,47.02)
  BOTTOM w0.102: R589.1 109.02,46.34 108.9,46.23 107.49,46.23 v2(107.25,46.47) ; v2(100.46,47.02) 100.61,47.16 U30.AP4
SIO_RCIN#: length 100.2
  TOP w0.102: U15.4 164.78,26.96 164.32,26.5 R285.1 163.16,26.5 162.85,26.81 162.09,26.81 161.86,27.04 v1(161.86,27.42) 161.86,27.67 161.53,28 161.53,29.27 160.88,29.93 v1(160.88,30.21)
  IN2 w0.089: v2(92.03,46) 93.38,44.65 93.38,39.51 92.7,38.82 92.7,32.45 94.04,31.1 94.42,31.1 95.57,29.96 95.57,28.99 97.29,27.27 99.6,27.27 100.47,28.13 102.82,28.13 105.54,25.41 107.35,25.41 107.81,24.95 111.88,24.95 112.31,25.39 113.6,25.39 114.62,26.4 119.06,26.4 120.14,27.48 127.24,27.48 128.3,26.41 130.16,26.41 130.44,26.69 137.1,26.69 140.56,30.16 152.62,30.16 152.74,30.05 155.87,30.05 156.55,30.72 158.18,30.72 159.1,31.64 159.17,31.64 159.31,31.78 159.64,31.78 159.87,31.55 159.87,30.9 160.56,30.21 v1(160.88,30.21)
  BOTTOM w0.102: U30.AT15 91.62,45.59 v2(92.03,46)
SL_CLK_100M: length 1.1
  BOTTOM w0.102: U22.4 104.98,119.89 104.81,119.72 R480.2
SLEEVE: length 14
  IN2 w1.016: 204.4,30.59 203.9,30.09 ; 204.53,30.72 205.55,31.74 206.67,31.74 207.71,32.78 207.71,34.02 208.21,34.53 208.21,37.45 209.23,38.47 211.26,38.47
  BOTTOM w0.203: U35.18 v1(202.94,30.67)
  vias: v1(209.48,33.9) v1(210.12,33.9) v1(212.15,38.85) v1(212.15,38.21)
SMB_RUN_CLK: length 106.4
  TOP w0.102: R286.2 v1(71.82,26.4) ; R387.1 v1(67.24,14.39) 67.68,13.96 v1(72.1,13.96) 72.45,14.31 R395.1
  IN1 w0.089: v1(71.82,26.4) 72.43,27.01 76.5,27.01 76.86,26.66 80.28,26.66 81.55,27.93 83.7,27.93 84.21,28.43 92.59,28.43 93.1,28.94 93.1,33.21 93.23,33.34 93.23,37.02 93.28,37.07 93.28,37.58 93.97,38.26 93.97,39.31 93.83,39.44 93.83,42.01 93.28,42.55 93.28,48.75 93.66,49.14 94.55,49.14 95,48.69 v2(95,48.49)
  IN2 w0.089: v1(67.24,14.39) 66.79,13.93 63.21,13.93 v1(62.67,14.46)
  BOTTOM w0.102: v2(95,48.49) 95,48.48 U30.AN12 ; CN5.253 57.44,31.21 55.92,29.68 55.92,28.33 56.72,27.52 60.03,27.52 61.05,26.5 61.05,22.73 61.91,21.87 61.91,20.94 63.69,19.16 63.69,16.62 62.67,15.61 v1(62.67,14.46) ; v1(71.82,26.4) 72.25,25.97 72.66,25.97 72.83,26.15 75.37,26.15 76.06,25.46 76.06,24.95 76.9,24.12 77.48,24.12 78.06,23.54 78.06,21.59 73.96,17.49 71.42,17.49 70.7,16.77 70.7,15.5 70.04,14.85 67.7,14.85 v1(67.24,14.39)
SMB_RUN_DAT: length 108.5
  TOP w0.102: R394.1 69.51,14.7 69.2,14.39 v1(67.88,14.39) 67.88,14.97 68.01,15.1 R379.1 ; v1(72.45,26.4) 72.58,26.53 R287.2
  IN1 w0.089: v2(95,47.52) 94.42,48.1 94.42,48.63 94.3,48.75 93.79,48.75 93.53,48.5 93.53,42.79 94.17,42.15 94.17,39.74 94.32,39.58 94.32,38.11 93.62,37.41 93.62,35.76 93.57,35.71 93.57,33.2 93.45,33.08 93.45,28.78 92.75,28.08 84.42,28.08 83.88,27.55 81.67,27.55 80.4,26.28 76.76,26.28 76.37,26.66 72.71,26.66 v1(72.45,26.4)
  IN2 w0.089: v1(62.04,14.46) 62.93,13.58 67.07,13.58 v1(67.88,14.39)
  BOTTOM w0.102: v1(67.88,14.39) 67.98,14.49 70.19,14.49 71.05,15.35 71.05,16.62 71.56,17.13 74.1,17.13 78.41,21.44 78.41,23.69 77.63,24.47 77.05,24.47 76.41,25.11 76.41,25.61 75.49,26.53 72.58,26.53 v1(72.45,26.4) ; v2(95,47.52) 94.67,47.19 U30.AP12 ; CN5.254 51.47,30.96 52.24,30.19 54.95,30.19 55.56,29.58 55.56,28.18 56.58,27.16 59.88,27.16 60.69,26.35 60.69,22.58 61.56,21.72 61.56,20.79 63.33,19.02 63.33,16.77 62.04,15.47 v1(62.04,14.46)
SMU_ZVDDP: length 13.2
  BOTTOM w0.102: R570.1 107.63,61.71 107.63,60.56 v1(107.38,60.31) 106.82,59.75 104.68,59.75 104.12,60.31 103.78,60.31 102.68,61.42 101.78,61.42 101.53,61.16 101.28,61.16 101.02,61.42 101.02,61.52 100.26,62.28 100.26,63.73 100.52,63.99 U30.P3
SPI_CS#_A: length 23.5
  TOP w0.102: R254.2 179.89,32.96 v1(179.84,33.01)
  IN1 w0.102: v1(179.84,33.01) 179.84,32.57 178.32,31.05 175.2,31.05 174.59,31.66 165.82,31.66 v1(164.48,33.01)
  BOTTOM w0.102: R676.2 166.07,34.73 164.86,34.73 TP74.1 164.26,34.14 R675.2 164.26,33.22 v1(164.48,33.01) 164.48,32.29 164.78,31.99 U34.1
SPI_ROM_REQ: length 7.8
  BOTTOM w0.099: U30.BA11 95.01,41.53 95.34,41.2 95.34,40.98 95.18,40.81 95.18,40.38 95.26,40.3
  BOTTOM w0.102: TP72.1 96.33,35.22 96.33,36.66 96.2,36.79 96.2,38.3 95.26,39.24 95.26,40.3
SPI_SCK_A: length 29.1
  TOP w0.102: R251.2 v1(177.61,33.01)
  IN1 w0.102: v1(160.36,35.57) 161.1,35.57 162.27,36.74 162.8,36.74 163.31,36.23 165.49,36.23 166.3,35.42 168.97,35.42 170.24,34.15 172.1,34.15 172.96,33.29 173.98,33.29 174.38,32.88 175.09,32.88 175.58,32.4 176.46,32.4 177.07,33.01 v1(177.61,33.01)
  BOTTOM w0.102: U34.6 159.32,29.45 159.45,29.58 159.45,30.09 160.48,31.13 160.97,31.13 161.35,31.51 161.35,33.9 161.07,34.18 R638.2 161.07,35.12 TP71.1 160.74,35.19 v1(160.36,35.57)
SPI_SDI_A: length 32.4
  TOP w0.102: R253.2 v1(179.13,33.01)
  IN1 w0.102: v1(179.13,33.01) 178.94,33.01 178.03,32.09 177.33,32.09 176.82,31.58 175.24,31.58 174.76,32.07 166.66,32.07 166.23,32.5 166.23,33.46 166.05,33.64 161.86,33.64 161.73,33.77 161.73,35.47 v1(161.66,35.55)
  BOTTOM w0.102: U34.5 159.17,28.18 159.85,28.87 159.85,29.93 160.65,30.72 161.35,30.72 161.86,31.23 161.86,32.75 TP77.1 162.24,33.9 161.99,33.9 161.76,34.12 R639.2 161.76,35.44 v1(161.66,35.55)
SPI_SDO_A: length 26.1
  TOP w0.102: TP82.1 167.45,32.63 v1(167.19,32.88) ; R252.2 v1(178.37,33.01)
  IN1 w0.102: v1(178.37,33.01) 177.86,32.5 177.15,32.5 176.64,31.99 175.41,31.99 174.92,32.47 170.9,32.47 170.62,32.75 170.62,33.51 170.5,33.64 169.48,33.64 169.35,33.77 169.35,34.4 168.84,34.91 167.55,34.91 167.19,34.56 v1(167.19,32.88)
  BOTTOM w0.102: R669.2 165.13,27.32 164.53,27.93 164.3,27.93 163.83,28.4 163.83,28.86 164.53,29.56 164.53,30.06 165.19,30.72 U34.2 166.56,30.72 167.19,31.36 v1(167.19,32.88)
SPI_TPM_CS#: length 42.7
  TOP w0.102: v1(118.9,24.59) 120.13,23.35 R316.1 R321.1
  IN3 w0.089: v1(112.18,27.29) 111.11,26.22 111.11,25.46 112.56,24.01 118.32,24.01 v1(118.9,24.59)
  BOTTOM w0.089: 97.6,39.53 97.6,40.6 U30.BD8
  BOTTOM w0.102: 97.6,39.53 98.11,39.03 98.36,39.03 99.76,37.62 99.76,37.51 100.65,36.62 R625.1 100.49,36.15 100.26,35.93 100.26,31.41 101.89,29.78 108.47,29.78 109.74,28.51 110.96,28.51 v1(112.18,27.29) ; v1(118.9,24.59) 119.19,24.88 120.56,24.88 121.32,24.12 121.47,24.12 121.85,23.74 Q33.2
SPI_WP_R: length 5
  TOP w0.102: v1(164.4,28.56) 164.02,28.94 163.26,28.94 TP81.1 162.97,29.22 R667.2 R668.2
  BOTTOM w0.102: U34.3 165.29,29.45 v1(164.4,28.56)
SSD_PWREN#: length 5.7
  TOP w0.102: R421.2 17.18,9.86 16.95,9.64 C519.2 16.56,9.21 16.48,9.13 15.43,9.13 15.17,9.38 R422.1 14.64,8.88 14.97,8.55 v1(15.07,8.55) 15.33,8.29 Q27.2
SUSB#: length 103.1
  TOP w0.102: v1(173.54,21.98) 173.47,22.06 173.47,26.1 170.82,28.75 U15.119 ; v1(107,26.02) 107.5,25.51 107.5,23.99 v1(107.33,23.81) 106.74,23.23 103.08,23.23 102.87,23.44 102.67,23.44 102.25,23.86 102.25,24.52 101.62,25.15 U14.4 101.38,25.29 101,25.67 R296.1
  IN1 w0.089: v1(107,26.02) 106.49,26.02 105.85,25.39 105.85,24.62 113.73,16.75 113.73,15.73 v1(114.23,15.23)
  IN3 w0.089: v1(173.54,21.98) 172.65,21.09 172.65,19.93 172.27,19.54 168.08,19.54 167.32,18.78 167.32,18.02 166.23,16.93 152.69,16.93 152.31,17.31 148.96,17.31 148.14,18.12 145.95,18.12 145.63,18.45 143.95,18.45 143.54,18.85 138.87,18.85 136.9,20.81 135.57,20.81 134.57,19.81 128.07,19.81 127.46,20.42 126.93,20.42 125.77,19.26 124.74,19.26 124.43,18.94 123.09,18.94 122.62,18.48 121.38,18.48 120.21,17.31 117.71,17.31 117.03,16.62 113.98,16.62 113.73,16.37 113.73,15.73 v1(114.23,15.23)
SUSC#: length 106.9
  TOP w0.102: v2(94.99,43.64) 95.44,43.19 95.44,42.12 95.57,41.99 95.57,39.55 96.25,38.86 96.25,36.09 97.03,35.32 97.03,34.78 97.75,34.05 97.75,32.62 98.21,32.16 v1(98.21,30.94) 98.21,29.4 98.49,29.12 98.49,26.66 97.85,26.02 97.85,20.82 101.26,17.41 102.4,17.41 v1(103.31,16.5) ; U15.18 166.85,21.36 v1(167.37,21.88)
  IN1 w0.089: v1(111.44,15.23) 104.58,15.23 v1(103.31,16.5)
  IN3 w0.089: v1(111.44,15.23) 111.57,15.23 113.36,17.02 116.87,17.02 117.56,17.72 120.06,17.72 121.23,18.88 122.46,18.88 122.92,19.34 124.27,19.34 124.58,19.65 124.76,19.65 125.49,20.39 126.34,20.39 126.77,20.81 127.62,20.81 128.23,20.2 132.42,20.2 133.54,21.32 136.95,21.32 139.03,19.25 143.7,19.25 144.11,18.84 145.81,18.84 146.12,18.53 148.29,18.53 149.11,17.72 152.92,17.72 153.3,17.33 165.11,17.33 167.37,19.59 v1(167.37,21.88)
  BOTTOM w0.102: v2(94.99,43.64) 95.35,43.99 U30.AV11
SUSCLK_32KHZ: length 2.6
  BOTTOM w0.102: R696.1 192.52,19.32 v1(192.44,19.24) 192.37,19.16 191.83,19.16 191.55,18.88 CN11.50
SUSLED#: length 77.1
  TOP w0.102: v1(166.77,18.41) 166.77,17.6 166.53,17.36 U15.28
  IN2 w0.089: v1(166.77,18.41) 166.3,17.94 166.3,16.24 166.46,16.09 168.44,16.09 169.24,16.89 175.71,16.89 176.06,16.54 180.48,16.54 182.37,18.43 186,18.43 188.3,20.73 190.43,20.73 191.65,19.51 193.41,19.51 197.05,15.86 207.18,15.86 209.41,18.08 210.74,18.08 213.36,20.7 213.36,22.07 212.34,23.08 212.34,24.9 213.98,26.53 215.33,26.53 216.34,27.55 216.34,30.97 216.98,31.61 v1(216.98,31.81)
  BOTTOM w0.102: v1(216.98,31.81) 216.77,32.02 216.77,32.57 214.95,34.4 CN8.18
SUSON: length 205.4
  TOP w0.102: R258.1 170.5,31.38 v1(170.62,31.25) 170.62,30.85 170.42,30.64 U15.120
  IN3 w0.089: v1(68.04,125.54) 68.04,125.43 72.07,121.4 72.71,121.4 74.23,119.87 76.01,119.87 78.1,117.78 78.1,117.27 79.18,116.19 81.98,116.19 82.36,115.81 83.88,115.81 85.28,114.41 85.28,112.13 84.9,111.75 79.18,111.75 77.66,110.22 77.66,108.19 76.54,107.07 76.54,103.85 77.02,103.36 77.02,98.74 77.38,98.39 82.31,98.39 83.39,97.31 92.3,97.31 93.79,98.79 99.12,98.79 101.28,96.63 101.28,95.51 103.29,93.5 105.96,93.5 106.15,93.31 107.3,93.31 110.27,90.33 110.27,82.82 111.19,81.9 111.95,81.9 112.71,81.14 114.87,81.14 116.27,79.74 116.27,79.05 118.2,77.12 118.2,74.26 118.73,73.72 125.26,73.72 126.43,72.55 126.43,67.17 126.08,66.83 126.08,63.83 124.67,62.42 124.67,47.33 126.12,45.89 126.12,44.8 130.38,40.54 130.38,39.72 131.04,39.06 136.77,39.06 138.76,37.07 141.28,37.07 143.6,34.75 143.6,34.11 141.92,32.44 141.92,30.19 144.72,27.39 152.82,27.39 153.39,27.95 157.63,27.95 160.65,30.97 161.86,30.97 162.62,31.74 164.65,31.74 165.8,30.59 169.73,30.59 170.39,31.25 v1(170.62,31.25)
  BOTTOM w0.203: v1(68.04,125.54) 68.04,125.37 67.82,125.15 PR121.1
SVC_APU: length 6.4
  BOTTOM w0.102: R563.1 84.31,77.13 83.37,76.18 83.37,73.61 83.19,73.43 83.19,73.15 83.32,73.02 83.32,72.75 83,72.44 U30.D25
SVD_APU: length 6.3
  BOTTOM w0.102: U30.C25 83.59,72.58 83.59,72.92 83.84,73.16 83.84,75.5 85.53,77.2 85.53,77.61 R565.1
SVI2_CLK: length 50.9
  TOP w0.102: v1(75.93,104.51) v1(76.45,103.99) 78.34,102.09 78.34,98.41 79.61,97.14 85.02,97.14 85.15,97.01 91.5,97.01 91.88,97.4 93.53,97.4 93.91,97.01 94.32,97.01 94.93,97.62 94.93,97.74 R98.1
  IN1 w0.089: v1(75.93,104.51) 75.93,104.52 75.6,104.85 75.6,106.82 74.84,107.58 72.17,107.58 71.66,108.09 71.66,114.44 69.45,116.65 v1(69.45,117.13)
  BOTTOM w0.102: PR127.2 70.81,122.32 PC141.2
  BOTTOM w0.107: PC141.2 69.71,121.76 69.16,121.21 69.16,118.33 69.58,117.91 PR148.2
  BOTTOM w0.203: v1(69.45,117.13) 69.45,115.73 PR163.1
  BOTTOM w0.254: v1(69.45,117.13) 69.45,117.34 69.59,117.48 PR148.2
SVI2_DATA: length 45.1
  TOP w0.102: R97.1 93.69,97.65 91.76,97.65 91.37,97.27 85.25,97.27 85.15,97.37 79.71,97.37 78.57,98.51 78.57,102.83 v1(77.76,103.64) 77.02,104.38 v1(77.02,104.46)
  IN1 w0.089: v1(77.02,104.46) 76.62,104.86 76.62,106.18 75.03,107.77 72.25,107.77 71.86,108.17 71.86,114.52 70.14,116.23 v1(70.14,117.13)
  BOTTOM w0.203: PR136.2 71.32,120.79 70.94,120.41 70.93,120.41 70.54,120.02 PC145.2 PR145.2 70.54,118.87 70.07,118.4 70.07,117.2 v1(70.14,117.13) 70.12,117.11 70.12,116.8 PR155.1
SVI2_EN: length 22.6
  IN2 w0.089: v1(59.42,117.46) 58.48,118.4 58.48,119.87 58.78,120.17 61.68,120.17 62.21,120.7 65.28,120.7 68.13,117.84 68.13,114.79 68.77,114.16 v1(69.58,114.16)
  BOTTOM w0.102: v1(59.42,117.46) 58.49,118.39 R488.2 59.01,118.86 59.05,118.89 U23.4 ; PR168.1 69.43,114.01 v1(69.58,114.16)
SVI2_SVT: length 39.3
  TOP w0.102: R96.1 91.88,98.16 91.22,97.5 85.38,97.5 85.28,97.6 79.8,97.6 78.8,98.6 78.8,102.93 v1(78.98,103.11) v1(77.66,104.43)
  IN1 w0.089: v1(77.66,104.43) 77.38,104.71 77.38,104.74 76.81,105.31 76.81,106.63 75.25,108.19 75.25,113.36 72.29,116.31 71.49,116.31 71.16,116.65 v1(70.7,116.65)
  BOTTOM w0.203: PR159.1 70.64,116.59 v1(70.7,116.65) 70.7,116.7 70.62,116.78 70.62,117.38 70.42,117.58 PC150.2
SVT_APU: length 5.2
  BOTTOM w0.102: R564.1 85.05,77.38 83.59,75.92 83.59,73.38 U30.A25
SYS_HWPG: length 200.4
  TOP w0.102: v1(156.12,13.45) 156.29,13.61 D21.1 156.93,12.08 155.74,10.88 145.73,10.88 144.99,11.62 144.99,13.79 145.5,14.3 145.5,21.32 145.17,21.65 145.17,26.07 142.94,28.31 142.94,30.72 142,31.66 142,32.8 PR72.1 142.46,32.98 142.68,32.75 143.06,32.75 143.29,32.98 143.29,34.07 144.16,34.94 144.16,37.43 144.36,37.63 145.22,37.63 147.53,39.94 147.53,41.24 149.39,43.09 149.92,43.09 v1(150.61,43.78) ; v1(168.34,34.4) 168.97,33.77 168.97,32.01 169.05,31.94 169.05,30.8 168.82,30.57 U15.124
  IN1 w0.089: v1(156.12,13.45) 155.23,12.56 147.92,12.56 147.14,13.33 113.84,13.33 112.96,14.21 93.2,14.21 91.8,12.81 91.8,11.71 88.79,8.7 83.53,8.7 78.78,13.45 75.14,13.45 75.12,13.47 v1(75.12,13.5)
  IN2 w0.089: v1(47.33,13.35) 49.06,13.35 49.31,13.09 59.57,13.09 59.8,12.86 60.62,12.86 60.84,13.09 74.76,13.09 75.12,13.45 v1(75.12,13.5)
  IN3 w0.089: v1(168.34,34.4) 165.97,34.4 165.72,34.66 165.09,34.66 164.84,34.42 157,34.42 153.78,37.63 151.83,37.63 150.89,38.57 150.89,43.5 v1(150.61,43.78)
  BOTTOM w0.152: v1(47.33,13.35) 47.66,13.67 PR351.1
SYS_PWRGD: length 71.1
  TOP w0.102: v1(151.87,22.72) 152.22,22.37 C426.2 152.59,21.83 152.74,21.67 R330.2 153.76,21.67 v1(153.99,21.45)
  IN1 w0.089: v1(123.76,37.83) 123.25,37.83 122.74,37.32 122.74,34.02 125.31,31.46 125.31,29.87 126.34,28.84 128.81,28.84 129.09,28.56 129.74,28.56 131.9,26.4 133.63,26.4 134.8,25.23 135.53,25.23 138.78,21.98 145.8,21.98 146.13,22.31 151.46,22.31 v1(151.87,22.72)
  IN2 w0.089: v1(123.76,37.83) 122.74,37.83 121.85,38.72 118.55,38.72 117.91,39.36 115.89,39.36 114.25,41.01 111.31,41.01 110.93,41.39 110.93,43.09 111.06,43.22 111.06,43.66 110.47,44.25 108.34,44.25 107.14,43.04 106.11,43.04 105.22,42.15 104.71,42.15 v2(102.93,43.93)
  BOTTOM w0.102: U30.AW2 101.45,43.54 102.54,43.54 v2(102.93,43.93)
SYS_PWRGD_R: length 8.2
  TOP w0.102: Q19.6 151.56,20.45 151.94,20.06 C446.1 R347.2 R330.1 153.58,21.22 154.04,20.76 v1(154.04,20.1) 154.3,19.84 D12.2 D13.2
SYS_RST#: length 78.7
  TOP w0.102: v1(155.05,22.72) 155,22.67 D12.1 ; v1(119.95,45.71) 119.31,45.71 118.93,45.33 116.94,45.33 116.35,44.74 115.91,44.74 115.45,45.2 113.47,45.2 113.09,44.82 112.05,44.82 v1(111.75,45.12)
  IN1 w0.089: v1(119.95,45.71) 119.31,45.07 119.31,41.39 120.97,39.74 120.97,31.04 122.01,30 124.62,30 126.17,28.45 128.65,28.45 128.93,28.17 129.58,28.17 131.73,26.01 133.47,26.01 134.64,24.84 135.37,24.84 138.62,21.59 145.96,21.59 146.29,21.92 154.25,21.92 v1(155.05,22.72)
  BOTTOM w0.102: v1(111.75,45.12) 111.75,44.45 C611.2 111.32,44.44 111.23,44.53 R593.1 R592.1 110.04,45.33 109.89,45.48 108.82,45.48 108.75,45.4 106.94,45.4 102.68,49.66 101.68,49.66 101.4,49.94 U30.AL2
SYS_SHDN#: length 229.6
  TOP w0.102: Q14.3 112.15,43.49 112.22,43.42 114.29,43.42 115.64,42.07 115.64,41.81 115.4,41.57 115.4,39.64 114.9,39.13 114.57,39.13 114.4,38.95 v1(114.31,38.95) ; PR111.1 47.91,18.42 v1(48.96,19.46) 48.96,20.76 50.46,22.26 50.46,24.85 v1(51.37,25.77) ; U15.85 180.33,23.76 180.15,23.94 178.9,23.94 178.67,24.17 178.67,25.08 178.12,25.64 178.12,26.71 181.67,30.27 v1(181.67,30.49)
  TOP w0.203: v1(144.59,37.2) 144.44,37.05 144.44,35.22 PR66.1 144.91,34.34 144.97,34.28 PR71.1
  IN1 w0.089: v1(94.61,36.88) 94.98,36.51 94.98,34.45 94.69,34.16 94.69,32 94.42,31.74 94.42,27.9 93.82,27.29 93.28,27.29 92.98,27.6 84.73,27.6 84.2,27.06 81.88,27.06 80.61,25.79 76.57,25.79 76.47,25.89 70.8,25.89 69.4,27.29 56.58,27.29 55.18,25.89 51.5,25.89 v1(51.37,25.77) 50.96,26.17 50.49,26.17 48.77,27.89 40.54,27.89 38.54,25.89 33.15,25.89 29.65,29.39 28.93,29.39 27.13,31.19 27.13,33.07 25.31,34.89 25.31,39.13 24.95,39.48 23.05,39.48 v1(22.79,39.23)
  IN2 w0.089: v1(181.67,30.49) 181.18,30 180.61,30 180.27,30.34 172.48,30.34 170.33,32.49 170.33,33.13 168.6,34.86 166.36,34.86 166.18,35.04 164.95,35.04 164.25,34.33 160.12,34.33 159.96,34.49 159.03,34.49 158.75,34.21 157.91,34.21 157.18,34.94 155.45,34.94 152.8,37.6 150.92,37.6 150.62,37.9 149.09,37.9 148.15,38.84 146.61,38.84 145.73,37.96 145.35,37.96 v1(144.59,37.2) 143.95,37.83 138.62,37.83 137.86,37.07 133.03,37.07 131.15,35.19 122.72,35.19 120.84,37.07 115,37.07 114.31,37.76 v1(114.31,38.95) 113.83,38.47 112.96,38.47 112.84,38.59 111.31,38.59 110.42,37.71 108.32,37.71 108.19,37.58 106.87,37.58 106.36,38.09 103.03,38.09 100.87,40.25 99.5,40.25 96.14,36.88 v1(94.61,36.88)
  BOTTOM w0.102: v1(22.79,39.23) 22.01,38.44 R605.1 ; PR310.2 114.44,38.82 v1(114.31,38.95)
TEMP_FAIL: length 15.4
  IN3 w0.102: v1(114.62,124.07) 115.38,123.3 115.38,123.05 115.89,122.54 115.89,114.29 115.38,113.78 115.38,113.08 v1(115.83,112.63)
  BOTTOM w0.102: v1(115.83,112.63) 115.6,112.63 U25.R38 ; R444.2 115.48,123.2 v1(114.62,124.07)
TEMP_MBAT#: length 99.2
  TOP w0.102: U15.73 180.48,18.96 180.35,19.09 178.04,19.09 177.86,19.26 177.86,20.27 v1(177.71,20.43) ; v1(135.7,27.29) 135.57,27.16 v1(135.57,20.05) ; PR108.2 101.53,18.66 101.79,18.4 PR110.1 102.2,18.81 102.3,18.91 104.2,18.91 104.58,18.53 104.58,17.26 v1(104.96,16.88)
  IN1 w0.089: v1(135.95,29.09) 135.95,27.55 v1(135.7,27.29)
  IN2 w0.089: v1(177.71,20.43) 176.98,20.43 176.46,20.94 173.16,20.94 171.74,22.36 166.41,22.36 166.18,22.59 163.22,22.59 162.06,21.44 157.95,21.44 155.86,23.53 146.23,23.53 144.84,22.15 142.49,22.15 140.72,20.38 136.03,20.38 135.7,20.05 v1(135.57,20.05) 135.44,20.18 134.21,20.18 132.96,18.93 122.9,18.93 122.29,18.32 115.58,18.32 114.59,19.32 112.23,19.32 110.02,17.11 105.19,17.11 v1(104.96,16.88)
  BOTTOM w0.198: PR337.1 136.28,28.76 v1(135.95,29.09)
TEST_PG: length 8.5
  BOTTOM w0.102: R524.2 R523.2 C565.2 95.79,98.43 v1(96.38,99.02) 96.66,99.3 100.29,99.3 100.58,99.01 100.86,99.01 101.17,99.32 U25.AY13
TEST_PG_BACO: length 9.5
  BOTTOM w0.102: v1(94.68,95.62) 94.73,95.67 94.73,96.53 94.65,96.61 R522.2 C564.2 94.65,98.38 95.06,98.79 95.31,98.79 96.08,99.56 100.46,99.56 U25.BA13
THERMDA_1: length 171.6
  IN3 w0.089: v1(18.41,37.58) 18.41,38.21 19.17,38.98 19.17,40.43 20.38,41.64 20.38,45.91 17.21,49.08 17.21,52.69 17.89,53.38 17.89,56.32 24.19,62.62 24.19,74.15 23.05,75.3 23.05,80 23.94,80.89 23.94,90.54 26.24,92.84 26.24,96.23 v1(25.46,97.01)
  BOTTOM w0.102: Q30.3 102.8,83.04 101.85,82.09 Q30.2 100.71,82.09 99.11,83.69 C572.1 98.49,84.44 96.53,86.4 90.53,86.4 90.02,86.9 84.44,86.9 83.37,85.84 82.21,85.84 80.43,87.62 77.15,87.62 76.9,87.36 75.88,87.36 73.85,85.33 73.85,81.39 73.34,80.89 64.07,80.89 59.75,85.2 59.75,87.49 60.26,88 60.26,88.76 59.52,89.5 59.52,96.35 59.04,96.84 57.77,96.84 57.54,97.06 57.54,97.45 57.36,97.62 55.71,97.62 54.88,98.46 52.12,98.46 50.39,96.73 47.55,96.73 45.72,98.56 39.46,98.56 37.25,96.35 26.12,96.35 v1(25.46,97.01) ; U32.2 v1(18.41,37.58)
THERMDC_1: length 167.9
  IN3 w0.089: v1(18.86,38.09) 19.49,38.72 19.49,40.37 20.65,41.53 20.65,45.94 17.4,49.2 17.4,52.61 18.08,53.3 18.08,56.24 24.46,62.62 24.46,74.28 23.3,75.44 23.3,79.87 24.21,80.77 24.21,90.43 26.51,92.73 26.51,96.6 v1(26.1,97.01)
  BOTTOM w0.102: U32.3 19.06,37.89 v1(18.86,38.09) ; v1(26.1,97.01) 26.53,96.58 28.23,96.58 29.02,97.37 37.94,97.37 39.36,98.79 42.68,98.79 43.46,99.58 43.78,99.58 44.57,98.79 45.81,98.79 47.64,96.96 50.26,96.96 51.99,98.69 54.97,98.69 55.81,97.85 58.38,97.85 59.78,96.46 59.78,89.6 60.51,88.86 60.51,87.89 60.01,87.38 60.01,85.31 64.18,81.14 73.24,81.14 73.59,81.5 73.59,85.44 75.78,87.62 76.77,87.62 77.02,87.87 80.5,87.87 82.28,86.09 83.25,86.09 84.29,87.13 90.14,87.13 90.65,86.63 v1(98.21,86.63) 99.89,84.94 C572.2 100.26,84.44 100.71,83.99 Q30.1
TP_INTH#_L: length 8.5
  BOTTOM w0.102: v1(66.52,26.21) Q32.1 68.13,25.59 68.13,24.5 69.67,22.96 R681.1 ; R681.1 70.54,22.96 70.7,23.13 R682.1 ; R681.1 70.29,22.55 70.32,22.52 CN12.7
TP_SMB_CLK: length 6.2
  TOP w0.102: v1(71.18,20.15) 71.32,20.29 C433.1 71.64,20.49 71.64,19.75 71.53,19.64 R348.1 71.53,19.57 71.87,19.23 71.87,17.62 71.6,17.34 Q20.3
  BOTTOM w0.102: v1(71.18,20.15) 71.32,20.29 CN12.6
TP_SMB_DATA: length 4.7
  TOP w0.102: v1(72.45,20.15) 72.44,20.15 C434.1 72.01,20.38 72.01,19.86 72.23,19.64 R349.1 72.23,18.77 72.35,18.64 Q20.6
  BOTTOM w0.102: v1(72.45,20.15) 72.32,20.27 CN12.5
TPCLK: length 116
  TOP w0.102: U15.89 180.3,25.36 180.28,25.38 179.65,25.38 179.21,25.82 179.21,25.82 v1(178.8,26.22)
  IN2 w0.089: v1(178.8,26.22) 177.79,26.22 177.07,25.51 172.81,25.51 171.84,24.55 169.93,24.55 169.47,25.01 165.55,25.01 164.86,24.32 157.12,24.32 156.13,25.31 146.05,25.31 144.4,23.66 141.84,23.66 141.02,22.83 133.53,22.83 133.23,22.54 132.37,22.54 131.43,21.6 127.67,21.6 127.53,21.74 123.93,21.74 123.35,21.17 111.75,21.17 108.93,18.35 104.63,18.35 103.57,19.42 98.3,19.42 97.44,20.28 93.58,20.28 90.97,22.9 78.61,22.9 77.77,22.06 76.41,22.06 v1(76.01,22.47)
  BOTTOM w0.102: R671.2 75.12,25.22 75.5,24.84 L12.1 75.74,24.38 76.08,24.04 76.08,22.67 76.01,22.59 v1(76.01,22.47)
TPCLK-1: length 3.8
  BOTTOM w0.102: L12.2 75.26,23.6 74.63,22.96 C662.1 74.46,22.74 74.59,22.62 v1(75.3,22.62) 75.32,22.59 CN12.2
TPD_EN: length 137.4
  TOP w0.102: R256.2 183.7,32.24 184.01,32.55 v1(184.77,32.55) 184.9,32.55 185.48,31.96 185.48,30.16 185.69,29.96 v1(186.12,29.96)
  IN2 w0.089: v1(186.12,29.96) 185.74,29.58 182.94,29.58 182.56,29.2 181.93,29.2 181.62,28.89 181.62,28.38 181.44,28.2 175.71,28.2 174.82,27.32 171.74,27.32 170.9,28.16 170.9,28.48 170.52,28.85 169.3,28.85 169.12,29.03 165.5,29.03 164.51,28.04 157.14,28.04 156.5,28.69 154.07,28.69 152.89,27.51 144.11,27.51 143.61,28.01 142.87,28.01 142.4,27.55 142.4,26.93 141.68,26.21 140.42,26.21 139.21,24.99 131.14,24.99 130.81,24.66 124.42,24.66 122.82,23.06 119.73,23.06 119.31,23.48 115.48,23.48 114.72,22.72 108.88,22.72 107.66,21.5 105.29,21.5 105.14,21.65 99.3,21.65 99.12,21.83 94.84,21.83 92.31,24.36 75.92,24.36 75.26,23.7 70.9,23.7 70.15,22.95 67.64,22.95 67.19,23.4 66.81,23.4 66.38,22.97 v1(65.47,22.97)
  BOTTOM w0.102: v1(65.47,22.97) 65.59,22.85 65.59,22.47 65.86,22.2 R686.1 66.73,22.2 66.74,22.21 R687.1
TPD_INT#: length 50.8
  TOP w0.102: v2(100.08,44.5) 100.52,44.06 100.52,42.02 102.55,39.99 R226.1
  IN2 w0.089: v1(92.64,29.7) 93.05,29.3 93.05,28.84 91.96,27.75 84.72,27.75 83.93,26.96 71.74,26.96 v1(71.18,26.4)
  IN3 w0.089: v1(92.64,29.7) 92.9,29.7 93.41,30.21 94.02,30.21 96.3,32.5 96.71,32.5 97.24,33.03 97.24,39.51 99.5,41.77 99.5,43.8 100.08,44.38 v2(100.08,44.5)
  BOTTOM w0.102: U30.AU4 100.14,44.49 100.13,44.5 v2(100.08,44.5) ; R677.2 71.18,24.75 71.31,24.88 71.31,26.28 v1(71.18,26.4)
TPD_INT#_EC: length 110.8
  TOP w0.102: R246.1 R269.2 164.3,31.28 v1(164.7,30.87)
  IN2 w0.089: v1(164.7,30.87) 164.7,30.36 163.96,29.62 160.3,29.62 159.9,30.01 156.65,30.01 156.09,29.45 153.75,29.45 152.61,28.31 146.17,28.31 145.19,29.28 140.5,29.28 137.33,26.12 130.68,26.12 130.38,25.82 123.54,25.82 122.22,24.5 121.22,24.5 120.74,24.98 119.98,24.98 119.37,25.59 115.45,25.59 113.75,23.89 101.26,23.89 99.8,25.35 96.41,25.35 94.65,27.11 86.75,27.11 85.99,26.35 73.54,26.35 72.71,25.51 69.02,25.51 v1(68.64,25.13)
  BOTTOM w0.102: v1(68.64,25.13) 68.64,27.27 v1(68.72,27.34) 69.61,27.34 71.03,25.92 R670.2
