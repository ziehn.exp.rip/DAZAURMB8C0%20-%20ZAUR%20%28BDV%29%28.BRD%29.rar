# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1V8_TPM_VSB:
  vias: v1(130.26,18.68)
+1V8TPM: length 24.2
  TOP w0.203: R316.2 121.45,23.76 121.3,23.91 v1(120.2,23.91) ; C440.1 v1(121.45,19.7) R350.2 ; U16.22 122.45,20.6
  TOP w0.381: v1(120.2,23.91) 119.57,24.54 119.57,25.64 120.03,26.1 123.18,26.1 123.63,25.64 125.28,25.64 125.54,25.39 131.25,25.39 131.46,25.18 131.46,23.79
  BOTTOM w0.381: v1(121.45,19.7) 121.45,20.59 120.84,21.2 120.84,22.47 120.2,23.1 v1(120.2,23.91)
  vias: v1(131.68,22.87)
+1V_S5_ON: length 3.6
  TOP w0.102: TP28.1 182.56,28.05 182.27,27.76 U15.95
+2.5V_SUS: length 172.4
  TOP w0.254: 34.29,79.87 U5.R9 ; 34.21,68.41 U6.R9 ; 34.21,44.81 U9.R9
  TOP w0.356: U9.B1 45.91,52.51 45.91,53.71 46.93,54.73 C279.2 47.31,55.23 47.69,54.85 47.69,53.45 ; 34.72,33.71 34.93,33.92 U12.R9 ; 47.29,89.71 46.35,89.71 45.45,88.81 45.45,87.03 U5.B1 ; 47.43,41.77 45.91,41.77 45.65,41.52 45.65,40.88 45.33,40.55 U12.B1
  TOP w0.381: U6.B1 46.27,76.47 46.77,76.47 46.92,76.62 C198.2
  TOP w0.508: v1(29.27,78.73) 29.28,78.73 C191.2 32.09,78.73 33.23,79.87 34.29,79.87 ; 33.7,30.28 33.18,30.79 C381.2 32.81,31.8 34.72,33.71 ; v1(29.65,66.8) 29.9,66.8 30.41,67.31 C225.2 32.56,68.27 32.7,68.41 34.21,68.41 ; 34.21,44.81 34.05,44.65 C329.2 30.41,44.24 29.49,43.31 v1(28.81,43.31) ; C198.2 46.92,78.15
  TOP w1.016: 46.92,78.15 46.97,78.2 46.97,81.86 47.69,82.57 47.69,89.26 ; 48.45,90.41 48.45,92.92 46.39,94.98 27.14,94.98 25.59,93.43 25.59,86.35 ; 47.69,53.45 47.69,45.39 47.49,45.2 ; 46.46,29.88 46.46,32.32 47.94,33.8 47.94,36.8 47.57,37.17 47.57,41.63 47.43,41.77
  BOTTOM w0.381: v1(28.81,43.31) 27.6,43.31
  BOTTOM w0.508: v1(29.27,78.73) 27.91,78.73 ; v1(29.65,66.8) 27.87,66.8
  BOTTOM w1.016: 33.34,30.97 31.43,30.97 29.27,33.13 29.27,36.44 27.6,38.1 27.6,57.64 27.86,57.89 27.86,65.46 27.86,66.79 27.91,66.84 27.91,79.74 27.86,79.79 27.86,83.82 26.86,84.82 25.97,84.82
  vias: v1(25.59,85.2) v1(25.59,84.57) v1(33.57,29.51) v1(34.34,29.51) v1(48.4,28.54) v1(51.12,29.83) v1(56.96,28.82) v1(57.59,28.82)
+3V: length 432.2
  TOP w0.102: v1(144.76,44.74) 144.97,44.95 144.97,46.21 144.61,46.57 139.97,46.57 137.6,48.93 PR57.1
  TOP w0.178: v1(43.75,25.39) 43.75,25.89 43.5,26.15 PR96.1 ; v1(96.48,83.53) 96.48,84 96.43,84.05 R128.1 ; v1(15.57,21.31) 15.29,21.31 15.05,21.07 R336.1
  TOP w0.203: v1(129.22,120.38) 129.22,119.37 129,119.14 R43.1 ; Q6.2 19.11,88.89 19.27,89.04 R116.1 v1(19.27,89.85) ; Q6.5 19.11,84.82 18.96,84.67 R129.1 20,84.44 v1(20.51,84.95) ; v2(91.91,33.9) 92.01,33.9 92.49,33.42 R241.2 R242.1 ; Q7.2 92.39,82.92 92.14,83.17 91.37,83.17 91.09,82.89 R135.2 90.49,82.89 v1(90.21,83.17) 90.49,83.45 R131.2 ; R78.2 49.41,104.58 v1(49.08,104.25) ; 71.82,29.32 R286.1 R287.1 ; R73.1 56.88,107 56.43,107.45 R68.1 56.43,108.17 56.45,108.19 v1(56.45,108.2) ; R315.2 197.32,23.86 196.61,24.57 v1(196.61,24.67) ; R137.1 103.21,82.51 v1(103.44,82.28) 103.44,82.66 103.03,83.07 R133.1 ; R232.2 105.72,37.82 105.06,37.17 R236.2 ; R230.2 100.11,37.86 v1(100.26,37.71) ; R170.2 106.66,75.78 106.22,76.21 104.64,76.21 102.3,78.56 102.3,79.35 102.56,79.62 ; R300.2 88.96,27.74 88.96,26.58 88.71,26.33 ; PR75.1 v1(195.26,32.35) ; 106.49,79.62 106.49,77.84 107,77.33 R164.1 ; v1(168.34,31.23) R263.2
  TOP w0.254: v1(116.09,46.82) 116.48,46.82 116.72,47.07 116.75,47.07 R202.1 ; v1(53.27,103.34) 53.55,103.34 53.83,103.62 53.83,104.22 53.47,104.59 R76.2 ; v1(92.64,84.95) 92.64,84.7 92.39,84.44 Q7.5
  TOP w0.305: R385.1 159.49,15.95 155.14,15.95 154.72,16.37 v1(154.72,16.5) ; v1(172.65,28.48) 172.65,27.63 174.05,26.23 174.05,23.1 175.35,21.8 v1(175.73,21.8) ; R672.2 86.13,24.97 86.14,24.98
  TOP w0.381: v1(59.5,102.73) 59.24,102.73 58.99,102.98 58.99,103.11 58.24,103.86 R80.2 ; 106.11,40.88 106.74,41.52 106.74,42.53 105.85,43.42 v1(104.84,43.42) ; R367.2 128.15,17.51 128.02,17.39 127.44,17.39 127.33,17.27 R375.2 125.77,17.27 125.53,17.51 123.76,17.51 123.25,18.02 v1(123.25,18.53) ; v1(62.16,22.59) 62.04,22.47 62.04,21.2 61.52,20.68 R340.1 ; 105.98,39.61 106.49,39.1 106.49,38.21 106.1,37.82 R232.2 ; v1(103.44,79.62) 102.56,79.62 101.17,81.01 R142.1 ; v1(103.44,79.62) v1(107.63,79.62) ; v1(103.44,79.62) 103.44,81.14 v1(103.21,81.37) ; v1(153.43,18.66) 153.22,18.86 R347.1 154.27,19.28 154.65,18.91 156.91,18.91 157.16,19.16 157.16,22.72 156.58,23.3 150.56,23.3 150.25,23.61 147.13,23.61 146.54,24.19 146.54,26.2 146.75,26.4 146.75,28.56 ; R329.1 198.49,21.26 v1(198.49,20.86) 198.49,20.51 198.87,20.13 R344.1 ; v1(22.92,5.21) 23.66,5.21 25.6,3.26 25.6,2.88 26.08,2.4 28.64,2.4 29.89,3.65 Q28.2
  TOP w0.508: v1(82.74,28.43) 81.47,28.43 80.58,27.55 80.45,27.55 ; 80.45,27.55 74.99,27.55 73.21,29.32 61.53,29.32 v1(60.39,28.18) ; 80.45,27.55 83.02,24.98 88.05,24.98 88.2,25.13 ; v1(109.41,36.99) 106.44,36.99 105.85,37.58 R232.2
  IN1 w0.381: v1(56.45,108.2) 56.02,108.63 55.93,108.63 55.23,109.33 54.16,109.33 53.4,110.1 53.4,110.48 53.02,110.86 51.5,110.86 50.73,111.62 50.73,113.9 49.92,114.72 48.4,114.72 45.07,118.05 v1(41.06,118.05)
  IN1 w0.508: v1(62.16,22.59) 60.39,22.59 59.75,21.96 57.08,21.96 55.54,23.51 51.75,23.51 50.96,22.72 50.68,22.72 48.02,25.39 v1(43.75,25.39)
  IN2 w0.254: v1(116.09,46.82) 115.45,46.82 112.81,44.18 111.28,44.18 110.19,45.27 108.47,45.27 106.87,43.67 105.09,43.67 v1(104.84,43.42)
  IN2 w0.305: v1(109.32,122.81) 109.32,123.82 111.47,125.97 120.71,125.97 122.11,124.57 122.11,124.07 123.63,122.54 124.14,122.54 124.42,122.26 124.42,121.55 124.95,121.02 128.84,121.02 129.22,120.64 v1(129.22,120.38)
  IN2 w0.381: v1(15.57,21.31) 15.57,21.05 15.94,20.69 16.7,20.69 17.59,19.8 17.59,18.66 18.98,17.26 19.87,17.26 20.57,16.56 20.57,15.67 22.41,13.83 23.68,13.83 24.34,13.17 v1(24.34,12.94) ; v1(49.08,104.25) 49.21,104.25 49.59,104.63 50.48,104.63 50.61,104.76 53.43,104.76 53.91,104.28 53.91,103.75 53.5,103.34 v1(53.27,103.34) ; v1(82.99,78.85) 85.02,78.85 86.55,80.38 86.55,81.39 88.58,83.43 v1(88.96,83.43) ; v2(94.47,35.11) 95.13,35.11 96.79,33.46 v2(96.79,33.44) ; v1(154.72,16.5) 154.72,16.9 153.43,18.2 v1(153.43,18.66) 152.84,19.24 152.79,19.24 152.06,19.97 146.58,19.97 145.86,20.69 142.43,20.69 141.39,19.65 136.94,19.65 v1(136.51,19.21)
  IN2 w0.508: v2(96.79,33.44) 97.39,33.44 98.99,35.04 98.99,36.44 v1(100.26,37.71) 100.26,37.32 100.52,37.07 102.93,37.07 103.19,37.32 104.96,37.32 105.47,36.82 108.65,36.82 108.82,36.99 v1(109.41,36.99) ; v2(91.91,33.9) 91.63,33.9 89.47,31.74 83.37,31.74 82.74,31.1 v1(82.74,28.43)
  IN3 w0.305: v1(89.22,123.68) 89.98,122.92 93.15,122.92 93.79,122.29 93.79,121.4 95.69,119.49 99.25,119.49 101.15,121.4 101.62,121.4 101.75,121.27 105.39,121.27 106.02,120.63 106.44,120.63 108.62,122.81 v1(109.32,122.81)
  IN3 w0.381: v2(91.91,33.9) 92.14,33.9 93.36,35.11 v2(94.47,35.11)
  IN3 w0.508: 27.87,25.51 37.78,25.51 37.91,25.39 v1(43.75,25.39)
  BOTTOM w0.152: PR296.1 145.72,45.35 145.38,45 145.02,45 v1(144.76,44.74)
  BOTTOM w0.178: R562.2 83.55,78.42 83.12,78.85 v1(82.99,78.85) ; v2(91.91,33.9) 91.58,34.23 91.58,34.23 91.46,34.35 91.46,35.31 91.85,35.7 R615.2
  BOTTOM w0.203: v2(96.79,33.44) 96.56,33.66 96.56,34.02 R641.2 ; v2(94.47,35.11) 94.17,35.42 R618.2 ; R643.2 91.37,33.63 91.63,33.9 v2(91.91,33.9) ; v1(63.24,123.62) 64.92,123.62 66,122.54 PR133.1 ; v1(49.08,104.25) 49.08,103.84 C559.2 ; R661.2 87.06,26.96 87.28,26.74 R673.2 ; v1(88.96,83.43) 89.09,83.3 R541.2 ; R690.1 R689.2 v1(175.73,21.8) ; v1(18.22,38.85) 17.81,38.44 C623.1 17.81,37.04 17.76,36.98 U32.1
  BOTTOM w0.254: v1(88.68,24.88) 88.68,24.32 88.5,24.14 87.51,24.14 87.28,24.38 R673.2 ; CN5.255 59.99,30.71
  BOTTOM w0.381: v1(107.63,79.62) 107.88,79.62 108.52,78.98 108.52,77 109.15,76.36 109.15,75.81 109.54,75.42 PC199.2 PR237.1 111.42,75.05 PR238.1 ; R510.2 53.77,103.48 53.63,103.34 v1(53.27,103.34) ; v1(103.44,79.62) 103.99,79.06 PQ27.1 ; v1(66.86,95.49) 66.73,95.35 R525.1 ; v1(123.25,18.53) 123.27,18.51 127.17,18.51 127.29,18.63 136.18,18.63 136.51,18.96 v1(136.51,19.21)
  BOTTOM w0.508: R493.1 40.42,118.22 40.6,118.05 v1(41.06,118.05) ; v1(62.16,22.59) 61.91,22.85 61.91,26.66 v1(60.39,28.18) 60.39,30.31 59.99,30.71
  vias: v1(11.47,9.49) v1(11.7,10.15) v1(12.25,9.84) v1(12.25,9.21) v1(12.89,9.84) v1(12.89,9.21) v1(23.43,88.25) v1(23.43,87.62) v1(25.21,32.37) v1(25.21,31.74) v1(25.21,31.1) v1(25.21,30.47) v1(48.96,96) v1(48.96,95.11) v1(60.13,102.73) v1(62.72,94.83) v1(64.78,93.05) v1(65.24,92.57) v1(148.78,29.75) v1(148.78,29.12) v1(149.41,29.75) v1(149.41,29.12) v1(150.05,29.75) v1(150.05,29.12) v1(150.68,29.75) v1(150.68,29.12) v1(160.59,27.19) v1(161.22,27.19) v3(188.28,30.09) v3(188.28,29.32)
+3V_CCD_PWR1_C: length 47.7
  TOP w0.102: v1(82.92,124.25) 82.9,124.23 Q43.1
  IN1 w0.089: v1(82.92,124.25) 82.87,124.29 78.2,124.29 75.79,126.71 61.45,126.71 60.84,126.1 60.84,123.38 62.32,121.91 62.32,120.46 61.28,119.42 61.28,116.47 61.59,116.16 v1(62.13,116.16)
  BOTTOM w0.254: CN2.33 59.72,107.65 59.98,107.91 61.78,107.91 62.14,108.27 62.14,108.67 61.61,109.21 61.61,115.63 v1(62.13,116.16)
  vias: v1(59.52,105.95)
+3V_DMIC: length 4.2
  BOTTOM w0.508: CN1.4 37.69,116.1 v1(38.97,117.38) 39.3,117.71 R493.2
+3V_EC: length 1.1
  TOP w0.203: 164.49,24.16 U15.11
  vias: v1(160.59,25.89)
+3V_GFX: length 175.4
  TOP w0.203: v1(107.1,122.41) 107.41,122.72 R16.1 ; R26.1 120.84,122.39 v1(120.84,122.8) ; R39.1 122.95,120.26 v1(122.92,120.23) 122.74,120.05 R41.1 ; v1(109.03,125.46) 108.9,125.34 107.73,125.34 107.41,125.01 R5.1 ; C130.1 91.1,95.85 91.1,96.22 91.28,96.41 U3.5 ; R19.1 128.71,122.67 128.23,123.15 R14.2 128.1,123.43 v1(127.72,123.05) ; v1(105.49,109.73) 105.2,109.73 104.84,110.1 C38.1 ; v1(122.62,124.32) 122.49,124.19 R12.1 ; v1(125.16,122.13) 125.44,121.85 R31.1 ; R11.1 v1(121.6,124.27) ; R9.1 v1(118.65,124.37) R2.1
  TOP w0.508: C130.1 90.47,95.75 v1(90.36,95.64) ; v1(117.66,123.81) C1.1 117.22,124.51 117.03,124.7 U1.8 ; v1(111.8,122.21) 111.8,122.19 111.77,122.16 U1.3 ; U1.7 115.25,123.43 115.12,123.3 v1(114.49,123.3)
  IN1 w0.508: v1(90.36,95.64) 87.79,95.64 86.55,96.89 83.5,96.89 82.21,98.18 79.46,98.18 77.91,99.73 77.91,101.71 78.67,102.48 78.67,104.89 78.17,105.4 v1(77.66,105.4) 77.66,106.77 79.03,108.14 79.03,110.04 80.2,111.21 82.46,111.21 82.69,111.44 84.8,111.44 85.41,112.05 85.41,113.88 84.34,114.95 v1(83.73,114.95) ; v1(148.07,63.17) 147.93,63.03 147.05,63.03 146.47,63.61 144.59,63.61 139.51,68.69 130.06,68.69 124.42,74.33 115.6,74.33 114.36,75.57 114.36,80.12 112.71,81.77 110.5,81.77 109.49,82.79 v1(109.03,82.79)
  IN2 w0.508: v1(90.36,95.64) 92.42,95.64 93.66,96.89 95.69,96.89 97.34,95.24 101.03,95.24 102.23,96.44 102.87,96.44 103.82,97.4 v1(104.58,97.4) ; v1(58.94,119.62) 61.91,119.62 62.42,120.13 64.7,120.13 67.5,117.33 67.5,114.29 68.26,113.52 69.66,113.52 71.72,111.47 71.72,110.17 72.2,109.69 74.13,109.69 75.07,108.75 75.07,107.48 77.15,105.4 v1(77.66,105.4)
  BOTTOM w0.152: PR246.1 148.46,62.77 v1(148.07,63.17)
  BOTTOM w0.203: v1(114.49,123.3) 114.23,123.05 114.21,123.05 R441.1 R438.1 ; R446.2 107.12,121.78 106.55,121.21 106.3,121.21 v1(106.23,121.14) 105.85,120.76 R464.1 ; v1(111.8,122.21) 111.72,122.29 108.62,122.29 108.29,121.96 R447.2 ; R450.1 114.26,121.27 114.49,121.5 v1(114.54,121.5) 114.57,121.5 114.79,121.27 R451.1 ; R468.1 112,119.52 v1(111.69,119.52) ; R469.1 v1(114.49,119.75) R470.1 ; PR193.1 77.4,105.14 v1(77.66,105.4) ; R467.1 109.49,120.13 v1(109.1,119.75) 108.72,120.13 R466.2 ; v1(117.66,123.81) 117.92,123.56 R440.1
  BOTTOM w0.381: v1(105.49,109.73) U25.AM31
  BOTTOM w0.508: PR129.1 127.96,122.16 v1(126.05,122.16) ; v1(109.03,82.79) 108.49,82.26 107.91,82.26 107.51,81.85 106.69,81.85 106.28,81.44 PQ27.3 105.19,82.65 PC192.1 ; PR218.1 117.43,88.77 PR217.2 117.54,88.13 v1(117.54,87.87)
  vias: v1(111.82,125.21)
+3V_HDMI: length 12
  TOP w0.102: v1(22.73,74.26) 22.54,74.45 C211.2
  TOP w0.178: C174.2 17.56,81.45 v1(17.56,81.27)
  TOP w0.203: R138.2 22.95,82.25 22.9,82.31 v1(22.72,82.31) ; R136.1 19.78,83.07 v1(20.13,83.43)
  BOTTOM w0.178: v1(22.73,74.26) U28.1
  BOTTOM w0.203: C595.1 23.36,73.53 23.1,73.27 23.1,72.48 22.9,72.28 R569.1 ; R534.1 21.8,82.95 21.69,83.06 R536.1 21.17,83.32 21.07,83.43 20.38,83.43 ; v1(20.13,83.43) R540.1 R539.1
  BOTTOM w0.254: C595.1 23.68,73.82 23.25,74.26 v1(22.73,74.26)
  BOTTOM w0.381: 20.38,83.43 v1(20.13,83.43)
+3V_LAN: length 37.8
  TOP w0.203: U2.11 44.04,102.51 43.37,101.84 43.37,101.33 43.59,101.11 C107.2 43.59,100.32 43.63,100.28 C111.1
  TOP w0.508: v1(61.91,97.4) 62.17,97.66 R100.2 ; v1(43.63,99.05) C111.1
  IN1 w0.508: 42.78,107.94 42.78,106.59 41.72,105.52 41.72,104.05 40.83,103.16 40.83,102.14 41.01,101.97 41.01,100.39 41.84,99.55 43.12,99.55 v1(43.63,99.05)
  IN3 w0.508: v1(43.63,99.05) 44.67,98 51.98,98 53.66,99.68 56.93,99.68 59.73,96.89 61.4,96.89 v1(61.91,97.4)
  vias: v1(41.72,108.83) v1(48.45,113.78) v1(48.83,108.37) v1(48.83,107.43) v1(49.08,113.78) v1(49.46,108.34)
+3V_LDO_EC: length 41.2
  TOP w0.203: v1(181.16,33.01) 181.16,32.6 R255.2 ; R247.2 174.46,32.72 174.33,32.85 173.57,32.85 173.54,32.88 173.45,32.78 R250.2 R270.2
  TOP w0.508: 173.54,32.88 v1(173.54,32.88) ; v1(149.62,35.22) 150.06,35.66 PR63.1 ; R245.1 161.13,31.74 v1(160.84,31.74)
  IN1 w0.508: v1(160.84,31.74) 160.82,31.74 159.85,30.77 156.48,30.77 153.22,34.02 150.81,34.02 v1(149.62,35.22)
  IN2 w0.508: v1(181.16,33.01) 181.16,32.75 180.58,32.17 174.26,32.17 v1(173.54,32.88)
  IN3 w0.508: v1(160.84,31.74) 161.45,32.35 165.26,32.35 165.72,31.88 169.88,31.88 170.27,32.27 173.19,32.27 173.54,32.63 v1(173.54,32.88)
  vias: v1(157.92,22.85)
+3V_RTC: length 57
  TOP w0.203: R222.2 148.65,41.11 148.65,41.13 148.51,41.28 148.16,41.28 147.81,40.93 147.81,39.79 147.38,39.36 v1(147.38,38.34)
  IN2 w0.508: v1(102.68,31.1) 102.68,31.23 103.44,31.99 104.58,31.99 104.84,32.24 105.85,32.24 106.36,31.74 109.51,31.74 109.64,31.61 110.17,31.61 111,32.43 111,33.2 111.31,33.51 112.46,33.51 113.09,32.88 119.06,32.88 121.78,30.16 131.46,30.16 132.14,30.85 132.14,32.37 133.67,33.9 136.49,33.9 139.03,36.44 142.81,36.44 143.44,35.8 144.84,35.8 v1(147.38,38.34)
+3V_RTC_0: length 103.8
  TOP w0.381: R277.1 v1(105.73,28.43)
  IN1 w0.508: v1(105.73,28.43) 105.47,28.43 103.82,26.78 103.82,24.12 103.06,23.35 103.06,22.08 102.3,21.32 100.65,21.32 98.36,19.04 89.37,19.04 88.45,19.95 84.36,19.95 80.78,16.37 75.37,16.37 74.36,15.35 65.85,15.35 65.47,15.73 63.82,15.73 63.43,16.12 48.58,16.12 42.1,9.64 21.35,9.64 19.7,7.99 16.28,7.99 v1(15.77,7.48)
  BOTTOM w0.508: v1(15.77,7.48) 15.68,7.48 15.66,7.5 CN20.1
+3V_RTC_1:
  vias: v1(106.54,29.48)
+3V_RTC_2:
  vias: v1(105.37,27.7)
+3V_S5: length 254.7
  TOP w0.178: v1(73.09,20.15) 73.09,19.73 72.93,19.58 R349.2 ; v1(70.42,20.15) 70.42,19.72 70.56,19.58 R348.2
  TOP w0.203: R259.2 171.26,32.75 v1(171.13,32.88) ; v1(121.47,49.95) 121.2,49.95 120.97,50.18 C308.2 120.46,50.18 120.25,50.39 U8.1 ; R228.2 R226.2 v1(103.82,39.99) ; R260.2 v1(172.02,32.88) ; v1(101.41,27.67) R279.2
  TOP w0.254: R734.2 78.49,123.72 78.93,123.28 Q43.3 79.79,123.28 80,123.48 86.04,123.48 86.29,123.23 v1(87.23,123.23) 87.23,124.22 87.85,124.84 R735.2 88.08,124.83 Q42.3 ; v1(100.95,22.9) 100.95,23.42 U14.5
  TOP w0.305: Q20.2 70.57,17.99 v1(70.29,18.27) ; v1(111.68,39.84) 111.82,39.84 112.39,39.27 R601.2 ; Q20.5 73.44,17.99 74.36,18.91 v1(74.36,20.15)
  TOP w0.381: v1(42.89,21.36) 42.52,21.36 41.97,20.81 41.97,16.62 40.83,15.48 36.64,15.48 34.48,13.32 34.48,12.56 33.34,11.42 32.7,11.42 32.3,11.02 32.3,9.65 32.7,9.26 32.7,8.11 v1(32.24,7.66) 31.81,7.23 v1(31.81,6.59) R430.2 ; R281.2 100.52,28.05 100.9,27.67 v1(101.41,27.67) ; R417.1 203.71,12.23 203.71,12.24 203.64,12.31 v1(203.64,12.81) 203.64,13.06 R404.1 203,13.44 202.63,13.07 202.63,12.18 202.5,12.05 200.96,12.05 200.63,12.38 199.78,12.38 198.23,10.83 197.62,10.83 197.28,11.17 197.28,12.05 196.52,12.81 196.52,13.84 196.45,13.91 194.85,13.91 194.28,14.48 194.28,15.19 193.74,15.73 193.74,17.03 194.02,17.31 194.02,19.97 192.44,21.55 v1(192.44,21.96) ; R413.1 146.24,13.45 146.57,13.78 146.57,19.49 147.14,20.06 R346.1 147.51,20.43 147.76,20.69 v1(147.76,20.84) ; v1(107,25.01) 106.95,24.95 106.95,24.7 106.23,23.99 R313.1 ; v1(176.54,33.06) 176.72,32.88 R265.2 ; R267.2 107.28,30.36 v1(107.25,30.36)
  TOP w0.508: v1(197.04,33.26) 197.67,32.63 PR76.1
  IN1 w0.508: v1(13.6,8.98) 13.6,8.16 14.92,6.84 16.32,6.84 16.44,6.97 22.67,6.97 23.94,5.7 30.92,5.7 v1(31.81,6.59)
  IN2 w0.381: v1(111.06,53.45) 111.19,53.58 114.36,53.58 115.25,52.69 118.17,52.69 120.92,49.95 v1(121.47,49.95)
  IN2 w0.508: v1(87.23,123.23) 87.23,123.81 88.4,124.98 90.51,124.98 91.43,124.07 91.43,123.18 88.56,120.31 88.56,117.61 89.37,116.8 89.37,115.07 88.17,113.88 v1(83.83,113.88)
  SVCC w0.203: v1(103.69,32.63) 104.58,32.63
  IN3 w0.381: v1(203.64,12.81) 203.64,14.72 207.07,18.15 v1(207.96,18.15) ; v1(197.04,33.26) 197.55,32.75 197.55,31.36 196.47,30.28 196.47,29.64 195.39,28.56 194.14,28.56 193.03,27.44 193.03,26.91 v1(192.72,26.61)
  IN3 w0.508: v1(111.69,46.01) 112.18,46.01 113.6,47.43 113.6,50.96 112.74,51.83 112.74,52.54 111.82,53.45 v1(111.06,53.45) 111.06,54.22 110.83,54.44 110.83,59.65 110.17,60.31 v1(110.17,61.07)
  IN3 w1.27: 50.48,120.76 51.75,120.76 52.77,119.75 56.2,119.75 57.08,120.64 65.34,120.64 67.63,118.35 70.42,118.35 71.05,118.99 75.63,118.99 77.02,117.59 77.02,115.23
  BOTTOM w0.178: v1(74.61,24.5) 74.67,24.55 R671.1 ; CN12.1 76.66,21.21 77.15,21.7 77.15,22.72 76.74,23.13 C663.2 v1(76.64,22.47)
  BOTTOM w0.203: v1(103.69,32.63) 103.69,32.26 U33.5 ; v1(115.07,37.78) 115.07,37.83 115.84,38.59 R602.1 ; v2(109.08,43.78) 108.8,44.06 R594.2 ; R593.2 110.81,43.85 v2(110.55,43.6) ; R576.2 110.65,52.92 111.06,53.33 v1(111.06,53.45) ; v1(110.17,61.07) 109.82,61.43 R572.2 R571.2 ; v1(111.69,46.01) 111.24,46.01 110.91,46.34 R589.2 R748.2 ; R674.1 72.6,24.75 73.16,25.31 R671.1 ; R591.2 108.95,44.94 v2(109.08,44.82)
  BOTTOM w0.356: v1(192.72,26.61) 193.41,26.61 193.56,26.45 193.74,26.45 194.27,25.92 R678.1
  BOTTOM w0.381: R708.1 208.73,17.25 207.96,18.02 v1(207.96,18.15) ; R686.2 v1(66.99,22.98) 67.51,23.51 Q32.2 ; v1(176.54,33.06) 176.54,32.57 176.08,32.12 172.78,32.12 v1(172.02,32.88) v1(171.13,32.88) 171.04,32.88 170.05,31.89 170.05,29.64 169.58,29.17 169.58,28.08 169.94,27.72 v1(169.94,26.66) ; Q31.2 98.72,27.82 99.12,27.42 101.15,27.42 v1(101.41,27.67) ; R681.2 v1(69.53,23.74)
  BOTTOM w0.508: v1(70.42,20.15) 70.29,20.03 v1(70.29,18.27)
  vias: v1(17.59,89.27) v1(17.59,88.4) v1(47.56,112.41) v1(47.56,111.77) v1(48.83,120.76) v1(49.46,120.76) v1(52.44,101.18) v1(53.02,101.46) v1(83.3,114.24) v1(93.53,26.02) v1(147.13,24.55) v1(147.76,24.55) v1(148.4,24.55) v1(149.03,24.55) v1(149.67,24.55) v1(150.79,24.55) v1(151.42,24.55) v1(152.06,24.55) v1(152.69,24.55) v1(153.33,24.55) v1(158.68,23.84) v1(159.32,23.84) v1(187.01,21.78) v1(187.54,22.13)
+3V_SSD: length 2.1
  TOP w0.178: R432.2 v1(25.72,4.4)
  TOP w0.203: R434.2 31.78,3.29 v1(32.19,3.29) ; R425.2 v1(23.43,7.23)
  vias: v1(16.06,6.21) v1(16.06,5.57) v1(16.7,6.21) v1(16.7,5.57) v1(17.33,6.21) v1(17.33,5.57) v1(18.15,6.39) v1(22.03,3.29) v1(22.06,3.92) v1(22.69,3.92) v1(22.67,3.29) v1(35.75,3.67) v1(36.38,3.67) v1(37.02,3.67) v1(37.65,3.67) v1(38.29,3.67)
+3V_WLAN_P: length 17.6
  IN1 w0.508: v1(197.93,11.42) 197.17,12.18 194.75,12.18 194.37,11.8 194.37,11.21 193.64,10.48 v1(193.64,10.4)
  IN2 w0.508: v1(189.29,23.1) 187.39,23.1 186.75,22.47 182.56,22.47 181.8,21.7 v1(180.05,21.7)
  BOTTOM w0.508: R704.1 180.79,21.7 v1(180.05,21.7) 179.89,21.53 Q44.2
  vias: v1(188.43,26.91) v1(190.05,11.42) v1(190.69,11.42) v1(191.7,31.5) v1(192.11,30.87) v1(193.36,11.64)
+3VLCD_CON:
  vias: v1(63.05,103.03) v1(64.2,102.6) v1(64.83,102.6)
+3VLCD_CON_R:
  vias: v1(60.39,106.29) v1(60.74,105.5) v1(61.02,106.29)
+3VPCU: length 277.7
  TOP w0.203: 137.92,28.43 138.62,28.43 141.54,31.36 141.54,33.1 PR68.1 ; 137.92,28.43 v1(137.91,28.43) ; 137.92,28.43 137.92,28.83 PR84.2 ; R246.2 165.13,32.75 v1(165.13,32.98) ; v1(103.69,18.4) PR110.2
  TOP w0.305: PR91.2 136.43,28.08 137.38,29.03 ; v1(137.91,28.43) 137.56,28.43 137.38,28.6 137.38,29.03 ; PC101.1 137.38,29.03
  TOP w0.508: R83.2 57.47,101.48 57.45,101.46 v1(57.42,101.46)
  IN1 w0.508: v1(212.23,31.74) 211.52,31.74 211.26,31.48 211.26,25.84 209.97,24.55 208.01,24.55 207,23.53 207,20.99 206.44,20.43 206.16,20.43 204.89,19.16 203.72,19.16 202.26,20.62 201.67,20.62 200.62,21.68 199.63,21.68 199.22,22.08 199.22,23.53 200.34,24.65 200.34,28.66 199.21,29.79 199.21,29.87 198.44,30.64 198.44,33.9 199.2,34.66 201.99,34.66 202.98,35.65 203.64,35.65 204.15,36.16 v1(204.15,36.31) ; v1(55.48,14.13) 60.64,14.13 61.33,13.45 73.98,13.45 74.74,14.21 78.8,14.21 83.75,9.26 88.45,9.26 91.25,12.05 91.25,15.73 93.03,17.51 102.17,17.51 103.06,18.4 v1(103.69,18.4) 103.69,19.16 105.09,20.56 105.09,25.64 v1(105.98,26.53) ; v1(38.67,121.32) 38.86,121.14 41.11,121.14 41.76,120.48 43.39,120.48 44.05,121.14 45.65,121.14 45.9,120.89 46.8,120.89 52.64,115.05 55.56,115.05 55.94,114.67 55.94,112.64 54.52,111.21 v1(54.52,110.32)
  IN2 w0.508: 165.13,32.72 v1(165.13,32.98) ; 165.13,32.72 165.13,32.53 165.82,31.84 168.62,31.84 168.97,31.48 168.97,31.23 170.11,30.09 170.88,30.09 172.02,28.94 v1(172.02,28.48) ; 165.13,32.72 164.53,32.12 162.24,32.12 ; v1(159.19,32.68) 159.32,32.55 160.16,32.55 ; v1(105.98,26.53) 106.36,26.53 106.61,26.78 108.14,26.78 109.41,28.05 113.35,28.05 114.11,28.82 118.55,28.82 119.11,28.26 127.62,28.26 128.71,27.16 129.86,27.16 130.59,27.9 133.21,27.9 133.62,28.31 134.81,28.31 135.19,27.93 136.97,27.93 137.47,28.43 v1(137.91,28.43) 137.91,28.56 140.58,31.23 141.41,31.23 142.56,32.37 145.93,32.37 147.38,30.92 152.92,30.92 153.6,31.61 156.22,31.61 v1(157.29,32.68)
  IN3 w0.508: v1(204.15,36.31) 204.15,36.05 203.74,35.65 202.73,35.65 201.74,34.66 199.2,34.66 198.44,33.9 196.78,33.9 196.66,33.77 194.83,33.77 193.81,32.75 192.55,32.75 192.06,33.23 184.57,33.23 183.6,32.27 183.6,30.44 186.37,27.67 186.37,24.24 v1(186.24,24.12) 184.59,24.12 184.08,24.62 184.08,25.26 181.67,27.67 175.32,27.67 174.94,27.29 172.96,27.29 172.02,28.23 v1(172.02,28.48)
  BOTTOM w0.203: CN8.23 212.39,31.9 v1(212.23,31.74)
  BOTTOM w0.305: PR332.2 PR334.2 138.6,28.95 138.08,28.43 v1(137.91,28.43)
  BOTTOM w0.508: v1(38.67,121.32) 38.86,121.14 R448.1 ; R630.2 v1(204.15,36.31) ; R711.1 53.16,16.82 55.48,14.49 v1(55.48,14.13)
  vias: v1(55.15,110.32) v1(108.65,90.41) v1(109.41,90.41) v1(157.92,32.68) v1(158.56,32.68)
+3VPCU_EC: length 127.2
  TOP w0.203: v1(184.85,25.89) 184.08,25.89 183.8,26.18 C408.1 C407.1 182.53,26.18 182.15,26.56 U15.92 ; v1(162.94,18.63) 163.07,18.5 C454.1 164.17,18.5 164.52,18.16 U15.26 ; 174.81,11.42 174.59,11.64 174.59,12.03 174.46,12.15 C510.1 174.05,12.28 174.05,12.9 174.02,12.94 U15.50 ; U15.114 172.82,31.14 v1(172.93,31.25) 172.82,31.36 172.82,31.86 C365.1 ; 169.23,34.46 169.23,32.12 169.45,31.89 C364.1 169.73,30.92 170.02,30.64 U15.121
  TOP w0.508: 166.56,34.17 L3.2 ; 166.56,34.17 167.42,35.04 168.65,35.04 169.23,34.46 ; 166.56,34.17 165.87,34.86 164.89,34.86 162.97,32.93 R245.2 ; v1(185.69,17.26) 185.69,17.72 185.14,18.27 L7.1 ; 174.81,11.42 175.32,10.91 v1(185.86,10.91)
  IN1 w0.508: v1(163.01,31.23) 163.52,31.74 164.78,31.74 165.9,30.62 172.3,30.62 v1(172.93,31.25) ; v1(185.69,17.26) 186.02,17.59 190.02,17.59 191.72,19.29 193.38,19.29 194.12,18.55 194.12,14.08 192.57,12.54 192.57,10.88 191.54,9.84 186.68,9.84 185.86,10.65 v1(185.86,10.91)
  IN2 w0.508: v1(185.69,17.26) 185.69,17.56 185.38,17.87 182.66,17.87 180.78,15.99 175.83,15.99 175.5,16.32 170.19,16.32 169.41,15.54 166.16,15.54 165.27,16.42 165.27,17.28 164.4,18.15 163.42,18.15 v1(162.94,18.63)
  IN3 w0.508: v1(184.85,25.89) 185.02,26.07 185.02,26.86 184.47,27.42 184.08,27.42 182.81,28.69 182.81,28.82 182.05,29.58 179.51,29.58 179,30.09 174.09,30.09 v1(172.93,31.25)
  BOTTOM w0.508: v1(185.69,17.26) 185.69,17.56 185.63,17.61 185.63,22.06 185.23,22.47 185.23,23.48 185.61,23.86 185.61,24.88 184.85,25.64 v1(184.85,25.89)
+3VPCU_ECPLL: length 1.9
  TOP w0.203: 166.79,30.59 167.04,30.85 167.45,30.85 167.62,30.68 U15.127
+5V: length 126
  TOP w0.381: v1(60.79,102.73) 60.77,102.75 60.77,102.93 60.17,103.53 R81.1
  TOP w0.508: L4.1 202.13,28.06 201.9,27.83 C394.2 C409.1 199.71,26.54 199.45,26.28 199.45,24.98 198.54,24.07 198.54,22.29 197.8,21.55 197.8,20.38 198.46,19.72 v1(198.46,19.42)
  IN1 w1.016: 21.78,70.98 23.05,69.71 23.05,65.65 20.64,63.23 18.6,63.23 15.94,60.57 15.94,58.03 17.21,56.76 17.21,51.68 17.97,50.91 17.97,43.29 18.6,42.66 18.6,40.75 16.06,38.21 16.06,33.39 16.32,33.13 16.32,30.59
  IN2 w1.016: 16.83,85.2 16.83,85.46 20.51,89.14 20.51,89.78 23.05,92.32 26.22,92.32 29.78,95.87 43.62,95.87 46.04,98.28 49.72,98.28 51.24,99.81 59.75,99.81
  IN3 w0.381: v1(60.79,102.73) 60.79,100.87 v1(60.26,100.34)
  BOTTOM w0.254: Q41.1 198.37,16.18 196.65,17.9 R703.1
  BOTTOM w0.508: v1(198.46,19.42) 198.46,19.05 199.29,18.22 C699.2 L14.1 201.04,17.45 201.13,17.36 201.13,16.57 200.77,16.22 198.68,16.22 Q41.1 198.37,15.29 198.05,14.97 v1(198.05,14.72)
  vias: v1(16.06,29.45) v1(16.06,28.69) v1(16.44,84.82) v1(16.7,29.45) v1(16.7,28.69) v1(17.08,84.82) v1(59.62,100.34) v1(62.55,96.25) v1(63.18,96.25) v1(140.32,15.73) v1(140.96,15.73) v1(141.59,15.73) v1(142.23,15.73) v1(142.78,13.83) v1(176.74,23.81) v1(177.38,23.81) v1(179.29,17.94) v1(179.9,17.77) v1(214.82,13.58) v1(214.82,12.94) v1(215.58,13.58) v1(215.58,12.94)
+5V_HDD: length 16.2
  TOP w0.381: C497.1 v1(216.46,12.68) 215.71,11.92 Q23.3
  IN3 w0.381: v1(215.83,14.85) 215.07,14.85 213.37,13.14 212.08,13.14 211.77,13.45 v1(211.77,13.7)
  BOTTOM w0.254: v1(215.45,16.12) 214.69,16.88 214.41,16.88 213.93,17.36 213.93,17.77 212.66,19.04 211.77,19.04 211.13,18.4 R701.1
  BOTTOM w0.381: v1(211.77,13.7) 211.4,14.07 R718.1
  vias: v1(215.83,15.48) v1(216.09,16.12)
+5V_HDMIC: length 2
  TOP w0.203: R122.2 v1(16.44,87.87) ; R121.2 v1(14.54,87.87)
  BOTTOM w0.508: RV6.1 C579.1
  vias: v1(12.74,81.32) v1(13.09,80.78) v1(13.3,81.82)
+5V_KB:
  vias: v1(200.47,14.92)
+5V_ODD:
  vias: v1(130.49,16.62) v1(131.13,16.62) v1(131.76,16.62) v1(132.4,16.62) v1(136.08,14.39)
+5V_PVDD: length 13
  BOTTOM w0.203: L10.2 195.69,22.9 195.39,22.59 193.84,22.59 193.46,22.21 193.46,21.36 194.77,20.05 197.67,20.05 197.78,19.95 198.66,19.95 199.2,19.42 199.2,19.26 199.63,18.83 200.52,18.83 201.1,19.42
  vias: v1(201.46,19.11)
+5V_S5: length 218.3
  TOP w0.203: R392.1 24.41,15.32 v1(24.57,15.49)
  TOP w0.305: v1(151.75,53.6) 151.72,53.63 PR43.1
  TOP w0.381: v1(140.57,49.57) 140.57,50.18 140.44,50.31 PR51.2 ; L5.1 210.49,23.45 208.57,21.53 v1(208.57,19.98) ; v1(146.75,20.84) 146.75,21.58 146.01,22.31 v1(146.01,29.32)
  TOP w0.483: v1(70.61,125.58) 70.61,125 PR1.2
  IN2 w0.305: 73.11,114.59 73.11,115.71 72.93,115.88 v2(72.93,116.37) ; 73.11,114.59 74.1,114.59 76.39,112.31 77.46,112.31 78.21,113.06 v1(78.21,114.87) ; 73.11,114.59 72.9,114.37 71.35,114.37 70.55,115.18 69.53,115.18 69.11,114.75 v1(69.11,114.66) 68.51,115.25 68.51,119.75 70.61,121.84 v1(70.61,125.58)
  IN2 w0.381: v1(140.57,49.57) 142.23,49.57 142.56,49.9 144.08,49.9 144.97,50.79 147.76,50.79 149.03,52.06 150.36,52.06 151.83,53.52 151.83,53.59 151.8,53.62 151.77,53.62 v1(151.75,53.6)
  IN3 w0.381: v1(146.01,29.32) 146.99,30.3 146.99,33.4 145.6,34.78 145.6,35.7 147.48,37.58 148.02,37.58 149.79,39.36 149.79,40.93 149.11,41.61 149.11,44.26 148.32,45.04 148.32,46.37 149.36,47.41 150.33,47.41 150.93,48 151.41,48 153.1,49.69 153.1,51.96 152.33,52.72 152.33,53.02 v1(151.75,53.6)
  IN3 w0.508: v1(22.03,43.67) 21.91,43.8 21.91,46.11 21.35,46.67 21.35,51.42 19.24,53.53 19.24,55.23 22.03,58.03 24.19,58.03 25.59,59.42 25.59,72.38 27.65,74.43 27.65,93.97 28.76,95.09 28.76,100.42 29.17,100.82 37.27,100.82 39.69,103.24 40.7,103.24 41.39,103.92 41.39,105.57 40.98,105.98 40.5,105.98 40.24,106.23 40.24,107.63 40.96,108.34 40.96,113.27 41.97,114.29 41.97,117.99 42.48,118.5 56.86,118.5 57.21,118.86 59.04,118.86 59.17,118.73 63.26,118.73 63.69,118.3 64.2,118.3 64.78,117.72 65.72,117.72 68.78,114.65 69.07,114.65 69.08,114.66 v1(69.11,114.66)
  BOTTOM w0.203: C681.2 20.25,18.91 v1(20.38,18.78) ; PR161.1 73.32,115.98 v2(72.93,116.37) 72.55,115.99 PR160.1
  BOTTOM w0.254: PR166.1 69.08,114.66 v1(69.11,114.66)
  BOTTOM w0.381: C682.1 v1(21.27,18.78)
  BOTTOM w0.508: v1(78.21,114.87) 78.21,114.55 PR167.2
  vias: v1(16.06,27.55) v1(16.06,26.91) v1(16.06,26.28) v1(16.7,26.91) v1(16.7,26.28) v1(20.84,18.3) v1(21.02,22.01) v1(21.02,21.37) v1(21.45,23.02) v1(21.65,22.01) v1(21.65,21.37) v1(22.03,43.04) v1(22.29,22.01) v1(22.29,21.37) v1(193.79,27.16) v1(194.42,27.16) v1(208.21,19.42) v1(208.77,19.11) v1(209.13,19.67)
+5VA: length 16.9
  TOP w0.203: L4.2 204.78,29.82 205.51,30.56 C366.2 206.06,31.99 206.47,31.57 C367.1 207.07,31.1 v1(206.69,30.72) 206.84,30.57 207.22,30.57 208.73,29.06 L5.2
  BOTTOM w0.203: U35.26 206.79,28.46 207.4,29.07 207.4,30.87 208.09,31.56 C642.2 207.61,31.64 207.55,31.57 C367.1 207.07,31.1 v1(206.69,30.72)
+5VPCU: length 122.7
  TOP w0.203: v1(27.27,28.76) 27.06,28.76 26.83,28.53 PR90.1
  TOP w0.381: v1(202.63,11.29) 202.89,11.55 C517.2 ; R190.1 24.33,50.01 24.71,49.63 R193.1 24.71,48.75 25.59,47.87 25.59,43.93 24.57,42.91 22.72,42.91 22.21,42.4 20.81,42.4 v1(19.98,43.24) ; Q23.1 212.37,10.97 212.05,10.65 v1(211.9,10.65) R420.1
  IN2 w0.381: v1(205.17,36.31) 204.53,35.67 202.88,35.67 201.61,34.4 199.2,34.4 198.69,33.9 196.66,33.9 196.53,33.77 194.88,33.77 194.24,33.13 187.89,33.13 v1(187.26,32.5)
  IN2 w0.508: v1(116.14,82.92) 116.77,83.55 122.06,83.55 125,80.61 128.69,80.61 129.73,81.65 132.08,81.65 133.63,80.1 135.28,80.1 136.7,78.68 138.86,78.68 141.29,76.26 141.29,73.14 141.67,72.76 141.67,67.17 143.06,65.77 146.69,65.77 148.78,63.68 148.78,62.77 149.67,61.89 149.67,60.9 v1(149.03,60.26)
  BOTTOM w0.203: v1(157.16,31.43) 157.16,31.36 157.33,31.19 157.33,30.17 157.22,30.06 PR330.1 ; v1(147.89,43.55) 147.76,43.42 PR301.2 ; PR252.2 146.56,60.88 147.18,60.26 v1(149.03,60.26) ; PR245.1 149.77,62.11 150.2,61.68 150.2,60.26
  BOTTOM w0.381: v1(116.14,82.92) 116.39,82.92 PC191.1 116.51,83.55 PU9.4 ; R631.2 v1(205.17,36.31) ; v1(23.84,29.75) 23.91,29.83 26.35,29.83 27.24,28.94 27.24,28.79 v1(27.27,28.76)
  BOTTOM w0.457: PR293.1 146.37,46.5 v1(146.38,46.51)
  BOTTOM w0.508: v1(149.03,60.26) 150.2,60.26 150.84,59.63 150.84,57.92 151.67,57.09 151.67,56.61 153.92,53.25 154.51,51.82 154.52,51.81 154.79,51.17 154.79,49.79 153.55,48.55 153.02,48.55 152.44,47.97 152.44,46.6 151.45,45.6 v1(151.34,45.6)
  vias: v1(19.42,44.82) v1(19.42,44.18) v1(19.42,43.55) v1(19.98,44.51) v1(19.98,43.88) v1(22.79,30.97) v1(22.79,30.34) v1(23.18,29.78) v1(23.23,26.33) v1(23.23,25.69) v1(23.86,26.33) v1(23.86,25.69) v1(24.52,25.44) v1(28,22.24) v1(28,21.6) v1(28,20.94) v1(28,20.31) v1(28,19.67) v1(28,19.04) v1(28.64,22.24) v1(28.64,21.6) v1(28.64,20.94) v1(28.64,20.31) v1(28.64,19.67) v1(28.64,19.04) v1(29.27,22.24) v1(29.27,21.6) v1(29.91,22.24) v1(29.91,21.6) v1(30.54,22.24) v1(30.54,21.6) v1(47.41,23.15) v1(47.76,23.79) v1(48.04,23.15) v1(48.12,26.4) v1(48.7,23.05) v1(147.23,17.05) v1(147.25,17.69) v1(147.53,16.5) v1(148.17,16.5) v1(185.96,32.52) v1(186.62,32.5) v1(187.26,31.86) v1(188.73,19.67) v1(188.73,19.04) v1(189.37,19.67) v1(189.37,19.04)
+A3VPCU: length 1.9
  TOP w0.203: 182.85,18.68 182.18,19.36 U15.74
  vias: v1(182.61,18.12)
+V3A_LX:
  vias: v1(147.43,29.09)
+V3A_LX_R: length 3
  BOTTOM w0.102: PC274.1 145.32,29.23 145.81,28.74 v1(145.81,28.69)
  BOTTOM w0.559: PC274.1 PR331.2
+V3A_OUT: length 2.7
  BOTTOM w0.152: 151.12,37.35 151.12,39.33 150.84,39.61 PR309.2
  vias: v1(149.9,32.02) v1(151.13,35.35) v1(151.13,34.69) v1(151.79,35.35) v1(151.79,34.69) v1(152.47,35.35) v1(152.47,34.68) v1(153.11,35.36) v1(153.13,34.71)
+V5P5A_LX:
  vias: v1(41.95,20.81)
+V5P5A_LX_R: length 1.5
  BOTTOM w0.61: PR345.2 43.39,22.16 43.55,22.32 PC293.1
+V5P5A_OUT: length 5
  BOTTOM w0.152: 37.27,16.24 37.4,16.12 39.89,16.12 40.7,15.3 40.7,14.49 PR348.1
  vias: v1(31.28,25.08)
+VCC_CORE: length 147
  IN2 w0.152: v1(149.62,45.59) 149.41,45.8 149.41,46.09 149.19,46.32 149.19,47.2 148.31,48.08 145.64,48.08 144.44,49.27 142.9,49.27 142.38,48.75 136.72,48.75 136.33,49.14 133.51,49.14 v1(132.87,49.78) ; v1(129.13,56.52) 127.84,56.52 127.51,56.19 127.51,51.19 127.79,50.91 130.92,50.91 131.6,50.23 131.6,49.2 132.56,48.25 135.95,48.25 136.29,47.91 142.77,47.91 143.29,48.43 144.07,48.43 145.3,47.2 147.93,47.2 148.53,46.6 148.53,45.47 148.86,45.14 149.9,45.14 150.06,45.3 150.06,45.94 149.64,46.36 149.64,46.82 150.05,47.23 v1(151.16,47.23)
  BOTTOM w0.178: PR295.2 v1(149.62,45.59)
  BOTTOM w0.203: PR290.2 151.05,47.11 v1(151.16,47.23) ; v1(129.13,56.52) 127.91,57.73 127.91,59.38 127.29,60.01 PL11.2 ; PL12.2 130.11,52.83 130.77,52.18 130.77,50.98 131.96,49.78 v1(132.87,49.78)
  BOTTOM w0.254: v2(94,67.32) 94.27,67.59 U30.K12 ; U30.AJ7 98.86,51.63 v2(98.86,51.46) ; U30.T7 98.11,62.39 v2(98.11,62.6) 98.1,62.6 U30.R8 ; v2(97.92,59.49) 97.7,59.27 U30.Y8 ; U30.T10 v2(95.6,62.5) ; U30.H11 95.96,68.73 v2(96.03,68.73) ; U30.AE8 97.7,55.19 U30.AD7 99.01,55.49 v2(99.5,55.49)
  BOTTOM w0.305: U30.H15 92.31,69.99 U30.G14 92.8,69.7 v2(92.99,69.7) ; U30.P10 95.59,63.47 95.05,63.47 v2(94.95,63.58) ; v2(96.53,53.51) 96.1,53.93 U30.AF10 ; v2(89.68,59.39) 90.08,58.99 U30.Y17 U30.AA16 90.91,58.17 91.29,57.79 v2(91.29,57.76) 91.32,57.76 91.69,57.39 U30.AB15 U30.AC14 v2(92.91,56.19) 93.3,55.79 U30.AD13 ; U30.AK17 90.09,50.99 89.69,51.39 v2(89.67,51.39) 89.67,51.42 89.31,51.78 U30.AJ18 89.2,51.79 v2(88.8,52.19) 88.51,52.49 U30.AH19 ; U30.AF7 98.86,53.63 v2(98.86,53.49) ; v2(91.28,64.14) 91.33,64.14 91.68,63.79 U30.P15 91.73,63.79 v2(92.16,63.36) 92.51,63.02 U30.R14 92.54,62.99 92.94,62.59 v2(92.97,62.59) 92.97,62.56 93.31,62.22 U30.T13 ; U30.Y13 93.31,59.02 92.98,59.34 v2(92.98,59.42) 92.93,59.47 92.85,59.47 92.53,59.79 U30.W14 92.47,59.79 92.13,60.13 v2(92.13,60.18) 91.72,60.59 U30.V15 91.63,60.59 v2(91.24,60.99) 91.24,61.08 90.93,61.39 U30.U16 90.9,61.39 U30.T17 ; U30.V17 90.11,60.59 U30.W16 U30.Y15 91.73,58.99 92.08,58.64 92.13,58.64 v2(92.16,58.62) 92.16,58.56 92.51,58.22 U30.AA14 92.51,58.08 92.83,57.76 v2(92.91,57.76) 92.91,57.68 93.2,57.39 U30.AB13 ; v2(95.64,58.55) 95.64,58.45 U30.AA10 ; v2(93.68,53.87) 93.36,54.19 U30.AF13 v2(92.91,54.59) U30.AE14 U30.AD15 91.31,56.19 v2(91.2,56.19) 91.18,56.22 91.18,56.32 U30.AC16 U30.AB17 90.1,57.42 v2(89.77,57.76) 89.34,58.19 U30.AA18 v2(88.91,58.59) ; U30.G10 96.95,70.43 96.96,70.43 96.98,70.45 v2(96.98,70.45) ; v2(96.67,55.5) 96.6,55.5 U30.AD10 ; U30.W7 98.86,60.34 v2(98.86,60.55) ; U30.AK19 v2(88.89,51.37) ; U30.M7 98.51,66.07 98.1,66.47 v2(98.1,66.5) 97.7,66.89 U30.L8 ; v2(96.45,65.51) 96.45,65.62 96.1,65.96 U30.M10 ; U30.AB19 88.51,57.36 88.8,57.07 v2(88.8,56.99) 89.2,56.59 U30.AC18 89.71,56.19 v2(89.74,56.19) 89.76,56.18 89.76,56.14 U30.AD17 U30.AE16 91.18,54.72 91.18,54.68 91.31,54.56 v2(91.34,54.56) U30.AF15 92.1,53.79 92.11,53.79 U30.AG14 U30.AH13 93.68,52.22 v2(93.68,52.19) ; v2(93,67.32) 92.77,67.32 U30.K14 ; U30.H8 97.62,68.99 v2(98.09,69.46) 98.51,69.88 U30.G7 ; U30.G12 95.31,69.19 U30.H11 ; U30.K6 99.49,68.28 99.49,68.42 99.5,68.43 v2(99.5,68.44) ; U30.AA7 98.11,58.39 98.11,58.59 U30.Y8 ; U30.P13 93.31,63.82 92.96,64.16 v2(92.96,64.19) 92.93,64.19 92.53,64.59 U30.N14 92.51,64.64 92.47,64.68 v2(92.47,65.11) ; U30.AJ10 96.11,51.99 v2(96.5,52.37) ; U30.R16 90.97,62.99 v2(91.36,62.6) 91.36,62.53 U30.T15 91.7,62.11 92.03,61.79 v2(92.08,61.79) 92.48,61.39 U30.U14 92.93,60.96 v2(92.98,60.96) 92.98,60.91 U30.V13 ; U30.AF19 88.51,54.09 v2(88.8,53.79) 89.2,53.39 U30.AG18 U30.AH17 90.9,51.79 U30.AJ16 91.25,51.45 91.25,51.41 v2(91.23,51.39) 91.36,51.39 91.7,51.04 U30.AK15 ; U30.P7 98.81,63.69 v2(98.81,63.5) ; U30.AK13 92.91,51.39 v2(92.91,51.47) 92.83,51.47 U30.AJ14 92.11,52.19 92.1,52.19 U30.AH15 U30.AG16 90.51,53.79 U30.AF17 89.76,54.54 89.76,54.58 v2(89.74,54.59) 89.71,54.59 U30.AE18 89.2,54.99 v2(88.8,55.39) 88.51,55.69 U30.AD19
  BOTTOM w0.33: v2(95.64,59.52) U30.W10
  vias: v1(93.56,63.77) v1(128.23,55.08) v1(128.87,55.76) v1(128.87,55.08) v1(129.53,55.66) v1(129.53,55.03) v1(129.5,54.34) v1(130.19,55.64) v1(130.19,54.95) v1(130.19,54.31) v1(130.83,55.63) v1(130.83,54.94) v1(130.83,54.28) v1(130.81,53.56) v1(130.86,52.88) v1(131.42,54.59) v1(131.42,53.95) v1(131.45,53.28) v1(131.46,55.94) v1(131.46,55.28) v2(92.99,70.33) v2(93.7,57.76) v2(94.9,65.51) v2(100.42,59.96) v2(100.41,57.96) v2(103.72,54.6) v3(117.2,64.22) v3(117.21,63.44) v3(117.2,62.65) v3(117.21,61.87) v3(117.93,64.14) v3(117.95,63.4) v3(117.94,62.57) v3(117.95,61.83) v3(118.04,69.46) v3(118.04,68.69) v3(118.04,67.93) v3(118.04,67.17) v3(118.67,64.13) v3(118.69,63.4) v3(118.67,62.56) v3(118.69,61.83) v3(118.81,69.05) v3(118.81,68.29) v3(118.81,67.52) v3(118.81,66.76) v3(118.81,66) v3(119.19,69.73) v3(119.44,63.51) v3(119.44,62.77) v3(119.44,62.04) v3(119.44,61.3) v3(119.57,69.05) v3(119.57,68.29) v3(119.57,67.52) v3(119.57,66.76) v3(119.57,66) v3(119.95,69.73) v3(120.2,61.28) v3(120.71,69.73) v3(120.71,68.57) v3(120.71,67.8) v3(120.71,67.04) v3(120.71,66.25) v3(121.6,69.73) v3(121.6,68.57) v3(121.98,66.66) v3(121.98,65.9) v3(122.74,66.66) v3(122.74,65.9)
+VCC_V3A: length 1.4
  BOTTOM w0.229: PU13.9 145.07,35.33 PC264.1
+VCC_V5P5A: length 3.6
  BOTTOM w0.102: v1(42.84,14.44) 43.29,14.9 43.29,15.75 PC304.1
  BOTTOM w0.229: PU15.11 43.33,16.96 43.42,16.87 43.42,16.5 PC304.1
+VDD_08: length 33.5
  TOP w0.203: PR10.2 88.83,117.84 89.47,118.48 91.72,118.48 92.48,117.72
  TOP w0.381: v1(127.95,120.38) 127.95,119.87 PR9.1
  IN1 w0.381: v1(127.95,120.38) 126.93,120.38 125.92,119.37 123.92,119.37 123.04,118.48 119.07,118.48 114.18,113.59 114.18,110.43 113.88,110.12 v2(112.41,110.12)
  BOTTOM w0.305: U25.AG35 109.28,110.74 v1(109.28,110.1)
  BOTTOM w0.381: U25.W32 112.71,110.12 v2(112.41,110.12) ; U25.AC32 110.94,109.72 v1(111.39,110.17) ; U25.AJ32 108.03,110.15 v1(108.19,110.15) ; U25.AL34 106.91,110.12 v1(106.93,110.12) 107.2,110.12 U25.AJ34 ; U25.AG32 108.42,109.43 v1(108.16,109.43)
  vias: v1(108.82,109.54) v1(110.25,110.12) v3(96.07,116.83) v3(96.84,116.83)
+VDD_18:
  vias: v1(88.12,49.54) v2(87,49.56) v3(83.63,30.59) v3(84.26,30.97) v3(84.26,30.21)
+VDD_18_S5: length 1.2
  BOTTOM w0.305: U30.AL19 88.8,49.89 v2(88.8,49.79) 89.2,49.39 U30.AM18
  vias: v1(82.87,26.58)
+VDDCI: length 35.8
  TOP w0.203: PR15.1 72.04,117.34 71.84,117.54 71.84,118.25 72.3,118.71 v1(72.3,120.33)
  IN2 w0.152: v1(72.3,120.33) 72.3,120.87 72.45,121.03 73.08,121.03 74.58,122.53 88.05,122.53 v1(88.4,122.18)
  BOTTOM w0.203: v1(72.3,120.33) 72.32,120.31 PR142.2 ; v1(88.4,122.18) 88.43,122.16 88.43,120.53 88.67,120.28 PL6.2
  BOTTOM w0.381: PC134.1 92.2,124.44 93.03,123.61 93.03,122.09 v3(93.11,122) ; v1(116.65,103.24) 116.65,103.37 U25.L21 ; v1(110.6,98.28) 110.44,98.28 U25.AE11 ; U25.L17 117.33,102.05 v1(117.33,102.22) ; U25.L25 116.67,106.05 v1(116.67,106.23) ; U25.L29 116.61,108.11 v1(116.52,108.11) ; U25.N11 116.52,99.24 v1(116.52,99.3) ; U25.L13 117,99.83 v1(117.36,100.19) ; v1(114.44,98.34) 114.05,98.72 U25.U11 ; U25.AA11 v1(112.46,98.26)
  vias: v1(109.28,98.13) v1(113.85,116.19) v1(114.49,116.83) v1(114.49,116.19) v1(115.12,117.33) v1(115.12,116.7) v1(116.09,98.69) v1(116.6,107.3) v1(117.41,106.16) v3(93.11,121.23) v3(93.11,120.46) v3(93.11,119.7) v3(93.11,118.94) v3(93.86,119.54) v3(94.14,120.23)
+VDDCR_SOC: length 47.2
  TOP w0.203: PR32.2 148.74,59.84 148.22,60.36 147.81,60.36 146.72,61.45 144.97,61.45 v1(144.21,60.69)
  IN2 w0.178: v1(134.83,77.53) 135.53,76.82 137.65,76.82 138.04,76.43 138.04,76.06 138.04,73.8 139.72,72.11 139.72,63.28 142.67,60.33 143.85,60.33 v1(144.21,60.69)
  BOTTOM w0.203: v1(134.83,77.53) 134.24,77.53 133.28,76.57 133.28,75.43 133.02,75.17 PL9.2 ; PR232.1 129.05,79.8
  BOTTOM w0.305: U30.W18 89.29,59.79 v2(88.88,60.2) 88.51,60.57 U30.V19 88.51,60.62 v2(88.1,61.02) 87.73,61.39 U30.U20 ; U30.R18 89.28,62.99 v2(88.85,63.42) 88.51,63.76 U30.P19 v2(88.1,64.19) 87.71,64.59 U30.N20 ; v2(90.48,64.24) 90.55,64.24 U30.N16 90.6,64.9 v2(90.48,64.9) ; v2(89.67,60.99) 89.63,60.99 89.31,61.32 U30.U18 89.28,61.39 v2(88.88,61.79) 88.51,62.16 U30.T19 U30.R20 87.7,63.1 87.43,63.38 v2(87.43,63.39) ; U30.W20 v2(88.1,59.39) U30.Y19 ; v2(88.9,64.9) 89.02,64.9 89.31,64.62 U30.N18 v2(89.7,64.19) U30.P17
  vias: v1(96.58,76.31) v1(115.38,79.87) v1(115.38,79.23) v1(116.9,79.87) v1(116.9,79.23) v1(118.43,80) v1(118.43,79.36) v1(119.95,80) v1(120.71,80) v1(128.28,77.53) v2(87.35,61.85) v3(128.28,76.8) v3(128.28,76.06) v3(128.28,75.32) v3(128.31,74.59) v3(128.31,73.85) v3(128.99,77.96) v3(128.99,77.18) v3(128.99,76.44) v3(128.99,75.68) v3(128.99,74.92) v3(128.99,74.15)
+VDDQ: length 59.5
  TOP w0.508: R181.1 49.5,57.23 v1(48.32,58.41) v1(48.32,60.92) ; v1(64.17,116.57) 64.48,116.57 64.76,116.29 65.77,116.29 66.22,116.74 67.16,116.74 67.5,117.08 68.4,117.08 PR8.2 ; v1(28.97,64.83) v1(29.6,64.83)
  IN1 w0.508: v1(57.16,110.6) 58.79,110.6 62.6,114.41 62.6,115.71 63.46,116.57 v1(64.17,116.57)
  IN2 w0.381: v1(57.16,110.6) 57.03,110.48 55.97,110.48 55.31,111.14 54.44,111.14 53.02,109.71 52.13,109.71 51.75,109.33 51.75,105.78 52.26,105.27 53.66,105.27 54.42,104.51 54.42,103.49 53.35,102.42 52.21,102.42 48.91,99.12 45.58,99.12 43.22,96.76 v1(39.56,96.76)
  IN3 w0.381: v1(39.56,96.76) 41.36,94.96 41.36,93.31 42.15,92.52 v1(42.78,92.52)
+VDDQ_BOOT1: length 1.3
  TOP w0.483: PC16.1 61.18,119.73 PR4.1
+VDDQ_SR: length 2.4
  BOTTOM w0.102: v1(61.98,124.9) PC139.1
  BOTTOM w0.508: PC139.1 PR126.2
+VDDQ_VTT: length 87.2
  TOP w0.203: R161.1 33.62,77.61 33.46,77.46 28.89,77.46 28.64,77.71 28.64,78.6
  IN2 w0.508: v1(30.39,96.86) 31.05,97.52 42.97,97.52 44.26,98.81 44.26,100.7 44.64,101.08 46.95,101.08 48.45,102.58 48.45,104.51 49.34,105.4 49.44,105.4 51.04,107 51.04,109.89 52.23,111.09 53.4,111.09 54.15,111.83 55.6,111.83 56.17,111.26 56.81,111.26 56.83,111.29 57.54,111.29 57.85,110.98 57.85,109.84 56.83,108.83 56.07,108.83 55.69,108.44 v1(55.69,108.06)
  IN3 w0.508: v1(30.39,96.86) 30.39,95.13 28.89,93.64 28.89,80.12 v1(28.76,80)
  BOTTOM w0.508: v1(55.69,108.06) 55.69,108.34 56.2,108.85 57.24,108.85 59.88,111.49 59.88,115.86 60.85,116.83 60.95,116.83 61.33,117.2 61.33,118.17 60.94,118.56 60.94,120.5 61.33,120.89 61.81,120.89 62.48,121.56 62.48,121.77 63.64,122.92 64.47,122.92 PR132.2
  vias: v1(28.89,79.36) v1(29.02,90.66) v1(48.87,31.78) v1(48.89,31.15)
+VIN: length 96
  TOP w0.381: PC74.1 139.91,49.66 v2(139.96,49.62) ; PR2.1 133.69,122.95 v1(133.79,123.05) ; PC69.1 137.44,54.88 v2(138.49,55.93)
  IN1 w0.381: v1(74.89,125.31) 77.79,122.41 82.48,122.41 83.7,121.2 89.02,121.2 90.49,122.67 93.41,122.67 93.91,122.16 93.91,121.65 95.72,119.85 98.97,119.85 100.9,121.78 101.13,121.78 v1(102.02,122.67)
  IN3 w0.254: v1(133.79,123.05) 133.23,123.61 125.46,123.61 124.73,122.87 121.63,122.87 120.76,123.73 118.63,123.73 118.15,123.25 117.46,123.25 117.41,123.3 116.9,123.3 114.18,126.02 106.69,126.02 106.49,126.22 101.87,126.22 101.31,125.67 101.31,123.38 v1(102.02,122.67)
  BOTTOM w0.254: PR257.1 144.58,58.58 144.58,58.92 143.8,59.7 141.57,59.7
  BOTTOM w0.381: v1(111.44,82.41) 110.55,82.41 110.21,82.06 PR227.1 ; PR214.1 v1(87.09,88.03)
  BOTTOM w0.508: PR212.1 70.33,89.74 69.91,90.16 69.91,90.79 69.06,91.64 PR211.1 69.02,93.33 68.72,93.64 68.72,99.58 70.91,101.76 ; PC305.2 48.52,15.3
  vias: v1(50.33,16.85) v1(50.58,13.98) v1(51.22,13.98) v1(51.85,13.98) v1(52.49,13.98) v1(52.59,15.25) v1(68.18,120.48) v1(78.4,122.03) v1(79.54,104.76) v1(80.51,121.59) v1(81.73,121.21) v1(82.36,120.89) v1(124.73,35.69) v1(125.38,35.7) v1(126.05,35.67) v1(126.75,35.7) v1(132.37,63.71) v1(137.53,59.24) v1(139.51,34.78) v1(140.14,34.78) v1(140.78,34.78) v1(141.41,34.78) v1(142.02,42.33) v1(142.68,32.52) v1(143.61,43.57) v1(143.62,42.74) v1(143.64,41.98) v1(145.11,65.12) v1(145.53,65.77) v1(145.6,64.62) v1(146.15,65.11) v1(146.63,64.62) v2(136.74,59.56) v2(136.74,58.93) v2(142.47,59.1) v2(142.47,58.52) v2(142.47,57.92) v2(143.05,59.1) v2(143.05,58.52) v2(143.05,57.92) v3(72.68,103.29) v3(72.68,102.53) v3(72.68,101.76) v3(72.68,101) v3(72.68,100.24) v3(129.53,64.76) v3(129.47,63.61) v3(130.06,64.12) v3(130.67,64.68)
+VIN_BLIGHT:
  vias: v1(62.88,106.16) v1(62.88,105.52) v1(63.28,104.91) v1(63.51,106.16) v1(63.51,105.52)
AVDD2: length 3.7
  BOTTOM w0.203: C674.1 204.13,21.57 204.13,22.25 v1(204.28,22.39) 204.28,22.7 204.13,22.85 U35.40
  BOTTOM w0.381: C674.1 204.02,20.95 204.28,20.69 L13.2
AVDD2_R: length 5.4
  TOP w0.381: R353.1 204.19,18.49 v1(204.18,18.48) 203.97,18.27 v1(203.52,18.27) 203.52,17.93 203.82,17.62 R370.2
  BOTTOM w0.381: v1(203.52,18.27) 203.77,18.27 204.28,18.78 L13.1 204.65,18.94 205.41,18.18 R699.2
DVDD_IO: length 15.1
  TOP w0.203: C401.1 197.93,27.81 R278.1 ; C401.1 R292.1 ; C401.1 v1(198.82,27.55)
  IN2 w0.203: v1(196.66,22.08) 196.18,22.08 195.77,22.49 195.77,24.75 197.8,26.78 198.05,26.78 v1(198.82,27.55)
  BOTTOM w0.203: Q38.2 195.84,21.69 196.23,22.08 v1(196.66,22.08) ; v1(198.82,27.55) 198.69,27.67 198.31,27.67 198.03,27.95 C650.2 199.07,28.05 199.47,27.66 U35.9
GND: length 1943.5
  TOP w0.102: v1(43.06,109.59) 42.53,110.12 41.86,110.12 R65.1 41.86,109.31 42.37,109.31 42.61,109.07 v2(42.61,108.7)
  TOP w0.152: RV9.1 7.71,14.58 RV8.1
  TOP w0.178: U13.3 v1(20.43,34.58) ; v1(61.61,100.37) 61.61,100.42 61.58,100.44 61.4,100.44 61.15,100.7 C108.1 61.15,101.02 60.97,101.2 C103.1 ; C12.1 v1(49.08,115.28) ; R396.2 12.63,14.42 v1(12.71,14.34) ; C485.2 63.59,14.75 v1(63.31,14.46) ; C529.2 v1(13.78,4.18) ; v1(34.48,24.12) 34.35,24.24 PC122.2 ; v1(49.85,115.28) C13.1 ; C533.2 v1(21.02,2.53) ; v1(63.84,23.74) 63.97,23.61 C423.1 ; C532.2 v1(38.16,5.32) ; C277.2 v1(20.56,55.58) ; C444.1 22.95,19.54 22.82,19.42 v1(22.41,19.42) ; C534.2 v1(23.68,2.53)
  TOP w0.203: v1(163.94,19.59) 163.79,19.45 R691.1 162.34,19.45 162.22,19.56 Q35.1 ; C190.1 51.6,78.73 v1(51.62,78.71) ; C57.2 v1(149.69,107.94) ; R399.1 206.87,14.46 206.97,14.36 v1(206.97,14.21) ; C509.1 23.3,12.18 23.69,11.79 v1(23.69,11.54) ; v1(51.57,84.57) 51.45,84.44 C170.2 ; C452.2 213.55,19.04 213.29,19.29 v1(213.17,19.29) 213.04,19.29 212.81,19.06 C451.2 ; v1(145.08,82.86) 144.76,82.54 C177.2 ; v1(112.23,118.38) 112.23,118.76 112.68,119.21 R44.2 ; C342.2 112.16,42.23 112.11,42.27 v1(111.49,42.27) ; v1(184.42,17.26) R369.2 ; C68.2 146.85,106.39 v1(147.37,106.92) ; R13.1 v1(123.86,123.78) ; v1(37.27,31.63) 37.27,31.38 C376.2 ; v1(32.32,83.43) 33.21,82.54 33.7,82.54 U5.T7 ; C158.2 v1(145.01,88.57) ; R209.1 R216.1 116.65,43.67 116.4,43.43 C332.2 ; v1(207.2,17.39) 207.07,17.51 R365.1 ; v1(180.09,26.21) 180.14,26.16 U15.91 ; C459.2 214.16,18.25 v1(214.31,18.4) ; R186.2 51.85,51.95 51.53,51.63 v1(51.53,51.58) ; v1(141.58,106.18) 141.58,106.29 C64.2 ; C365.2 172.78,32.75 v1(172.91,32.88) ; R274.1 41.56,31.65 v1(41.71,31.79) ; C139.2 144.88,94.09 v1(144.8,94.17) ; v1(120.69,100.95) 120.31,101.33 119.84,101.33 119.72,101.46 119.49,101.46 119.46,101.48 C104.2 ; C15.2 147.22,114.14 v1(147.18,114.18) ; C308.1 121.45,50.63 v1(121.47,50.6) ; C140.2 133.57,93.05 133.58,93.03 v1(133.58,92.59) ; C372.2 174.46,31.2 v1(174.69,30.97) ; v1(51.62,76.96) 51.62,76.95 C200.2 ; v1(197.57,24.53) 197.58,24.53 R304.2 ; U6.T1 34.07,75.53 v1(33.67,75.13) 33.67,75.12 33.47,74.92 31.1,74.92 31,74.82 C212.1 ; C183.1 C184.1 20.76,80.25 v1(20.51,80) ; C36.2 118.68,110.7 v1(119.14,111.16) ; C370.1 47.3,32.11 47.69,32.5 v1(48.07,32.5) 48.19,32.38 C371.1 ; R8.1 111.31,124.07 111.62,124.37 v1(111.82,124.37) ; R338.1 v1(16.7,19.16) ; C375.2 104.13,30.97 v1(104.25,31.1) ; v1(32.02,32.89) 31.66,32.53 C358.2 ; v1(47.24,16.72) 46.66,16.13 PR115.1 ; v1(161.51,30.21) 161.51,30.72 C374.2 ; R59.2 143.56,111.87 v1(143.98,112.29) ; v1(174.05,15.35) 173.62,14.92 U15.49 173.62,12.79 R733.2 173.49,12.15 v1(173.59,12.05) 173.94,11.7 C510.2 ; C221.2 29.68,69.21 29.65,69.18 v1(29.65,69.16) ; v1(145.58,112.44) 145.79,112.23 C22.2 C23.2 ; C215.2 v1(51.62,73.77) ; C166.2 v1(149.69,86.47) ; v1(143.36,82.58) 142.98,82.58 142.58,82.18 C175.2 ; v1(114.49,118.99) 114.26,119.21 R45.2 ; v1(121.47,48.63) 121.38,48.63 C313.2 119.54,49.16 119.44,49.26 U8.5 U8.2 ; C191.1 31.07,77.96 C194.1 ; v1(143.58,117.08) 143.44,117.08 143.16,116.8 C8.2 ; C280.2 C281.2 41.87,54.59 v1(41.96,54.49) ; v1(199.83,22.41) 200.04,22.41 R327.2 ; R29.2 129.98,121.91 v1(130.36,122.29) ; C86.2 v1(132.83,105.02) ; C62.2 117.48,107.48 v1(117.56,107.56) ; C69.2 144.66,106.3 v1(144.78,106.18) ; R177.1 v1(43.49,64.88) ; C427.2 163.61,21.48 v1(163.94,21.14) 163.71,21.14 163.48,20.91 C676.1 ; v1(206.18,12.05) 206.41,12.28 R411.1 R407.1 ; v1(120.07,96.54) 119,96.54 C126.2 ; C283.1 43.91,54.78 v1(43.62,54.49) 43.34,54.78 C282.2 ; R212.2 36.41,44.34 36.92,44.85 v1(36.92,45.11) ; C213.1 51.6,74.92 v1(51.63,74.94) ; R22.2 v1(122.49,121.73) R35.1 ; v1(139,27.21) 139.01,27.22 139.01,28.06 139.66,28.72 PR86.1 ; C122.2 C123.2 111.48,98.17 v1(111.48,98.25) ; U9.T1 33.74,52.31 31.56,52.31 30.89,52.97 C293.1 30.39,52.97 29.88,53.48 v1(29.88,53.86) ; C47.2 147.19,108.97 146.8,108.58 v1(146.38,108.58) ; C60.2 119.82,107.05 120.08,107.3 v1(120.08,107.63) ; PR105.2 101.22,21.58 PC126.2 ; C137.2 143.67,93.7 v1(143.98,93.39) ; C129.1 51.5,95.87 v1(51.58,95.96) ; v1(40.09,64.88) 40.17,64.94 C241.2 ; C172.2 v1(149.69,82.92) ; R355.2 12.79,18.75 12.51,19.04 v1(12.38,19.04) ; C136.2 147.67,93.89 v1(147.76,93.79) ; R36.2 v1(125.44,120.18) 125.44,119.78 125.16,119.49 R42.1 ; C106.2 v1(142.43,100.11) C118.2 ; C135.1 51.38,94.73 v1(51.61,94.96) ; C515.2 22.06,11.44 v1(22.16,11.54) ; v1(35.62,66.53) 35.78,66.38 C237.1 C236.2 ; v1(143.65,36.47) 143.65,35.8 143.67,35.77 PR64.1 ; C499.2 23.53,13.1 v1(23.69,12.94) ; R3.2 R4.1 v1(122.19,125.31) ; v1(42.84,31.79) 43.02,31.61 C378.2 ; 8.95,16.12 8.95,15.68 8.66,15.39 RV9.1 ; C356.2 31.15,34.12 v2(31.3,34.28) ; R381.1 206.56,15.99 v1(206.94,16.37) 206.56,16.75 R372.1 ; R199.1 v1(16.22,47.99) ; R273.2 39.97,31.2 39.81,31.36 39.81,31.61 v1(39.56,31.86) 39.28,31.58 C377.1 ; C48.1 43.4,109.25 v1(43.06,109.59) ; PR78.2 193.99,31.43 ; v1(139.2,116.63) 139.16,116.67 R46.1 ; C284.2 45.37,54.65 v1(45.53,54.49) ; C363.2 166.08,31.72 C369.2 ; v1(142.34,87.02) 142.4,86.97 R120.2 ; R174.2 36.41,68.2 v1(36.92,68.71) ; C96.1 39.59,103.34 39.18,103.75 v2(39.18,104) ; C78.2 v1(117.36,104.2) ; C119.2 v1(116.77,98.16) ; v1(33.82,56.4) 33.84,56.4 33.87,56.37 33.92,56.37 34.13,56.17 C272.2 ; C164.2 145.26,86.67 v1(144.78,86.19) ; v1(206.92,15.3) 206.84,15.23 R390.1 ; C124.2 115.66,96.43 115.1,95.87 v1(114.79,95.87) ; C277.2 19.66,55.58 19.37,55.29 U7.3 ; C242.2 41.31,65.53 41.31,64.98 v1(41.21,64.88) ; C168.2 v1(149.69,85.33) ; C148.2 v1(149.69,92.19) ; C42.2 v1(149.69,109.97) ; v1(38.67,78.6) 38.67,78.35 38.37,78.04 R159.2 C197.2 ; C192.1 22.54,78.22 v1(22.41,78.09) ; C82.2 119.59,104.76 v1(120.04,104.32) ; C412.2 163.69,25.48 v1(163.94,25.23) ; U15.104 v1(176.82,28.64) ; C49.2 v1(149.69,108.95) ; v1(42.48,78.09) 42.35,78.22 C189.1 R152.2 ; v1(135.7,119.11) 135.7,118.22 135.35,117.87 C5.2 C4.2 C3.2 ; v1(169.73,32.88) C364.2 R258.2 ; C18.2 144.71,114.14 v1(144.77,114.19) ; C154.2 v1(149.69,91.05) ; C178.2 145.63,81.39 v1(145.38,81.13) ; R249.2 38.16,31.91 v1(37.91,31.66) ; v1(58.91,106.29) 58.79,106.29 58.26,105.76 C74.2 ; v1(129.22,24.24) 129.22,24.12 129.63,23.71 C419.2 ; C165.2 v1(51.62,86.6) ; R37.1 106.85,120.71 107.2,120.36 107.2,120.18 v1(107.25,120.13) ; R176.2 42.1,65.01 v1(41.97,64.88) ; v1(147.44,116.72) 147.44,116.73 C6.2 ; v1(112.59,95.74) 113.1,96.25 C128.2 ; v1(134.13,104.97) 134.13,104.85 133.95,104.66 C87.2 ; C111.2 42.85,100.18 43.14,100.47 C107.1 ; v1(51.62,45.12) 51.57,45.07 C328.1 ; v1(143.35,104.9) 143.42,104.97 C75.2 ; v1(135.85,105.12) 135.85,104.61 C88.2 ; v1(146.07,104.13) 145.45,104.76 C79.2 ; R38.1 120.97,121.09 v1(120.92,121.14) ; v1(94.17,114.67) 94.17,114.79 94.65,115.27 PC26.2 ; v1(45.98,42.47) 45.98,42.59 45.63,42.94 C334.2 ; v1(116.04,48.8) 115.96,48.73 R196.1 115.45,50.35 115.76,50.66 116.39,50.66 117.64,49.42 R191.1 ; C352.1 49.24,36.41 v1(48.96,36.69) ; C432.2 120.74,20.73 120.99,20.48 C440.2 120.71,20.02 v1(120.71,19.75) ; C174.1 17.21,82.66 v1(17.46,82.92) ; v1(16.32,54.72) 16.48,54.89 U7.9 17.77,54.89 U7.11 17.37,55.68 U7.8 16.54,55.68 v1(16.32,55.46) ; v1(143.21,90.05) 143.1,89.93 C160.2 ; C324.2 30.79,47.24 31.15,46.87 32.98,46.87 33.34,47.23 34.02,47.23 U9.T7 ; C442.2 130.5,20.44 129.83,19.77 C445.1 ; U15.1 166.39,28.16 166.69,27.85 167.14,27.85 167.37,27.62 v1(167.37,27.35) ; C361.2 51.45,32.37 v1(51.53,32.29) ; C411.1 v1(93.61,25.26) ; C341.2 v1(149.67,42.4) ; v1(51.6,81.44) 51.52,81.52 C180.2 ; C46.1 53.37,109.23 52.78,109.83 v1(52.78,110.3) ; v1(141.9,102.06) 141.95,102.11 C97.2 ; R391.2 22.92,15.99 R374.1 22.31,16.27 22.26,16.32 v1(22.03,16.32) ; C240.2 C239.2 ; v1(145.58,115.78) 145.67,115.87 C7.2 ; v1(145.58,108.58) 145.58,108.62 144.85,109.34 C45.2 ; 154.91,28.96 PU4.15 PU4.11 ; C355.1 49.03,34.25 v1(48.83,34.05) ; C84.2 141.31,104.92 v1(141.67,105.27) ; v1(18.48,77.58) C195.1 C201.1 ; v1(48.96,54.49) 49.31,54.85 C286.2 C288.1 ; C61.1 59.87,106.92 C67.1 ; C159.2 146.91,89.66 v1(146.38,90.19) ; R50.1 v1(149.69,113.02) ; R363.2 13.4,16.72 v1(13.3,16.62) 13.3,16.27 12.91,15.88 R383.2 ; v1(45.78,78.09) R157.1 ; R272.2 96.71,31 96.33,30.62 v1(96.33,30.67) ; C35.1 v1(48.96,110.96) ; v1(41.34,78.07) C188.2 ; C207.1 v1(19.24,76.19) ; R737.2 32.35,65.44 v1(32.47,65.31) ; C133.2 143.73,95.36 v1(143.85,95.23) 143.99,95.36 C131.2 ; C176.2 143.22,81.51 v1(143.47,81.26) ; v1(145.76,96.24) 145.51,96 C132.2 ; C156.2 v1(149.69,89.9) ; C163.2 v1(149.69,87.62) ; v1(162.8,16.5) 162.8,16.19 163.16,15.83 R384.2 ; v1(149.69,110.98) C30.2 149.18,111.16 149.42,111.4 C21.1 ; C95.1 117.9,102.49 117.92,102.48 117.92,101.84 118.04,101.71 R88.2 ; R115.1 v1(31.3,89.52) ; C179.2 v1(147.21,82.88) ; R357.1 68.95,18.6 v1(69.28,18.27) ; v1(29.5,45.83) 29.75,45.58 C326.2 ; C171.2 v1(149.69,84.19) ; R24.1 108.87,121.96 v1(109.26,121.58) ; v1(25.05,14.34) R405.1 ; C531.2 35.4,4.78 v1(35.24,4.94) ; C161.2 v1(149.69,88.76) ; C340.1 30.5,40.78 30.78,40.5 v1(30.9,40.5) ; R101.2 113.88,98 v1(113.6,98.28) 113.47,98.28 113.09,97.9 C120.2 ; C199.1 36,76.08 v1(36.03,76.06) ; v1(144.78,84.59) 144.73,84.64 C169.2 ; v1(105.98,27.16) 105.85,27.16 105.7,27.01 C404.2 ; PU5.11 v1(21.75,28.05) ; C63.2 v1(149.69,106.92) ; C13.1 C14.1
  TOP w0.241: 64.96,118.9 65.29,119.23 PU1.3
  TOP w0.254: v1(106.49,31.1) 106.49,31.23 105.9,31.81 105.15,31.81 R262.2 ; R77.1 51.03,104.02 v1(51.76,104.02) ; v1(38.01,56.2) 38.01,56.12 37.75,55.86 C274.2 ; v1(36.92,45.11) 36.92,45.13 U9.N9 ; v1(208.6,13.7) C498.2 C504.2 208.06,12.63 207.84,12.42 C516.2 ; v1(101.48,22.52) 101.93,22.97 102.5,22.97 102.96,22.52 PD4.2 ; U6.N9 36.92,68.73 v1(36.92,68.71) ; C273.1 35.9,55.89 36.15,56.14 v1(36.15,56.25) ; U10.14 19.36,48.88 v1(19.62,49.14) ; C403.2 101.54,26.42 102.07,25.89 102.55,25.89 102.68,25.77 v1(103.19,25.77) 103.47,25.48 U14.3 ; C25.2 44,111.63 43.79,111.83 43.58,111.83 43.36,112.06 43.36,113.14 43.89,113.67 Y1.2 ; v1(36.76,33.64) 36.53,33.88 U12.N9 ; R664.1 88.67,23.24 90.46,21.45 92.31,21.45 93.61,22.74 v1(93.61,25.26) ; v1(184.42,26.4) 184.19,26.63 C408.2 C407.2 ; R225.1 110.63,42.05 109.83,41.25 R604.1 ; U18.13 v1(210.25,13.45) ; 64.58,17.61 v1(64.58,17.59) ; 64.58,17.61 64.49,17.7 U17.16 ; 64.58,17.61 64.58,18.02 64.4,18.2 U17.15 ; v1(44.38,115.18) 44.89,114.67 45.78,114.67 46.77,113.68 46.77,111.43 C26.1 ; U9.H9 40.61,45.44 40.61,44.91 40.18,44.48 v1(40.13,44.48) ; v1(93.97,94.47) 93.58,94.47 U3.3 ; C449.2 v1(61.52,19.56) ; PR48.2 153.22,51.61 v2(153.83,51) 153.4,51 PR50.1 ; U18.18 213.04,16.37 v1(213.14,16.27) ; U17.5 66.16,16.18 66.38,15.96 v1(66.74,15.96) ; v1(210.37,19.19) 210.37,19.16 210.25,19.04 U18.3 ; v1(21.75,8.44) 21.69,8.38 U21.5 ; v1(36.92,80.06) 36.92,80.11 U5.N9 ; C296.2 85.69,53.07 86.51,53.07 C291.2 ; C212.1 30.54,74.54 v1(30.8,74.28)
  TOP w0.305: v1(122.11,19.7) 122.51,20.1 U16.23 ; U17.13 64.16,20.4 64.45,20.69 v1(64.66,20.69) U17.12 ; v1(30.8,70.36) 31.73,70.36 32.25,70.88 33.98,70.88 U6.T7 ; U12.K9 38.93,33.97 v1(40.09,32.8) ; U16.33 123.94,23.1 U16.16 ; v1(111.92,48.2) 113.29,48.2 113.89,47.6 C610.1 ; v1(8.47,16.6) 8.95,16.12 RV3.8 RV3.3 v1(11.36,16.12) ; v2(86.01,46.58) 86.26,46.84 C318.2 ; U20.2 187.64,15.1 187.29,14.74 187.29,12.97 187.01,12.69 187.01,11.42 v1(186.5,10.91) ; C353.2 163.03,35.33 163.03,36.67 v1(163.31,36.94) ; U12.T7 32.83,35.75 v1(32.75,35.67) ; U17.10 v1(65.66,20.69) ; v1(39.31,80.13) U5.K9
  TOP w0.356: U12.T1 30.98,40.55 30.92,40.5 v1(30.9,40.5) ; U5.C9 44.53,80.45 v1(44.9,80.07) ; U12.E1 43.33,40.15 v1(43.33,40.15) 43.33,40.15 U12.D2 ; C25.2 44.05,111.18 44.05,110.27 v1(44,110.22) ; v1(36.53,88.06) U5.N1 ; U9.D8 v1(43.32,45.92) 43.32,45.93 U9.E8 ; U5.D8 v1(44.13,80.91) ; v1(45.73,80.87) 46.13,81.27 U5.A8 ; U6.A8 v1(46.53,69.53) ; v1(44.11,75.13) 44.11,75.12 U6.D2 ; v1(46.54,86.51) 46.53,86.51 U5.A2 ; v1(40.93,33.75) U12.H9 ; v1(41.34,78.07) 41.34,77.9 39.26,75.82 39.22,75.82 U6.K1 ; U12.F1 v1(41.73,40.95) 41.65,41.03 41,41.03 U12.H1 v1(40.13,40.95) 40.01,41.07 39.44,41.07 U12.K1 ; U9.A8 46.5,45.95 v1(46.53,45.95) ; U12.E8 43.3,34.58 v1(43.3,34.55) ; v1(42.53,81.68) 42.55,81.68 U5.E8 ; v1(44.93,45.95) 44.93,45.93 U9.C9 ; U5.K1 39.31,87.29 v1(39.31,87.38) ; v1(42.54,70.32) 42.54,70.29 42.9,69.93 U6.E8 ; v1(44.13,51.5) 43.75,51.13 U9.D2 ; U6.H9 40.93,68.73 v1(40.93,68.7) ; U12.A2 46.13,39.73 v1(45.73,39.33) 45.33,39.73 U12.B2 ; U9.E1 v1(42.53,51.53) U9.F1 ; v1(41.22,53.31) 41.22,53.29 41.22,53.29 40.2,53.29 39.22,52.31 39.22,52.22 U9.K1 ; U6.N1 36.53,75.56 v1(36.03,76.06) ; U9.E3 v1(43.33,50.73) ; U9.N1 36.53,52.42 v1(36.26,52.69) ; U5.H1 40.91,87.29 v1(40.91,87.33) ; U12.A8 46.65,34.43 v1(46.65,33.78) ; U12.D8 v1(44.13,34.55) ; C243.2 88.31,65.09 88.12,64.9 88.12,64.88 v2(88.11,64.87) ; U12.N1 36.53,40.84 v1(36.31,41.05) ; v1(46.54,75.13) 46.53,75.13 U6.A2 ; U5.E1 42.93,86.96 v1(42.51,87.33) 42.13,86.99 U5.F1 ; U5.G8 v1(40.93,80.91) ; U9.K9 39.98,44.48 v1(40.13,44.48) ; U12.C9 44.13,33.75 v1(44.11,33.75) ; C240.2 45.39,65.78 44.89,66.28 v1(44.89,66.41) ; U6.F1 v1(41.73,75.93) ; v1(44.11,86.51) 44.11,86.49 U5.D2 ; v1(41.72,84.29) 41.91,84.29 U5.E3 ; v1(45.74,75.13) 45.73,75.13 U6.B2 ; v1(43.7,37.48) 42.93,38.25 U12.E3 ; v1(45.74,86.51) 45.73,86.51 U5.B2 ; U5.T1 33.48,87.55 v1(33.29,87.55) ; U6.E1 42.53,75.93 v1(42.53,75.93) ; U9.G8 v1(40.94,46.71) ; U6.K9 v1(39.33,68.73) ; U12.G8 v1(40.93,34.55) ; PR61.1 147.51,36.57 147.48,36.57 147.41,36.5 147.3,36.5 v1(146.9,36.11) ; U6.G8 40.93,69.53 v1(40.93,69.5) ; U6.D8 v1(44.13,70.33) ; U9.B2 v1(45.73,51.53) 46.13,51.13 U9.A2 ; U6.C9 v1(44.11,69.54) ; U6.H1 v1(40.93,75.13) ; v1(41.74,72.88) 41.89,72.89 U6.E3 ; U5.H9 v1(40.93,80.11) ; U9.H1 v1(40.93,51.53)
  TOP w0.381: PC66.2 101.75,53.99 101.07,53.3 PC70.2 100.99,53.37 v2(100.41,53.95) ; C11.2 v1(46.8,114.54) ; v1(69.33,125.58) 69.23,125.58 69.13,125.48 PC1.2 ; PC116.2 25.34,26.65 25.12,26.88 PC115.2 v1(25.84,27.27) ; C418.2 161.96,23.74 v1(161.86,23.84) ; R95.1 119.03,97.9 119.68,97.9 v1(119.89,97.69) ; R231.1 104.7,37.82 105.09,38.21 v1(105.09,38.72) ; v1(53.66,51.55) 53.41,51.79 C299.1 ; v2(89.72,52.19) 89.72,52.2 89.7,52.22 89.7,52.23 89.65,52.28 C294.2 ; C138.1 90.48,93.26 v1(90.61,93.13) ; C359.2 97.1,32.38 96.66,31.94 v1(96.33,31.94) ; C518.2 14.93,10.65 v1(15.53,10.65) 15.53,10.04 15.78,9.79 C519.1 ; C26.1 46.8,111.24 47.18,110.86 v1(47.18,110.86) ; R299.2 209.23,24.09 v1(209.48,23.84) ; R275.2 210.13,29.7 v1(210.37,29.45) ; v1(9.56,12.33) 10.22,12.99 C500.2 ; v1(67.67,120.04) 67.75,120.04 68.13,119.66 PC19.1 ; PC93.2 v1(18.47,32.5) ; v1(112.68,121.91) 111.67,120.89 U1.4 ; v1(22.41,80) 22.55,79.86 R145.2 ; v1(12.76,12.94) 12.25,12.94 12.01,13.19 D24.1 ; C354.2 23.57,34.28 v1(24.06,34.28) ; v2(94.95,61.39) 95.54,61.39 C252.2 95.52,61.95 95.31,61.95 v2(94.91,62.35) ; C501.1 182.56,13.45 182.05,13.96 182.05,14.31 v1(182.03,14.34) ; v1(186.5,10.91) 186.5,11.16 185.74,11.92 185.23,11.92 184.84,12.31 C503.2 ; v2(102.27,57.38) 102.26,57.37 PC62.2 ; 18.09,27.81 PC114.2 ; 18.09,27.81 17.62,28.27 17.17,28.27 v1(16.7,27.8) ; 18.09,27.81 PC102.2 ; v1(131.13,21.2) 131.52,21.58 D9.1 ; v1(48.96,52.46) 49.1,52.31 C298.2 ; v1(119.82,42.79) 119.57,43.04 118.43,43.04 118.3,43.17 C332.2 ; v1(145.09,40.76) 145.42,40.44 PC79.2 PC80.2 ; v1(199.32,32.63) 199.19,32.49 R268.2 ; C311.2 96.18,50.38 C304.2 ; PC58.2 104.55,58.42 v2(104.07,58.9) ; R94.1 57.08,99.67 v1(57.08,97.18) ; v1(52.26,71.77) 52.39,71.64 C220.1 ; PC78.2 139.36,41.22 v3(139.37,41.24) ; v2(93.04,66.31) 92.95,66.41 C232.2 ; v2(83.85,68.05) 84.15,68.05 84.5,67.69 C227.2 ; RV2.2 15.81,88.01 v1(15.81,88.25) ; v1(216.6,42.28) 216.22,42.28 C337.2 216.35,42.91 v1(216.6,42.91) ; R271.2 210.88,31.36 211.14,31.1 v1(211.97,31.1) ; v1(22.92,57.01) 22.3,57.01 C267.2 ; PC110.2 32.1,28.65 v1(31.81,28.94) ; HE2.3 v1(46.16,121.56) ; v1(100.8,82.79) 100.8,82.51 101.24,82.07 Q8.1 ; v1(29.5,47.36) 29.62,47.24 C324.2 ; 200.33,13.46 201.13,12.66 v1(202.04,12.66) ; 200.33,13.46 200.71,13.84 R402.2 ; 200.33,13.46 Q25.1 ; v1(45.23,111.76) 45.23,112.33 Y1.4 ; v1(42.23,100.19) 42.61,99.81 C111.2 ; PC97.2 v1(24.45,31.09) ; C433.2 70.24,20.81 69.48,20.05 68.39,20.05 68.11,20.33 v1(68.11,20.69) ; PC20.2 v1(11.75,118.04) ; PC51.2 90.83,63.02 v2(90.43,62.61) 90.43,62.27 C250.2 ; PC91.2 v1(21.74,29.99) ; v1(44.38,115.18) 44.07,114.86 Y1.2 ; C400.2 184.07,28.03 v1(184.47,28.03) ; R243.2 94.3,32.64 v2(94.31,32.63) ; C424.2 184.44,23.24 184.47,23.21 v1(184.47,23.16) ; v1(11.36,5.75) 11.74,5.38 C528.1 ; v1(45.53,54.49) 45.81,54.49 46.15,54.84 C279.1 ; C244.2 50.1,63.75 C248.2 49.11,63.74 v2(48.96,63.59) ; HE1.3 v1(33.97,121.56) ; v1(16.32,46.6) 17.05,46.6 C325.2 ; C73.2 C83.2 64.97,103.63 v1(64.96,103.62) ; C301.1 16.67,51.47 v1(16.37,51.17) ; v2(102.29,58.9) 101.93,59.26 PC57.2 ; PC54.2 102.55,60.69 v2(102.67,60.81) ; R172.1 v1(102.18,74.03) ; v2(94.88,54.45) 95.53,54.45 C290.2 95.08,53.54 v2(94.9,53.54) ; PU6.2 195.26,27.16 194.63,27.8 v1(194.37,27.8) ; C416.1 v1(184.84,24.73) 184.86,24.76 C415.1 ; v1(117.56,38.31) 117.51,38.31 117.16,37.96 U11.2 ; C516.2 208.21,11.67 208.47,11.93 v1(208.47,12.38) ; C362.2 24.03,31.85 v1(24.19,32.02) ; C434.2 73.25,20.81 73.72,20.34 v1(73.72,20.15) ; Q12.1 v1(105.79,74.55) ; C259.1 56.82,59.55 54.05,59.55 53.91,59.41 C258.2 53.53,58.53 v2(53.91,58.15) ; R91.1 53.54,99.8 53.27,100.06 53.27,100.85 53.66,101.23 v1(53.66,101.46) 53.66,101.84 54.2,102.39 Q3.1 ; v1(144.44,25.23) 143.62,25.23 HOLE11.1 ; C238.2 38.68,65.15 v1(38.44,64.91) ; PR101.1 43.45,24.41 43.47,24.39 v1(43.5,24.39) ; v1(212.15,34.28) 212.16,34.27 212.16,33.26 R244.2 212.03,32.69 v1(212.23,32.5) ; v2(104.02,57.4) 105.08,57.4 105.31,57.17 PC63.2 ; Q9.1 98.22,82.79 97.84,82.41 v1(97.22,82.41) ; C224.1 49.34,68.31 v2(48.96,67.93) ; v1(184.41,31.13) 184.31,31.23 C373.1 ; C245.2 91.87,64.45 v2(92.16,64.16) ; R162.1 96.9,77.97 96.58,77.65 v1(96.58,76.95) ; C369.2 165.8,32.51 v1(165.8,32.88) ; C401.2 197.12,27.55 v1(196.81,27.85) ; v1(45.78,78.09) 45.78,77.81 46.14,77.46 C198.1 ; Q13.1 109.42,71.88 110.02,72.48 v1(110.02,72.76) ; v2(52.51,58.15) 51.75,58.91 C257.1 ; v2(87.26,51.24) 87.3,51.2 C305.2 ; Q18.1 25.01,21.39 24.76,21.64 v1(24.38,21.64) ; v1(97.62,97.23) 97.24,97.61 C125.1 ; C85.1 147.64,104.8 v1(147.28,105.16) ; PC126.2 101.4,22.44 v1(101.48,22.52) ; R257.1 101.29,31.85 101.41,31.74 C380.1 100.96,30.86 v1(100.57,30.47) ; PC123.2 33.43,24.28 33.59,24.12 v1(33.84,24.12) ; v1(93.97,94.47) 94.34,94.85 R103.2 ; v1(39.05,5.32) 39.05,7.85 HOLE12.1 ; v1(48.96,66.79) 49.84,66.79 C228.1 ; v2(88.1,63.39) 88.1,62.84 C249.2 88.1,62.33 v2(88.1,61.79) ; v2(88.8,56.19) 89.61,57 C269.2 ; v2(86.08,56.39) 85.53,56.94 C271.1 ; v1(104.23,82.28) 104.99,81.52 105.22,81.52 106.34,80.39 Q10.1 ; v1(45.98,42.47) 45.97,42.48 45.97,42.51 46.43,42.98 C335.1 ; PR27.2 142.17,72.4 v1(142.35,72.58) ; R198.2 v1(24.33,47.11) ; C353.2 D6.2 ; v1(149.57,38.35) 149.59,38.33 149.59,38.29 149.56,38.26 Q15.1 ; R67.2 C52.2 58.93,108.58 57.88,109.63 C43.2 57.5,109.46 56.6,109.46 v1(56.58,109.49) 56.58,109.97 Q2.1 56.41,110.7 C24.1 ; C530.2 37.15,5.83 v1(36.89,6.08) ; 96.33,30.62 96.33,30.59 96.72,30.2 C385.2 ; R225.1 110.79,42.27 v1(111.49,42.27) ; v1(23.94,55.49) 23.36,55.49 C278.1 ; Q3.4 56.08,103.99 56.21,103.86 R79.2 56.7,103.36 v1(57.21,102.86) ; v1(131.25,120.26) 131.25,119.86 130.74,119.35 PQ2.1 ; C442.2 130.36,20.7 v1(130.36,21.2) ; C345.2 v1(21.9,39.24) ; C2.2 123.88,121.75 v1(123.9,121.78) ; 193.99,31.43 194.37,31.81 v1(194.37,32.37) ; PC52.2 97.54,61.8 v2(97.21,61.46) ; Q16.1 104.31,35.66 v2(104.07,35.9) ; v2(85.46,63.5) 85.1,63.87 C246.2 ; v1(96.48,78.6) 96.48,78.79 C186.2 ; v1(103.19,25.77) R289.2 ; C134.1 v1(95.68,94.35) ; v1(208.09,22.59) 207.7,22.59 R328.2 ; Q26.1 v1(25.33,6.4) ; v2(87,44.39) 86.66,44.74 86.66,45.19 C327.2 ; C316.2 87.26,47.81 v2(87.05,47.6) ; R158.1 99.38,77.57 v1(99.38,77.08) 99.38,76.83 R166.1 ; v1(106.49,31.1) 106.73,31.35 R266.1 ; C413.2 v1(106.36,25.01) ; v1(151.62,55.26) 151.62,55.03 151.36,54.76 PC67.1 ; v1(119.75,41.76) C339.2 ; PR3.2 135.11,122.58 v1(134.55,123.14) ; v1(212.15,36.31) 214.95,36.31 ; C387.2 C386.1 v2(47.42,29.07) ; C478.2 v1(69.53,17.13) ; v1(150.68,13.45) 150.74,13.39 Q22.1 ; PC92.2 196.53,31.62 196.53,32.29 v1(196.78,32.55) ; PC107.2 v1(25.84,28.23) ; C425.1 160.71,23.7 v1(160.84,23.84) ; v1(133.8,38.08) 133.95,38.23 133.95,39.46 133.27,40.13 PQ6.1 ; C292.1 22.85,53.06 v1(22.59,53.33) ; C216.2 v1(23.68,72) ; C300.2 88.01,52.5 88.5,52.99 v2(88.8,52.99) ; v1(65.07,125.59) 65.19,125.47 PC2.1 PC3.2 ; PC100.2 v1(25.84,29.2) ; C1.2 117.52,125.44 v1(117.03,125.44) ; PC21.2 64.74,118.38 64.96,118.6 64.96,118.9 v1(64.94,118.9) ; C306.1 v1(16.37,50.46) ; C127.1 146.28,96.76 v1(145.76,96.24) ; v1(29.27,77.96) C191.1 ; v1(48.96,60.92) 49.08,60.8 C255.2 C260.1 ; U4.2 v1(13.2,85.01) ; v1(90.36,94.96) 90.98,94.96 C130.2 ; C343.1 115.96,40.63 v1(115.84,40.75) ; C217.2 84.13,71.19 v2(84,71.06) ; v1(54.54,51.57) 54.42,51.7 C297.2 ; C441.1 202.37,19.57 v1(202.09,19.29) ; C9.1 139.47,116.36 v1(139.2,116.63) ; v1(52.12,26.65) C410.1 51.11,24.5 C414.1 ; v2(88.16,58.62) 88.1,58.62 87.96,58.47 C268.2 ; v1(9.59,22.08) C435.2 ; PC64.2 98.71,56.08 v2(98.3,56.49) 98.23,56.56 PC59.2 ; v1(51.75,48.35) 51.73,48.37 C317.2 ; v1(148.47,68.96) 148.92,68.96 149.27,69.31 PQ5.1 ; C447.2 21.15,19.8 v1(21.91,19.8) ; v2(98.51,37.63) 98.49,37.6 98.49,37.46 C350.2 ; v2(87.24,53) 86.74,53 C291.2 ; Q11.1 v1(102.8,78.74) ; R192.1 16.07,49.4 v1(15.81,49.14) ; R339.1 184.47,20.31 v1(185,20.31) 185.11,20.2 L6.2 ; C247.2 94.97,64.51 v2(94.95,64.49) ; v1(35.49,28.94) 35.21,28.65 PC111.2 ; C351.2 100.61,36.65 100.9,36.94 v2(100.9,37.83) 101.02,37.95 C347.2 ; C114.2 61.24,100 v1(61.61,100.37) ; PC125.1 v1(38.92,23.74) ; C67.1 59.63,106.8 59.12,106.29 v1(58.91,106.29) ; C349.2 v1(21.78,36.68) ; RV1.2 v1(13.65,88.25) ; C254.2 92.93,60.16 92.16,59.39 v2(92.16,59.36) 92.21,59.36 92.9,58.67 92.9,58.67 C263.2 ; C28.2 C29.2 42.84,110.37 43.06,110.15 v1(43.06,109.59) ; PC118.1 192.05,25.77 v1(192.41,25.41) ; v1(129.86,24.23) 130.11,24.23 130.39,24.51 C417.1 ; C261.2 v1(22.91,59.43) ; R414.2 147.38,12.71 v1(148.12,13.45) ; v1(53.27,70.7) 53.27,70.1 C223.1
  TOP w0.406: PC68.1 140.11,54.39 139.91,54.59 138.96,54.59 138.84,54.71 v1(138.58,54.71) ; 92.93,60.22 v2(92.18,60.96) 92.93,61.71
  TOP w0.457: v2(88.8,57.79) 88.95,57.79 89.69,58.52 C264.2 ; v2(93.68,54.59) 93.95,54.86 C276.2 93.95,55.92 v2(93.68,56.19) 93.48,56.39 93.48,56.55 93.09,56.95 92.95,56.95 C270.2 ; v2(92.91,53.79) 92.29,53.18 C295.2 ; v2(88.8,54.59) 88.85,54.59 89.69,55.42 C275.2 ; 92.93,61.71 C251.2 92.93,61.79 v2(92.16,62.56) ; C294.2 89.65,53.78 v2(89.72,53.85) ; v2(90.51,59.39) 90.85,59.73 C256.2 90.85,60.31 90.45,60.7 v2(90.45,61.02) ; v1(47.24,16.72) 46.89,16.72 PQ11.1 ; C307.2 89.28,50.43 C303.2 90.5,50.43 90.7,50.63 v2(91.24,50.63) 91.83,50.63 C302.2 91.36,49.81 v2(91.24,49.81) ; 92.93,60.22 C254.2
  TOP w0.508: PC32.2 v1(111.52,109.08) ; v1(31.94,30.01) C381.1 ; C95.1 117.9,103.67 v1(118.44,104.21) ; C304.2 98.08,50.38 v2(98.1,50.4) ; C219.2 54.81,71.2 v1(54.16,71.84) ; v1(29.63,67.57) C225.1 ; C50.1 117.85,108.62 v2(117.21,109.26) ; C398.2 86.48,28.53 C391.2 86.48,29.24 86.29,29.42 v1(86.29,29.7) ; R67.2 60.77,108.91 60.94,109.08 61.83,109.08 62.16,108.75 62.16,107.48 62.04,107.35 C66.2 ; v1(56.32,71.84) 56.32,71.61 56.45,71.49 C218.2 ; C302.2 92.48,50.45 C309.2 ; C265.2 86.86,58.16 v2(87.34,58.63) 87.34,59.36 C253.2 ; v1(201.23,28.56) 200.76,29.03 C394.1 ; v1(45.39,31.79) C379.2 ; v1(201.23,25.92) 201.07,25.76 C409.2 ; PC31.2 116.39,110.4 v1(115.84,110.96) ; C329.1 29.03,44.06 v1(28.51,44.06) ; C157.1 49.25,89.33 v1(48.96,89.04) ; v2(87.22,54.6) 87.56,54.6 C287.2 ; R200.1 C610.1 ; v1(198.08,17.26) 197.53,17.81 PC129.2 ; v1(30.41,101.56) 30.41,101.85 29.92,102.35 C100.2
  IN1 w0.381: v2(86.08,56.39) 86.08,55.42 86.91,54.6 v2(87.22,54.6)
  BOTTOM w0.102: v1(99.76,114.67) 99.76,116.83 101,118.07 104.05,118.07 104.23,118.25 104.23,118.68 103.82,119.09 v1(103.82,119.24) ; U25.AY41 101.3,115.43 101.03,115.71 101.03,116.83 101.33,117.13 101.33,117.31 101.69,117.66 104.41,117.66 105.09,118.35 105.09,119.59 105.24,119.75 105.24,120.66 105.73,121.14 105.73,121.27 ; U25.AA3 111.96,93.78 110.95,93.78 U25.AC3 ; 101.19,42.67 100.88,42.67 100.56,42.99 U30.AW5 ; 101.92,125.84 102.17,126.1 103.69,126.1 103.95,125.84 ; U25.C19 121.94,102.66 121.94,103.69 U25.C21 ; v2(100.07,42.38) 100.52,41.93 101.21,41.93 101.55,41.59 U30.BB1
  BOTTOM w0.127: U30.BD3 100.84,40.75 100.24,41.36 100.09,41.5 99.94,41.5 99.51,41.94 U30.AY6
  BOTTOM w0.152: U25.A17 123.42,101.52 123.56,101.38 123.96,101.38 v1(124.14,101.21) ; U25.AW37 103.24,112.52 v1(103.76,112) ; U25.A25 123.88,105.92 124.3,105.5 124.93,105.5 v1(125.36,105.07) ; U25.A29 123.47,108.29 123.98,108.29 v1(124.41,107.86) ; U25.A21 123.6,103.72 124.08,103.24 v1(124.33,103.24) ; 101.19,42.67 101.41,42.9 v2(102.64,42.9)
  BOTTOM w0.178: C617.1 v1(15.43,42.28) ; v1(23.3,42.28) 23.02,42.56 C614.2 ; C663.1 77.18,23.58 77.4,23.35 v1(77.53,23.35) ; U39.9 16.57,19.04 v1(16.7,19.16) ; R560.2 v1(88.58,77.46) ; R533.1 87.82,84.19 87.92,84.29 v1(87.92,84.31) ; R561.2 v1(89.34,77.46) ; R559.1 v1(87.69,77.46) ; R566.2 v1(86.55,77.33)
  BOTTOM w0.198: PU14.34 135.76,29.65 136.14,29.65 136.99,28.79 PR338.1 ; PU14.36 133.02,29.98 PU14.22
  BOTTOM w0.203: PC173.1 68.27,104.01 v1(67.91,104.38) ; v2(178.27,19.49) 178.21,19.44 C700.2 ; v1(90.92,77.33) 90.87,77.38 R567.2 ; v1(96.33,31.94) 96.53,31.94 96.74,32.15 R646.2 ; R568.2 21.52,72.5 v1(21.78,72.25) ; VRAM1.N1 137.57,106.18 137.57,106.99 VRAM1.N3 ; U25.AY17 U25.BA17 ; R603.1 117.71,38.47 v1(117.56,38.31) ; v1(75.2,120.36) 75.2,120.23 74.98,120.02 PR139.2 74.98,119.69 75.45,119.22 75.45,118.54 75.92,118.07 PC149.2 ; v1(199.83,22.41) 199.3,22.95 C664.1 ; C682.2 21.11,20.02 C681.1 19.4,20.02 C680.1 ; 102.17,112.89 102.17,113.56 U25.AW39 ; v2(102.8,67.69) 102.8,67.79 102.44,68.15 101.96,68.15 U30.K1 ; R640.2 93.86,33.56 94.04,33.39 94.04,32.88 94.3,32.63 v2(94.31,32.63) ; v1(166.81,20.18) 167.07,19.93 C685.2 ; R484.1 v1(114.49,118.99) R483.1 ; R633.1 201.96,35.42 v1(201.61,35.42) ; v1(103.82,119.24) 104.18,119.6 U22.6 ; v1(129.47,113.4) R497.1 130.01,113.04 129.72,112.75 C545.1 ; R474.2 108.62,119.26 108.97,118.91 v1(109.1,118.91) 109.21,118.91 109.56,119.27 R475.2 ; U25.A13 123.84,99.32 v1(123.99,99.17) ; R460.1 114.62,120.51 v1(114.49,120.38) 114.36,120.51 R459.1 ; C559.1 49.82,103.27 v1(49.85,103.29) ; R444.1 114.87,122.03 v1(114.49,122.41) 114.11,122.03 R443.1 ; C542.2 v1(129.98,115.71) ; v1(91.86,31) 91.5,31.36 91.5,31.47 R648.1 ; C633.2 20.52,34.5 v1(20.43,34.58) ; PC148.2 72.32,117.87 v2(72.3,117.84) ; PR172.1 66.75,110.34 66.36,110.73 v1(66.36,110.86) 66.8,111.3 PC165.2 ; v1(125.44,120.18) 125.44,118.76 125.28,118.6 R491.1 ; v1(65.72,95.36) 65.95,95.14 C568.2 ; C650.1 197.01,28.05 v1(196.81,27.85) ; C537.2 37.7,123.51 ; R485.1 116.75,118.57 v1(116.9,118.41) 117.48,118.99 R486.1 ; v1(169.94,19.95) 169.94,20.1 R679.2 ; R528.1 130.27,89.55 130,89.29 130,88.91 C571.1 ; v1(136.76,83.81) 136.76,84.58 VRAM2.E12 ; v1(66.31,112.83) 66.69,112.46 PC163.2 ; C675.1 200.62,20.72 200.08,20.17 C679.2 ; v1(112.23,118.38) 112.23,118.86 112.31,118.93 R482.1 ; R487.1 120.2,118.99 120.53,119.32 120.53,119.92 120.33,120.13 119.92,120.13 R463.1 120.28,120.51 v1(120.92,121.14) ; C581.1 147.02,79.22 146.69,79.55 R548.1 ; R705.2 212.18,17.57 212.28,17.66 212.28,18.38 v1(212.23,18.43) ; R437.1 113.95,125.11 113.73,125.34 v1(113.35,125.34) ; v1(134.88,87.57) 134.88,86.7 VRAM2.B10 ; U25.AU1 103.2,91.93 v1(103.14,91.86) ; PC150.1 71.05,117.82 v1(71.36,117.82) 71.36,117.78 70.96,117.37 PC152.2 ; v1(194.75,29.96) C645.2 C648.2 ; v1(11.87,22.21) 12.25,22.21 12.51,21.96 C671.1 ; R445.1 117.57,122.36 v1(117.18,122.74) ; R490.1 121.65,118.6 v1(122.08,119.04) ; C623.2 17.36,37.48 v1(17.08,37.2) ; R458.2 R449.2 v1(112.68,121.91) ; C565.1 95.34,97.54 v1(95.36,97.52) ; 137.58,90.99 137.58,91.79 VRAM2.E3 ; U25.AC39 110.93,113.59 111.97,113.59 U25.AA39 112.03,113.59 113.07,113.59 U25.W39 113.11,113.62 114.2,113.62 U25.U39 ; v1(13.47,22.34) C672.1 C673.1 ; C677.2 202.49,19.92 202.66,20.08 C678.1 ; v1(103.82,118.48) 103.59,118.48 103.19,118.88 R479.2 ; R520.2 96.48,97.75 96.71,97.52 97.33,97.52 v1(97.62,97.23) 97.28,96.89 R524.1 ; R462.1 117.36,120.51 v1(117.28,120.43) 117.21,120.51 R461.1 ; C582.1 141.4,79.09 141.73,79.42 R553.1 ; C689.2 C690.2 ; C693.2 210.35,19.16 v1(210.37,19.19) ; R465.1 106.92,120.71 107.2,120.43 107.2,120.18 v1(107.25,120.13) 106.64,119.52 R481.2 ; R592.2 110.04,43.67 v2(109.97,43.6) ; v1(125.56,90.21) 124.95,90.21 124.11,89.37 R530.1 ; v1(63.82,90.26) 63.92,90.26 64.32,90.66 C570.2 ; R535.2 17.56,83.02 v1(17.46,82.92) 17.21,82.66 C174.1 ; PR270.1 153.54,51.27 153.81,51 v2(153.83,51) ; v1(111.92,48.2) 111.72,47.99 R586.2 ; v1(63.43,93.46) 63.69,93.71 C569.2 ; C687.2 C688.2 ; U33.3 101.89,33.28 101.89,33.57 101.66,33.79 v2(101.56,33.79) ; C573.2 v1(22.92,83.81) ; C564.1 v1(94.2,97.52)
  BOTTOM w0.229: PU13.8 144.62,35.36 PC264.2 ; v1(45.03,16.65) 44.68,16.99 PU15.8
  BOTTOM w0.254: v2(84,42.52) 84.07,42.59 U30.AY23 ; v1(51.53,39.02) 51.47,38.96 CN5.222 ; 82.79,58.52 81.59,58.52 81.1,58.04 ; 82.79,58.52 v2(82.8,58.53) 83.25,58.99 U30.Y25 ; 82.79,58.52 82.51,58.24 U30.AA26 82.51,57.93 v2(82.93,57.51) 82.93,57.36 U30.AC25 ; v1(105.19,91.73) 105.4,91.95 U25.AN1 ; U30.AW28 80.95,43.04 80.95,43.84 U30.AV28 U30.AU28 ; U30.AW28 80.51,42.99 v2(80.5,43) ; U30.AW28 81.03,42.96 81.03,42.39 v2(81.03,42.39) 81.4,42.39 U30.AY27 ; v1(29.14,8.37) 28.85,8.66 CN19.45 ; CN5.5 57.24,95.21 v1(56.46,95.99) ; U30.J19 88.01,67.9 88.01,67.3 U30.L20 ; CN15.B12 6.57,13.15 CN15.A1 ; U30.AA32 79.05,58.14 v2(78.74,58.14) ; CN5.217 59.66,40.21 v1(59.88,39.99) ; U30.W23 v2(85.3,59.59) 85.3,59.39 U30.Y22 ; v1(123.77,110.59) 123.6,110.59 123.33,110.32 U25.A33 ; 108.53,37.32 108.24,37.6 106.01,37.6 105.59,38.02 C622.2 ; 108.53,37.32 108.95,37.74 108.95,41.41 108.75,41.62 105.98,41.62 v1(105.95,41.59) ; 108.53,37.32 C625.1 ; v1(123.84,91.81) 123.43,92.21 123.43,92.9 U25.A2 ; v1(27.11,8.37) 27.35,8.61 CN19.51 ; PC141.1 71.3,122.03 71.3,122.44 PR127.1 71.59,123.04 v1(71.98,123.43) ; CN5.251 57.31,31.71 v1(56.32,30.72) ; U30.W26 82.51,60.21 v2(82.85,60.55) ; U30.W26 83.31,59.19 U30.Y25 ; U30.W26 82.06,59.55 81.66,59.55 ; v2(86.03,70.99) 86.23,70.99 86.51,70.72 U30.F21 ; CN5.226 51.79,37.96 v1(52.85,39.02) ; v1(182.03,14.34) 182.03,14.49 181.52,15 181.52,15.48 181.8,15.76 182.28,15.76 182.41,15.63 CN11.63 ; CN5.78 v1(51.62,76.96) ; 81.59,63.47 U30.R28 ; 81.59,63.47 81.99,63.47 U30.P26 82.51,63.79 U30.R25 83.36,62.99 83.71,62.64 v2(83.71,62.56) ; 81.59,63.47 81.59,63.51 U30.P28 80.88,64.22 80.88,64.62 80.56,64.94 v2(80.56,64.99) ; CN5.52 52.04,83.46 52.88,84.3 v1(52.88,84.57) ; U30.AV26 82.51,44 v2(83.01,44.51) 83.49,44.99 U30.AU25 ; U25.AJ5 107.44,95.32 v1(107.05,95.72) ; CN5.15 55.19,92.71 54.38,91.89 v1(54.38,91.72) ; CN5.197 57.49,45.21 57.37,45.08 v1(57.08,45.08) ; CN5.72 51.37,78.46 v1(51.62,78.71) ; v1(53.53,45.1) 53.53,44.82 52.67,43.96 CN5.202 ; v1(181.65,31.38) 182.19,30.83 182.19,29.82 182.38,29.63 CN11.7 ; v1(96.58,74.41) 96.58,73.57 96.51,73.49 U30.A10 ; U30.AU28 81.08,45.02 80.71,45.02 v2(80.62,44.93) ; U30.AU28 U30.AR28 ; v1(55.39,90.03) 56.07,90.03 56.39,89.71 CN5.27 ; v1(57.07,71.82) 57.08,71.81 57.1,71.81 57.2,71.71 CN5.99 ; U30.BD3 100.91,40.42 104.51,36.82 C624.1 ; CN5.48 51.46,84.46 v1(51.57,84.57) ; CN5.235 57.45,35.71 57.1,35.36 55.75,35.36 v1(54.31,33.92) ; v2(82.18,68.55) 82.51,68.23 U30.K26 ; CN19.33 31.85,8.71 32.07,8.5 v1(32.07,8.37) ; v1(51.62,71.77) 51.44,71.96 CN5.98 ; U30.AK5 100,50.89 100,50.09 U30.AL5 100.11,49.79 v2(100.11,49.53) ; v1(57.08,42.47) 57.35,42.21 CN5.209 ; PC149.2 76.1,117.9 76.1,116.92 PC153.2 ; v2(82.9,61.54) 82.51,61.94 U30.T26 ; CN5.10 v1(51.58,93.96) ; v1(118.58,91.81) 118.6,91.83 U25.J1 ; v2(85.99,43.68) 86.2,43.68 U30.AV21 ; CN15.A12 6.57,18.65 CN15.B1 ; v1(51.61,40.95) 51.61,40.96 CN5.214 ; v2(82.96,42.39) 82.7,42.39 U30.AY26 ; U30.A5 99.96,73.34 v2(99.32,73.34) 98.55,73.34 U30.A7 ; CN19.27 33.35,10.54 v1(33.08,10.81) ; CN5.1 57.84,96.21 57.08,96.96 v1(57.08,97.18) ; CN5.172 51.41,51.46 v1(51.53,51.58) ; U30.AP20 87.1,47.6 v2(87.05,47.6) ; v2(100.09,69.48) 100.09,69.81 U30.G5 U30.G3 ; v2(84.46,47.4) 84.46,47.54 84.91,47.98 U30.AN23 ; v1(36.76,7.86) 37.02,7.86 37.85,8.69 CN19.9 ; U25.A37 123.83,112.52 v1(123.91,112.61) ; CN5.23 56.68,90.71 55.67,91.72 v1(55.67,91.74) ; v1(57.08,82.41) 57.11,82.41 57.32,82.21 CN5.57 ; 81.1,58.04 U30.AA28 81.1,57.68 v2(81.39,57.39) ; 81.1,58.04 U30.Y28 81.66,59.55 ; v1(57.08,40.95) 57.09,40.95 57.34,41.21 CN5.213 ; CN19.57 v1(25.85,8.37) ; v1(55.81,42.47) 55.81,42.66 56.36,43.21 CN5.205 ; CN5.22 52.12,90.96 52.88,90.19 v1(52.88,90.07) ; R518.1 140.89,101.93 141.21,101.61 v1(141.21,101.6) ; v1(51.6,35.93) 51.57,35.96 CN5.234 ; CN5.93 57.27,73.21 56.96,73.52 v1(56.96,73.75) ; v1(52.89,81.44) 52.89,81.27 52.26,80.63 51.37,80.63 51.19,80.46 CN5.64 ; CN12.4 73.32,20.84 73.59,20.56 73.59,20.28 v1(73.72,20.15) ; CN5.260 51.11,29.46 v1(51.62,28.94) ; CN5.47 57.17,84.71 v1(57.07,84.61) ; v1(51.62,45.12) 51.29,45.46 CN5.196 ; v1(57.08,70.7) 57.08,70.14 57.52,69.71 CN5.107 ; v2(87,44.39) 87.26,44.65 87.36,44.65 U30.AU20 ; U25.B1 122.7,91.64 v1(122.82,91.52) ; v2(86.01,46.58) 86.2,46.39 U30.AR21 ; v2(53.66,88.92) 53.66,88.63 52.48,87.46 CN5.36 ; U30.Y25 83.72,59.41 v2(83.72,59.56) ; PU10.19 148.16,66.29 148.4,66.53 v1(148.52,66.53) ; v1(51.62,73.77) 51.44,73.96 CN5.90 ; v2(83.51,71.97) 83.59,71.97 83.95,71.6 84.29,71.6 U30.E23 84.93,70.97 v2(85.02,70.97) 85.08,70.97 U30.E22 ; v2(83.51,71.97) 83.42,71.97 83.05,71.59 82.71,71.59 U30.E26 ; v2(83.51,71.97) U30.E25 ; v2(102.64,42.9) 102.9,42.9 103.16,42.63 103.72,42.63 104.24,42.11 104.24,41.55 104.79,41.01 C619.2 ; CN5.14 v1(51.58,92.96) ; PR156.1 PR164.2 66.05,115.14 v1(65.59,114.68) 66.09,114.18 PC157.1 ; v1(106.36,116.06) 105.4,115.11 U25.AN41 ; U30.AP15 91.49,47.19 91.11,46.81 v2(90.99,46.81) ; CN5.189 56.64,47.21 56.2,46.76 v1(56.2,46.47) 56.2,46.34 56.6,45.93 57.08,45.93 57.35,46.21 CN5.193 ; CN5.31 59.6,88.71 v1(59.75,88.56) ; v1(54.89,50.36) 54.89,50.06 55.74,49.21 CN5.181 ; U25.AE1 109.8,91.94 109.77,91.91 v1(109.77,91.88) ; v1(57.16,74.94) 57.42,75.21 CN5.85 ; U30.V22 85.29,61.41 v2(85.29,61.53) 84.91,61.91 U30.T23 ; v1(66.31,112.83) 66.69,113.22 PC161.2 ; v1(55.82,75) 55.82,74.54 55.95,74.41 57.21,74.41 57.41,74.21 CN5.89 ; v1(56.33,51.57) 56.33,51.81 57.23,52.71 CN5.167 ; v2(83.75,45.47) 83.98,45.47 U30.AT23 ; v1(114.26,91.89) 114.2,91.95 114.2,92.42 U25.U1 ; v1(56.45,88.91) 56.45,88.51 57.25,87.71 CN5.35 ; v1(57.08,48.35) 57.23,48.21 CN5.185 ; U30.AD1 102.15,55.99 v2(102.29,55.85) ; PR346.1 45.48,16.19 v1(45.03,16.65) ; CN5.77 57.34,77.21 v1(57.08,76.95) ; U25.AA1 112,91.84 v1(111.93,91.77) ; U30.BB1 101.8,41.56 102.15,41.22 v2(102.16,41.22) ; v1(51.75,82.46) 51.75,82.46 CN5.56 ; v1(215.45,11.16) 215.45,11.54 214.68,12.32 HD1.9 ; v2(85.21,47.49) 85.7,47.98 U30.AN22 ; v1(169.94,19.95) 169.99,19.9 C688.2 C689.2 ; U30.L25 82.92,67.38 v2(82.92,67.55) ; v1(52.98,40.95) 52.98,40.84 52.1,39.96 CN5.218 ; CN5.26 51.49,89.96 v1(51.61,90.07) ; U30.G16 90,70.5 v2(90,70.95) ; v1(51.61,91.98) 51.58,91.96 CN5.18 ; v1(55.58,32.34) 55.58,32.23 55.98,31.83 56.52,31.83 57.39,32.71 CN5.247 ; v2(85.91,45.24) 85.51,44.84 U30.AU22 ; v1(172.2,20.05) 172.02,19.87 C690.2 C691.2 ; U30.AV16 89.7,44.79 U30.AU18 89.39,44.79 89.04,44.44 v2(89.04,44.4) 89,44.4 88.59,43.99 U30.AV19 ; U30.P32 v2(78.67,63.99) ; CN5.39 57.19,86.71 v1(57.08,86.6) ; CN5.30 51.46,88.96 51.5,88.92 v1(51.62,88.92) ; U30.W32 v2(78.71,59.99) ; U30.H22 85.51,69.15 v2(85.98,68.67) ; U25.A9 123.36,97.07 123.86,97.07 v1(124,96.92) ; v2(85.02,43.05) 85.04,43.05 U30.AY22 85.7,42.39 v2(85.98,42.39) 86.31,42.39 U30.AY21 ; PU11.19 142.22,45.45 142.35,45.58 142.35,46.06 PC243.2 ; CN5.82 52.01,75.96 52.92,75.04 v1(52.92,74.94) ; U25.G19 119.09,103.13 118.59,103.13 U25.K21 ; U30.AF5 U30.AG5 99.91,52.75 100.1,52.55 v2(100.1,52.45) 100.1,52.19 U30.AJ5 U30.AJ3 ; U30.AF5 100.37,53.99 v2(100.41,53.95) 100.97,53.95 U30.AF3 101.11,53.89 101.7,53.89 U30.AF1 ; U30.AF5 99.91,54.13 100.15,54.38 100.15,54.74 U30.AE5 100.1,55.19 v2(100.1,55.48) 100.1,55.79 U30.AD5 ; U30.A21 86.51,73.6 v2(86.9,73.99) ; v1(53.13,48.35) 53.13,48.33 52.26,47.46 CN5.188 ; v2(100.09,65.45) 99.91,65.64 U30.M5 99.96,66.04 99.96,66.94 U30.L5 99.91,67.04 v2(99.49,67.45) 99.91,67.86 U30.K5 ; CN5.171 59.72,51.71 v1(59.88,51.55) ; v1(51.55,36.96) CN5.230 ; CN5.256 51.18,30.46 52.39,29.25 v1(52.39,28.94) ; v1(52.26,71.77) 52.26,71.61 51.6,70.96 CN5.102 ; D36.1 11.62,17.89 v1(11.87,17.64) ; v1(56.32,36.94) 56.85,37.47 57.2,37.47 57.44,37.71 CN5.227 ; v1(57.04,81.42) 57.06,81.42 57.27,81.21 CN5.61 ; v1(52.98,50.35) 52.98,50.11 52.33,49.46 CN5.180 ; CN5.6 v1(51.61,94.96) ; v1(52.88,35.93) 52.88,35.79 52.04,34.96 CN5.238 ; U25.AW3 102.1,94.16 102.14,94.2 102.14,94.9 102.12,94.92 U25.AW5 102.1,95.18 v1(102.44,95.52) 102.1,95.86 U25.AW7 102.2,96.11 102.2,97.03 U25.AW9 U25.AY9 101.32,97.04 100.79,97.04 U25.BA9 100.7,96.82 v1(100.39,96.51) ; CN5.223 57.38,38.71 57.08,39 v1(57.08,39.03) ; v1(36.36,10.86) 36.36,10.83 36.35,10.82 CN19.15 ; 81.66,59.55 81.55,59.55 U30.W28 U30.V28 81.1,61.02 80.89,61.24 v2(80.89,61.52) 80.87,61.54 80.87,61.72 81.1,61.95 U30.T28 ; CN5.40 51.48,86.46 v1(51.62,86.6) ; U30.AR19 88.46,46.39 88.07,46 v2(88.05,46) ; v1(22.79,7.61) 22.32,8.08 22.32,8.79 22.35,8.81 CN19.71 ; v1(100.33,104.45) U25.BA23 100.77,104.76 101.34,104.76 U25.AY23 101.49,104.74 102.02,104.74 U25.AW23 ; v2(102.54,51.66) 102.42,51.79 102,51.79 U30.AJ1 ; CN5.175 57.3,50.71 v1(56.96,50.37) ; CN5.206 51.24,42.96 51.33,43.04 51.83,43.04 v1(52.39,42.48) 52.39,42.4 51.88,41.9 51.3,41.9 51.24,41.96 CN5.210 ; v2(78.9,70.51) 78.92,70.48 78.92,70.27 U30.G32 ; U30.N5 99.85,64.99 99.55,64.68 v2(99.55,64.49) 99.55,64.35 U30.P5 ; CN5.243 57.27,33.71 56.92,33.36 56.1,33.36 55.8,33.65 v1(55.8,33.9) 55.8,34.04 56.47,34.71 CN5.239 ; U25.J5 118.81,95.53 v1(119.18,95.53) ; v1(51.53,32.29) 51.37,32.46 CN5.248 ; v2(83.85,68.05) 83.85,68.35 83.51,68.69 U30.H25 83.44,68.99 v2(82.98,69.44) 82.51,69.92 U30.G26 82.49,69.99 v2(81.49,70.99) ; CN5.68 51.21,79.46 51.62,79.86 v1(51.75,79.86) ; U30.P1 102.3,63.99 v1(102.55,63.74) ; v1(59.75,36.56) 59.61,36.71 CN5.231 ; U30.AR16 90.3,46.39 U30.AP18 89.41,47.19 v2(89.02,46.8) ; v2(84,71.06) 84.08,71.06 84.45,70.69 U30.F23 ; C683.2 C684.2 C685.2 C686.2 C687.2 ; v2(99.01,43.1) 98.99,43.08 98.91,43.08 98.51,42.67 U30.AY7 U30.AY8 ; v2(84.56,58.55) 84.56,58.34 U30.AA23 ; CN5.81 59.39,76.21 59.75,76.57 v1(59.75,76.95) ; v1(53.78,86.6) 53.78,86.47 52.77,85.46 CN5.44 ; CN5.252 51.78,31.46 52.26,30.97 v1(52.26,30.85) ; VRAM2.K14 141.24,83.45 141.24,84.14 VRAM2.K13 ; HD1.6 213.16,13.82 v1(213.04,13.7) ; v1(48.96,52.46) CN5.168 ; v1(53.27,70.7) 53.25,70.73 52.13,70.73 51.36,69.96 CN5.106 ; U30.P23 84.96,63.99 85.44,63.52 85.45,63.52 v2(85.46,63.5) 85.46,63.39 85.7,63.14 U30.R22 ; v1(100.39,94.35) 100.39,94.61 U25.BA5 ; v1(121.04,116.39) 121.04,116.08 120.81,115.85 120.81,115.02 U25.E41 ; v2(84,43.69) 84.3,43.99 U30.AV23 ; U30.AR26 82.54,45.99 82.94,46.38 v2(82.94,46.58) 82.94,46.62 U30.AP25 ; v2(102.16,41.22) 101.92,40.98 101.92,40.55 103.75,38.72 v1(105.09,38.72) 105.09,38.85 104.65,39.29 104.65,40.03 103.16,41.52 102.45,41.52 v2(102.16,41.22) ; U25.C25 121.9,105.67 121.83,105.6 121.83,105.17 121.9,105.09 U25.C23 121.87,104.79 121.87,103.75 U25.C21 ; CN5.184 51.43,48.46 51.51,48.37 51.7,48.37 51.73,48.35 v1(51.75,48.35) ; v1(71.36,117.82) 71.39,117.84 71.39,118.82 PR145.1 PC145.1 ; U30.AV12 94.56,43.99 v2(95,44.42) 95.36,44.79 U30.AU11 95.7,44.79 U30.AV10 ; CN19.73 v1(21.85,10.91) ; U30.M32 79.2,65.99 v2(78.61,65.99) ; v1(123.94,94.79) 123.8,94.92 U25.A5 ; U25.J39 U25.J40 118.55,114.37 118.55,114.97 U25.J41 118.27,115.02 v1(118.07,115.23) ; U30.K3 100.55,67.99 v2(100.11,68.43) 100.11,68.79 U30.H5 ; CN5.94 51.57,72.96 v1(52.39,73.77) ; v1(100.39,108.7) 100.39,108.43 U25.BA29 100.78,108.19 101.33,108.19 U25.AY29 101.48,108.19 102.03,108.19 U25.AW29 102.39,108.41 v1(102.39,108.63) 102.39,108.93 U25.AW31 ; CN5.2 v1(51.58,95.96) ; v1(118.03,95.56) 117.5,96.09 U25.L7 ; U25.AC3 110.87,93.85 109.83,93.85 U25.AE3 109.66,93.82 v1(109.31,94.18) 108.95,93.82 U25.AG3 108.7,93.84 108.68,93.86 107.63,93.86 107.6,93.84 U25.AJ3 107.25,93.82 v1(106.99,94.07) 106.74,93.82 U25.AL3 106.46,93.86 105.45,93.86 U25.AN3 ; CN19.39 30.35,8.75 30.16,8.56 v1(30.16,8.37) ; v1(51.63,74.94) 51.61,74.94 51.6,74.96 CN5.86 ; U30.AK18 89.71,50.58 90.51,50.58 U30.AL16 ; v1(116.39,91.73) 116.4,91.73 U25.N1 ; v1(104.84,36.18) 104.94,36.08 104.94,32.65 105.28,32.31 105.92,32.31 106.36,31.86 v1(108.52,31.86) 109.15,32.5 109.15,36.33 109.13,36.36 v1(109.1,36.36) ; U25.AW39 101.95,113.62 101.4,114.17 U25.AY40 ; v1(56.32,78.71) 56.32,78.6 56.83,78.09 57.34,78.09 57.45,78.21 CN5.73 ; PC304.2 v1(43.73,14.79) ; v1(51.6,50.34) 51.48,50.46 CN5.176 ; v1(120.86,91.86) 120.8,91.92 U25.E1 ; v1(55.56,45.1) 55.56,45.07 56.43,44.21 CN5.201 ; U30.AY13 93.68,42.42 94.33,42.42 U30.AY12 ; U30.N25 83.31,65.18 v2(82.92,65.56) 82.51,65.98 U30.M26 82.51,66.16 v2(82.14,66.52) ; v1(51.6,81.44) 51.59,81.46 CN5.60 ; CN5.192 v1(51.86,46.46) ; v1(102.42,66.14) 102.26,65.99 U30.M1 101.7,66.09 101.11,66.09 U30.M3 ; CN19.21 34.85,10.62 v1(35.04,10.81) ; U30.AR12 94.58,46.39 95,46.81 v2(95,46.84) ; v2(102.67,60.81) 102.26,60.4 101.49,60.4 U30.V2 101.32,60.4 100.69,60.4 U30.V4 ; U30.AY15 91.69,42.4 v2(92.04,42.4) 92.32,42.4 U30.AY14 ; v2(82.86,48.49) 82.86,48.34 U30.AN26 ; U25.AA3 112.04,93.86 113.08,93.86 113.1,93.84 U25.W3 113.13,93.85 114.17,93.85 U25.U3 114.24,93.86 115.26,93.86 U25.R3 115.51,93.82 v1(115.84,94.14) 116.16,93.82 U25.N3 116.73,93.82 v1(116.93,94.02) 117.12,93.82 U25.L3 117.79,93.82 v1(118.09,94.12) 118.38,93.82 U25.J3 119.01,93.82 v1(119.2,94.02) 119.4,93.82 U25.G3 120.09,93.82 v1(120.25,93.98) 120.4,93.82 U25.E3 U25.E4 121.12,94.84 v1(121.37,94.84) 121.82,94.84 U25.C5 121.9,95.25 v1(121.7,95.45) 121.9,95.65 U25.C7 121.9,96.33 v1(121.69,96.54) 121.9,96.75 U25.C9 121.9,97.52 v1(121.66,97.76) 121.9,98.01 U25.C11 121.9,98.47 v1(121.59,98.78) 121.9,99.09 U25.C13 121.87,99.35 121.87,100.39 U25.C15 121.87,100.45 121.87,101.49 U25.C17 121.9,101.71 v1(121.52,102.09) 121.9,102.47 U25.C19 ; U30.A12 94.39,73.41 94.39,73.68 94.04,74.03 v2(94.04,74.15) ; v1(55.67,84.61) 55.67,85.06 56.32,85.71 CN5.43 ; v1(54.4,84.61) 54.4,84.46 55.16,83.71 CN5.51 ; U30.AB4 U30.AB2 101.52,57.38 v2(102.27,57.38) ; v1(51.9,33.9) 51.46,33.46 CN5.244 ; CN5.19 v1(57.08,91.71) ; U25.AG39 U25.AG40 108.65,114.38 108.65,114.97 U25.AG41 108.7,115.12 108.39,115.43 v1(108.27,115.43) ; v1(103.95,110.86) 103.95,110.97 U25.AR35 104.3,111.46 v1(103.76,112) ; v1(59.86,70.71) CN5.103 ; v2(102.19,50.37) 102.14,50.37 102.11,50.34 102.09,50.34 101.8,50.06 U30.AL1 ; CN5.9 57.07,94.21 v1(56.96,94.09) ; U30.C10 U30.E10 ; U30.T32 v2(78.64,61.99) ; CN13.5 v1(58.45,19.67) ; U25.BA17 100.33,101.52 v1(100.11,101.31) ; CN5.65 59.66,80.21 v1(60.01,79.86) ; Q40.1 195.25,17.37 195.01,17.13 194.3,17.13 194.12,16.95 194.12,15.83 194.6,15.35 195.24,15.35 195.49,15.1 v1(195.49,14.72) ; U30.T1 U30.T3 ; v2(102.29,58.9) 102.16,58.9 102.07,58.99 U30.Y1 101.69,59.11 101.12,59.11 U30.Y3 ; v1(56.45,79.86) 56.45,79.62 56.86,79.21 CN5.69 ; v2(83.01,43) 83.42,42.59 U30.AY25
  BOTTOM w0.279: v2(102.3,69.71) 102.17,69.71 101.89,69.99 U30.G1 ; U30.C3 U30.A3
  BOTTOM w0.3: U30.A23 v2(84.51,74.65) ; v2(86.41,39.98) 86.5,40.08 86.5,40.69 U30.BD21 ; U30.K32 78.64,67.99 v2(78.61,67.96) ; v2(78.29,43.65) 78.31,43.66 78.54,43.66 78.87,43.99 U30.AV32 ; 87.1,67.17 87.13,67.17 U30.L20 87.31,66.79 U30.M21 87.1,65.39 87.59,65.39 v2(88.11,64.87) ; v2(88.53,74.7) 88.53,73.32 U30.A19 ; U30.C32 79.21,72.65 79.03,72.82 v2(78.98,72.82) ; v2(84.41,39.97) 84.51,40.06 U30.BD23 ; U30.A30 80.12,73.31 80.12,73.73 80.09,73.76 v2(80.09,73.79) ; U30.A26 82.36,73.44 v2(82.36,73.77) ; U30.BD26 82.07,40.69 v2(81.97,40.59) ; U30.AY20 87.31,42.39 v2(87.02,42.39) 86.7,42.39 U30.AY21 ; U30.R28 80.95,62.84 80.95,62.14 U30.T28 ; U30.E27 81.51,71.01 81.49,70.99 v2(81.49,70.99) U30.F28 80.83,70.81 80.83,70.27 U30.G28 81.1,69.85 80.93,69.67 v2(80.93,69.49) 80.93,69.17 U30.H28 81.1,68.83 81.02,68.75 81.02,68.07 U30.K28 80.96,67.85 80.96,67.13 U30.L28 80.91,66.79 80.91,66.19 U30.M28 80.91,65.79 80.91,65.41 80.56,65.06 v2(80.56,64.99) U30.N28 ; v2(79.77,40.33) 79.77,40.35 79.82,40.39 79.82,40.4 U30.BD30 ; U30.H20 87.51,69.27 87,69.77 v2(87,70.28) ; v2(78.67,41.3) 78.89,41.3 79.18,41.59 U30.BB32
  BOTTOM w0.305: v2(88.1,63.39) U30.R19 v2(88.91,62.59) U30.T18 U30.U17 90.1,61.36 v2(90.45,61.02) 90.88,60.59 U30.V16 U30.W15 91.73,59.79 v2(92.16,59.36) 92.16,59.31 92.48,58.99 U30.Y14 U30.AA13 ; CN17.7 133.85,16.96 133.42,16.53 133.42,16.25 v1(133.28,16.12) ; VRAM1.R12 135.58,114.55 v1(135.2,114.16) VRAM1.R11 ; v1(120.07,96.54) 120.07,96.54 120.07,96.49 U25.G7 ; v1(138.36,117.59) 138.36,117.37 VRAM1.N14 ; v1(139.38,94.31) 139.58,94.11 VRAM2.H1 VRAM2.H2 ; CN8.14 212.24,36.4 v1(212.15,36.31) ; U25.U5 113.86,94.98 v1(113.68,94.98) ; CN19.75 21.35,10.3 v1(20.89,10.76) 20.89,10.4 20.25,9.76 CN19.77 20.66,8.44 v1(21.75,8.44) ; U30.AD5 100.1,56.19 v2(100.1,56.49) 100.1,56.79 U30.AC5 ; U25.AN35 105.93,110.8 ; 105.93,110.8 106.45,111.32 U25.AL35 ; 105.93,110.8 105.93,110.3 U25.AL32 ; VRAM2.C12 135.18,85.4 v1(135.18,85.43) 135.54,85.79 VRAM2.C11 ; v1(143.36,82.58) 143.29,82.64 143.29,83.1 VRAM2.N14 ; CN17.17 v1(128.85,16.69) ; VRAM2.M5 142.78,90.48 v1(143.21,90.05) ; U25.L35 117.9,111.72 v1(118.07,111.72) 118.2,111.72 U25.J37 ; v2(93.68,54.59) 93.68,54.62 U30.AE13 U30.AD14 92.11,56.19 92.1,56.19 U30.AC15 U30.AB16 90.11,58.19 U30.AA17 90.08,58.19 89.31,58.96 U30.Y18 v2(88.91,59.39) U30.W19 88.51,59.84 v2(88.1,60.24) 87.76,60.59 U30.V20 ; v2(87,70.28) 87,70.88 U30.E20 ; VRAM1.N12 137.16,114.58 v1(136.76,114.98) ; v1(118.44,104.21) 118,103.77 U25.K21 ; U30.N5 100.09,65.18 v2(100.09,65.45) ; CN11.39 184.39,21.63 184.49,21.73 v1(184.97,21.73) 184.97,21.2 184.47,20.69 184.47,20.43 184.16,20.13 CN11.45 ; VRAM1.C4 v1(145.58,108.58) ; v1(135.81,94.4) 135.81,94.02 VRAM2.C1 ; U30.AV1 101.85,43.94 v2(102.31,43.94) ; U25.K40 118.05,113.35 v1(118.04,113.35) ; U30.AG13 93.3,53.39 v2(92.91,53.79) U30.AF14 U30.AE15 U30.AD16 90.9,55.79 U30.AC17 U30.AB18 89.2,57.39 v2(88.8,57.79) 88.51,58.08 U30.AA19 88.51,58.27 v2(88.16,58.62) 88.12,58.62 87.74,58.99 U30.Y20 ; VRAM2.E14 137.18,82.83 v1(137.34,82.67) ; U25.AY41 101.3,114.72 101.4,114.62 U25.AY40 100.8,114.32 U25.BA40 100.7,114.99 v1(100.65,115.05) ; v2(98.1,64.6) U30.N8 ; VRAM1.G5 141.98,108.98 v1(141.58,108.58) ; VRAM1.T5 134.78,108.98 135.18,108.58 v1(135.2,108.58) 135.2,108.55 135.57,108.18 VRAM1.R4 ; VRAM1.C3 v1(145.58,107.78) ; U30.BD7 98.51,40.19 v2(98.58,40.12) ; v1(116.93,111.75) 116.9,111.75 116.53,112.12 U25.N37 ; U30.AN7 98.35,48.14 98.35,48.36 v2(98.1,48.61) 97.72,48.99 U30.AM8 ; v1(79.07,113) 78.6,112.52 PC162.1 ; v1(135.9,116.63) 135.9,116.47 135.6,116.18 VRAM1.R14 ; v1(137.57,112.53) 137.57,112.63 137.92,112.98 VRAM1.M10 ; v1(143.35,104.9) 143.58,105.13 VRAM1.E1 ; v1(111.56,94.88) U25.AA5 112.42,95.74 v1(112.59,95.74) 112.72,95.74 U25.W7 ; U30.N13 93.31,64.86 v2(93.05,65.11) ; v2(129.39,27.75) 129.5,27.75 129.53,27.78 PC285.1 ; VRAM2.U1 v1(147.76,93.79) ; v1(114.79,95.87) 115.05,95.87 U25.R7 ; U30.AE19 88.51,54.89 v2(88.8,54.59) 89.2,54.19 U30.AF18 89.34,54.19 89.68,53.85 v2(89.72,53.85) 89.73,53.84 89.73,53.8 90.1,53.43 U30.AG17 U30.AH16 91.2,52.29 v2(91.2,52.19) 91.6,51.79 U30.AJ15 U30.AK14 ; U30.AE19 U30.AF20 ; U30.AE19 U30.AD20 87.71,55.79 U30.AC19 ; v1(184.47,28.03) 184.36,28.13 CN11.13 ; U30.AV7 98.51,44.12 v2(98.15,44.47) 97.63,44.99 U30.AU8 ; v2(100.11,68.43) 100.11,68.19 U30.K5 ; U25.E21 120.04,104.09 v1(120.04,104.32) 119.98,104.32 119.6,104.7 U25.G23 ; v1(136.52,87.22) 136.38,87.08 VRAM2.D10 ; U30.AC19 88.51,56.56 88.8,56.27 v2(88.8,56.19) 89.2,55.79 U30.AD18 U30.AE17 v2(90.49,54.6) U30.AF16 91.25,53.84 91.28,53.84 91.7,53.42 U30.AG15 U30.AH14 v2(92.91,52.19) U30.AJ13 93.63,51.47 v2(93.68,51.47) ; U30.AC19 U30.AB20 87.69,57.39 87.21,57.87 87.21,58.51 v2(87.34,58.63) ; v2(94.97,58.53) 94.97,58.66 U30.Y11 ; U25.E25 120.41,105.92 120.69,105.64 v1(120.69,105.4) ; VRAM2.C3 v1(135.98,92.59) ; U25.AG7 108.22,95.64 v1(108.14,95.64) ; v2(83.7,60.55) 83.31,60.94 U30.V25 ; VRAM1.A3 146.91,107.38 v1(147.37,106.92) ; CN8.24 214.27,31.4 v1(214.44,31.23) ; v1(144.77,114.19) 145.18,113.78 VRAM1.C11 ; v1(52.32,106.29) 52.22,106.39 CN2.18 ; VRAM1.K13 VRAM1.K14 139.58,116.25 v1(139.2,116.63) ; U30.E20 87.59,71.48 88.42,71.48 U30.E19 ; U30.E20 U30.E21 86.43,71.39 v2(86.03,70.99) ; CN11.69 182.23,14.13 v1(182.03,14.34) ; U30.AG8 98.2,52.5 v2(98.2,52.45) ; v1(133.44,114.16) 133.44,114.16 133.87,114.58 VRAM1.U12 ; U30.P5 U30.R5 99.76,62.85 v2(99.76,62.52) 99.91,62.38 U30.T5 ; VRAM2.M10 142.35,87.02 v1(142.34,87.02) 142.29,87.02 141.98,86.72 VRAM2.L10 ; v2(87.26,51.24) 87.51,50.99 U30.AK20 U30.AJ19 87.71,52.59 U30.AH20 ; v1(144.78,91.79) VRAM2.R3 v1(145.58,91.79) ; v1(106.11,95.73) 105.8,95.73 U25.AN7 105.19,96.12 v1(104.92,96.39) 104.65,96.12 U25.AR7 103.87,96.55 v1(103.87,96.58) 103.6,96.85 U25.AU9 ; v1(217.36,32.37) 217.36,33.01 215.47,34.9 CN8.17 ; U25.AN39 105.14,113.62 v1(104.81,113.3) 104.63,113.3 U25.AR39 ; U25.AN39 105.6,113.62 v1(105.93,113.3) 106.18,113.3 U25.AL39 106.55,113.62 106.91,113.27 v1(107.05,113.27) 107.28,113.27 107.6,113.6 U25.AJ39 107.93,113.3 v1(108.11,113.3) 108.38,113.3 U25.AG39 109.03,113.3 v1(109.23,113.3) 109.48,113.3 U25.AE39 110.05,113.37 v1(110.35,113.37) 110.65,113.37 U25.AC39 ; U25.AN39 U25.AN40 ; U30.BD14 92.51,40.14 92.41,40.04 v2(92.41,40.03) ; CN2.9 47.72,110.31 v1(47.18,110.86) ; v1(137.4,94.47) 137.18,94.24 137.18,93.79 VRAM2.E1 ; v1(134.3,82.69) 134.3,83.07 133.98,83.39 VRAM2.A14 ; v1(214.44,32.37) 214.41,32.4 CN8.22 ; U30.J19 87.71,69.19 U30.H20 ; v2(102.29,61.9) 101.89,61.9 U30.T1 ; VRAM2.C14 135.58,83.02 v1(135.9,82.69) ; U30.AH20 U30.AG19 ; U30.AH20 87.29,53 v2(87.24,53) ; U30.AG19 87.71,54.19 U30.AF20 ; U30.AG19 88.51,53.29 v2(88.8,52.99) 89.2,52.59 U30.AH18 89.34,52.59 89.7,52.23 89.7,52.22 89.72,52.2 v2(89.72,52.19) 89.74,52.19 90.1,51.83 U30.AJ17 U30.AK16 90.91,50.96 v2(91.24,50.63) ; v1(147.28,105.16) 147.28,105.28 VRAM1.A1 ; U25.AY17 U25.AW17 102.1,101.27 102.42,100.95 v1(102.42,100.85) 102.42,100.74 U25.AW15 102.36,100.16 v1(102.36,99.85) ; VRAM1.N1 137.18,105.78 v1(136.78,105.38) ; v2(96.61,40) 96.51,40.11 U30.BD10 ; v2(94.6,40.05) 94.6,40.08 94.51,40.17 U30.BD12 ; VRAM1.L10 138.5,112.7 v1(138.5,112.53) ; U30.AU15 91.39,44.79 v2(90.95,44.35) 90.86,44.35 U30.AV16 ; PC298.1 47.05,16.98 47.24,16.8 v1(47.24,16.72) 47.39,16.56 PC305.1 ; CN17.4 135.35,16.78 135.12,16.55 v1(135.12,15.73) ; U30.AY14 93.02,42.59 ; 93.02,42.59 U30.AY13 ; 93.02,42.59 93.02,43.54 92.56,43.99 U30.AV14 ; U30.AF20 87.29,54.6 v2(87.22,54.6) ; VRAM1.E12 143.22,114.94 v1(143.18,114.94) ; U25.G11 119.6,98.13 119.89,97.85 v1(119.89,97.69) 119.89,97.64 U25.E9 ; U25.G15 119.6,100.42 119.93,100.09 v1(119.93,99.84) 120.4,99.36 U25.E13 ; v1(103.16,108.62) 103.6,108.18 U25.AU29 ; U30.N15 91.7,64.56 92.1,64.16 v2(92.16,64.16) 92.51,63.82 U30.P14 92.53,63.79 92.93,63.39 v2(92.96,63.39) 92.96,63.36 93.31,63.02 U30.R13 ; v2(98.86,45.49) 98.86,45.63 U30.AR7 98.16,46.33 98.16,46.53 U30.AP8 ; v1(90.53,74.03) 90.53,73.32 U30.A16 ; U30.AA5 99.91,58.21 99.77,58.34 v2(99.77,58.52) 99.77,58.7 99.91,58.83 U30.Y5 100.03,59.12 100.03,59.65 99.91,59.78 U30.W5 U30.V5 ; CN11.75 183.76,12.63 184,12.39 CN11.77 ; CN2.15 50.72,107.69 50.61,107.81 49.41,107.81 49.22,107.62 CN2.12 v1(49.22,106.08) ; VRAM2.A12 v1(133.53,85.45) ; VRAM1.K1 139.98,105.38 v1(139.98,105.19) ; v2(96.54,48.42) U30.AN10 ; VRAM2.K14 141.18,83.08 v1(140.88,82.78) ; U30.AY6 99.61,42.38 v2(100.07,42.38) 100.07,42.74 100.01,42.8 U30.AW5 100.01,43.44 v2(100.05,43.48) 99.91,43.63 U30.AV5 ; v1(133.6,94.33) 133.98,93.96 VRAM2.A1 ; v2(87.05,63.91) 87.59,63.91 U30.P20 ; v2(102.37,48.31) 102.13,48.31 U30.AN1 ; VRAM2.F10 137.69,86.88 v1(137.69,87.1) ; U25.AW19 102.1,102.89 v1(102.37,103.16) 102.1,103.43 U25.AW21 ; v1(118.04,113.35) 117.78,113.35 U25.L39 117.23,113.35 v1(116.95,113.35) 116.68,113.35 U25.N39 116.15,113.37 v1(115.8,113.37) 115.55,113.37 U25.R39 115.25,113.62 115.02,113.39 v1(114.75,113.39) 114.41,113.39 114.2,113.6 U25.U39 ; v1(118.04,113.35) 118.33,113.35 U25.J39 118.88,113.35 v1(119.11,113.35) 119.43,113.35 U25.G39 119.95,113.37 v1(120.25,113.37) 120.51,113.62 U25.E39 ; v2(94.88,54.45) 95.31,54.87 U30.AE11 ; v2(97.21,61.46) 97.23,61.46 U30.V8 ; U25.G35 119.3,111.32 v1(119.14,111.16) ; v1(146.39,83.78) VRAM2.U14 147.21,82.97 v1(147.21,82.88) ; CN11.57 184.29,17.13 v1(184.42,17.26) ; VRAM1.D10 144.38,112.83 143.98,112.43 v1(143.98,112.29) ; U30.E19 U30.F19 ; U30.E19 U30.E18 89.56,71.39 v2(90,70.95) 90.05,70.99 90.11,70.99 U30.E16 90.63,71.39 v2(91.02,71) 91.02,71.13 91.28,71.39 U30.E15 91.83,71.39 v2(92.03,71.2) 92.22,71.39 U30.E14 U30.E13 93.63,71.39 v2(94.02,71) 94.4,71.39 U30.E12 U30.E11 95.72,71.39 96.07,71.04 v2(96.09,71.04) 96.44,71.39 U30.E10 96.63,71.39 v2(96.95,71.07) 97.28,71.39 U30.E8 ; v2(100.52,73.77) 100.52,73.68 U30.A3 ; VRAM2.N12 v1(143.98,84.59) ; v1(145.57,106.19) 145.18,105.79 VRAM1.C1 145.18,105.78 v1(144.78,106.18) ; CN17.18 128.35,16.9 128.2,16.74 v1(128.2,16.69) ; v1(143.98,91.79) VRAM2.N3 ; VRAM2.P10 v1(144.78,86.19) VRAM2.R11 ; VRAM2.G10 138.78,86.77 139,86.98 v1(139,87.1) ; U30.AG11 95.31,53.14 v2(94.9,53.54) ; v2(87.97,48.26) 87.96,48.27 87.96,49.13 U30.AM20 ; U25.AC7 110.9,96.12 110.42,95.64 v1(110.35,95.64) 110.12,95.64 109.8,95.33 U25.AE5 ; v1(45.03,16.65) 45.69,16.65 45.8,16.54 45.84,16.54 46.43,15.94 PC306.1 ; U30.L13 93.51,66.76 93.06,66.31 v2(93.04,66.31) ; C634.2 94.9,33.51 v2(95.29,33.9) 95.68,33.51 C635.2 ; v2(89.72,64.9) 90.03,64.59 U30.N17 ; v2(92.01,67.32) 92.01,67.3 U30.L15 90.71,67.59 U30.K16 90.2,67.28 v2(90,67.28) ; v1(135.2,107.78) 135.2,107.76 VRAM1.R3 ; v1(184.47,23.16) 184.39,23.16 184.36,23.13 CN11.33 ; v1(137.98,90.06) 137.98,90.06 VRAM2.F5 137.58,90.99 ; VRAM2.R12 v1(144.78,84.59) ; VRAM1.C14 v1(145.58,115.78) ; VRAM2.U12 v1(146.38,84.59) ; v1(44.72,106.29) CN2.3 44.72,107.64 44.89,107.81 46.08,107.81 46.22,107.67 CN2.6 ; v1(134.13,104.97) 134.13,105.27 133.98,105.42 VRAM1.U1 ; U30.AY10 96.51,42.56 96.31,42.37 v2(96.07,42.37) 95.73,42.37 U30.AY11 95.31,42.39 94.7,42.39 U30.AY12 ; v1(136.8,15.73) 136.85,15.78 CN17.1 ; VRAM1.C12 v1(144.78,114.98) ; VRAM1.H1 v1(141.58,106.18) 141.18,106.58 VRAM1.H2 ; v2(102.36,45.72) 102.09,45.99 U30.AR1 ; U30.N11 94.95,64.63 v2(94.95,64.49) ; U25.AW25 102.27,106.09 v1(102.27,106.51) 102.27,106.85 U25.AW27 ; v1(145.08,82.86) 145.18,82.96 VRAM2.R14 ; U30.BD16 90.51,40.03 v2(90.45,39.98) ; U30.BD19 88.51,40.11 v2(88.58,40.03) ; v1(135.17,90.21) 134.78,90.59 VRAM2.B5 ; U30.A14 92.8,73.29 v2(93.03,73.52) ; PC278.1 v2(129.39,28.99) ; v1(137.55,108.58) 137.58,108.58 137.98,108.98 VRAM1.M5 ; VRAM2.R1 v1(144.8,94.17) ; VRAM1.E3 v1(143.18,107.78) ; U25.G31 119.59,109.22 119.52,109.3 v1(119.52,109.79) 119.52,109.92 119.01,110.43 118.7,110.43 U25.J34 ; VRAM2.C4 v1(135.18,90.99) ; v1(135.85,105.12) 135.58,105.39 VRAM1.R1 ; v1(136.06,112.52) 136.06,112.66 VRAM1.P10 ; v2(94.91,62.35) 94.91,62.59 U30.R11 ; VRAM1.G10 141.98,112.5 v1(141.59,112.12) ; U30.AC8 98.21,56.49 v2(98.3,56.49) ; v2(90,67.28) 90,68.76 v2(90.05,68.81) 89.86,68.81 89.51,69.16 U30.H18 89.51,69.21 89.86,69.57 v2(90.01,69.57) 90.43,69.99 U30.G16 ; v2(90,67.28) U30.L18 ; U30.AL16 91.24,49.85 v2(91.24,49.81) 91.29,49.81 U30.AM15 ; VRAM1.B10 145.58,112.58 v1(145.58,112.44) ; v1(104.33,109.82) 104.4,109.74 U25.AR31 ; v1(121.7,112.05) 121.7,111.62 U25.C35 121.88,111.42 121.8,111.35 121.8,110.4 121.88,110.32 U25.C33 121.9,110.07 v1(121.6,109.76) 121.9,109.46 U25.C31 121.9,109 v1(121.58,108.67) 121.9,108.34 U25.C29 121.9,107.86 v1(121.63,107.58) 121.9,107.3 U25.C27 121.9,106.77 v1(121.63,106.49) 121.9,106.21 U25.C25 ; U25.AL10 106.51,97.73 107.6,97.73 U25.AJ10 107.94,98.06 v1(108.14,98.06) ; v1(8.47,16.6) 8.95,16.12 RV3.8 RV3.3 v1(11.36,16.12) ; v1(139.51,82.66) 139.58,82.73 VRAM2.H14 139.59,83.39 139.71,83.52 139.71,84.07 139.59,84.19 VRAM2.H13 ; v1(140.78,115.01) 140.8,115.01 VRAM1.H13 VRAM1.H14 ; v1(142.79,109.57) 142.78,109.56 VRAM1.F5 ; v1(142.18,111.84) 142.78,112.44 VRAM1.F10 ; U30.F5 v2(100.49,70.99) ; U30.AU5 99.91,45.29 v2(100.08,45.47) 99.91,45.64 U30.AR5 100.1,46.19 100.1,46.66 99.91,46.86 U30.AP5 U30.AN5 99.91,48.14 100.12,48.35 v2(100.12,48.5) 100.12,48.78 U30.AM5 ; v1(141.93,90.04) 141.93,90.54 VRAM2.L5 ; v1(214.82,11.16) 214.48,10.82 HD1.12 ; U30.AY16 90.45,42.64 89.56,42.64 U30.AY18 89.28,42.37 88.73,42.37 U30.AY19 88.31,42.39 87.7,42.39 U30.AY20 ; U30.W13 U30.V14 92.51,60.64 v2(92.18,60.96) 91.76,61.39 U30.U15 U30.T16 90.48,62.61 v2(90.43,62.61) 90.43,62.66 U30.R17 89.7,63.39 U30.P18 v2(88.91,64.19) ; U30.T20 87.71,62.19 v2(88.1,61.79) U30.U19 88.51,61.36 v2(88.88,60.99) 89.28,60.59 U30.V18 U30.W17 v2(90.51,59.39) U30.Y16 U30.AA15 92.5,57.39 U30.AB14 U30.AC13 93.68,56.22 v2(93.68,56.19) ; v1(185,20.31) 184.97,20.28 184.97,19.29 184.31,18.63 CN11.51 ; U30.U13 U30.T14 92.51,62.22 v2(92.16,62.56) 91.73,62.99 U30.R15 U30.P16 ; U25.AJ1 107.6,92.04 v1(107.76,91.88) ; 87.1,67.17 86.68,67.59 U30.K21 ; CN11.19 184.19,26.63 v1(184.42,26.4) ; VRAM2.T5 v1(146.38,90.19) ; U25.N5 116.71,95.32 v1(117.11,95.72) ; VRAM2.K2 v1(140.78,93.39) ; VRAM1.T10 134.78,112.98 134.42,112.62 v1(134.42,112.52) ; VRAM1.E14 v1(143.58,117.08) ; VRAM2.U3 v1(147.77,92.19) ; CN2.21 v1(53.72,106.29) ; VRAM1.K2 v1(139.98,106.18) ; v1(111.49,42.27) 111.22,42.27 110.78,42.71 C615.2 111.56,43.67 C611.1 ; U30.V11 95.31,61.03 v2(94.95,61.39) ; CN11.1 v1(184.41,31.13) ; U30.H13 93.98,68.72 v2(94.02,68.72) ; VRAM2.N1 v1(143.98,93.39) ; v1(133.55,107.82) VRAM1.U3 ; VRAM2.R4 v1(145.58,90.99) ; v1(146.38,108.58) 145.98,108.98 VRAM1.B5 ; VRAM1.A12 v1(147.18,114.18) ; VRAM2.T10 v1(146.4,87.02) ; v1(138.42,108.58) 138.42,108.62 VRAM1.L5 ; v1(73.98,24.5) 73.98,24.32 74.46,23.84 C662.2 ; v1(189.55,26.88) CN11.18 ; VRAM2.G5 v1(139.18,90.19) ; v1(140.81,94.32) 141.18,93.95 VRAM2.K1 ; v2(98.99,71.12) 98.72,71.39 U30.E7 ; U25.AW9 102.33,97.35 v1(102.33,97.68) ; v1(133.58,92.59) VRAM2.A3
  BOTTOM w0.33: U30.AL10 96.61,50.5 98,50.5 v2(98.1,50.4) ; U30.AL10 96.1,49.79 U30.AM11 ; U30.AL10 96.1,50.19 U30.AK11
  BOTTOM w0.356: v1(143.65,36.47) PC261.1 PC264.2 ; U30.H18 89,69.69 89,70.21 88.52,70.69 U30.F19 ; PC249.2 145.33,40.52 v1(145.09,40.76) ; PC262.2 146.53,36.48 v1(146.9,36.11)
  BOTTOM w0.381: PR215.2 90.1,88.03 v1(90.45,88.38) 90.45,88.11 PQ22.1 ; v1(93.97,94.47) 93.04,93.55 PQ18.1 ; v1(114.74,111.66) 114.66,111.66 U25.U37 ; R501.2 C547.2 96.32,106.95 v1(95.97,107.3) ; v1(197.57,24.53) 197.29,24.81 197.29,25 C653.1 196.91,25.38 196.91,26.03 C652.2 ; CN14.5 122.11,19.11 v1(122.11,19.7) ; C541.2 100.91,118.85 100.4,119.36 v1(100.4,119.62) 100.1,119.92 99.02,119.92 97.99,118.89 R492.1 ; VRAM1.U14 133.79,116.37 133.79,116.38 v1(133.54,116.63) ; v1(12.89,77.84) 13.14,78.09 U27.3 ; C622.2 v1(105.09,38.72) ; C584.2 96.23,78.85 v1(96.48,78.6) ; SW1.5 61.82,100.37 v1(61.61,100.37) ; v1(132.4,122.29) 132.58,122.47 PQ13.1 ; v1(57.71,118.22) R488.1 57.71,119.08 58.13,119.49 58.13,120.15 58.73,120.75 C539.2 ; v2(89.09,29.32) 89.09,28.94 v1(88.72,28.57) 88.07,27.93 R663.1 ; C577.1 86.43,81.77 v1(86.17,82.03) ; PU9.8 110.55,87.36 v1(110.93,86.98) ; PR311.2 112.97,38.2 112.28,37.5 PU12.2 112.28,36.28 112.58,35.98 v1(112.91,35.98) ; v1(113.85,82.41) 113.85,82.16 114.05,81.96 PR228.2 ; v1(147.44,116.72) 147.33,116.72 146.8,116.18 VRAM1.A14 ; v1(13.9,24.62) 14.41,24.12 U36.2 ; U25.K25 118,106 v1(118.42,106.42) ; v1(163.94,25.23) 163.41,25.23 163.26,25.39 U37.4 ; v1(102.68,121.78) 102.67,121.79 C535.2 ; CN16.2 174,17.97 174.31,18.27 v1(174.31,18.43) ; RV5.2 14.79,83.55 v1(14.54,83.81) ; Y4.4 108.1,36 v1(107.91,36.18) ; v1(107.12,78.35) 107.27,78.49 PQ28.1 ; v1(62.16,117.51) 62.16,118.48 61.94,118.7 U23.3 ; C588.2 v1(91.87,76.44) ; U25.R35 115.67,110.96 v1(115.84,110.96) ; C546.2 97.34,109.33 v1(97.85,109.84) 97.34,110.35 R500.2 ; C585.2 v1(91.87,78.73) C583.2 ; v1(13.69,6.08) 13.67,6.09 CN20.2 ; v1(105.95,41.59) 105.59,41.23 C619.2 ; v1(196.99,22.67) 196.99,23.32 C659.1 ; v1(135.72,120.18) 136.18,120.64 R457.1 ; U34.4 166.94,28.18 167.37,27.75 v1(167.37,27.35) ; v1(12.91,74.79) 12.99,74.87 U29.3 ; C665.2 207.93,22.59 v1(208.09,22.59) ; U25.R32 114.98,110.04 v1(114.77,110.04) 114.45,109.72 U25.U32 ; v1(62.55,94.22) 63.17,94.22 C567.2 ; v1(11.54,12.23) 11.24,12.53 D38.1 ; v1(139.03,98.28) 138.99,98.24 C566.1 ; v1(115.44,98.29) U25.R11 ; PC241.2 135.11,47.27 v1(135.28,47.1) 135.44,47.27 PC242.2 ; U25.AN35 104.89,110.81 104,110.81 v1(103.95,110.86) ; U25.L23 117.28,104.44 117.28,104.28 v1(117.36,104.2) ; v1(113.6,98.28) 113.5,98.28 113.05,98.72 U25.W11 ; C586.2 96.46,76.95 v1(96.58,76.95) ; R713.1 13.02,14.64 v1(12.71,14.34) ; U25.AA10 v1(111.48,98.25) U25.AC11 ; C692.1 D35.1 9.34,19.17 v1(8.95,18.78) ; v1(149.69,78.35) 149.5,78.15 PC197.2 ; C660.1 v1(10.87,22.34) ; U25.E17 120.69,101.23 v1(120.69,100.95) ; PC270.2 113.23,34.22 113.23,34.22 PU12.4 113.23,35.19 113.59,35.55 v1(114.3,35.55) ; PC142.2 63.05,121.47 v1(63.38,121.8) ; v1(116.77,87.87) 116.77,87.37 PC185.2 ; U25.E29 120.4,107.96 v1(120.08,107.63) 119.6,107.16 U25.G27 ; U25.AJ35 107.21,110.93 v1(106.93,110.93) 106.9,110.93 U25.AL35 ; v1(144.74,101.22) 144.48,101.49 C562.1 ; U25.AA32 111.52,109.24 v1(111.52,109.08) ; U30.AV14 93.31,44.79 U30.AU13 ; v1(110.35,111.09) 110.11,111.32 U25.AE35 ; U30.AK8 98.1,50.6 v2(98.1,50.4) U30.AL7 ; SW1.6 v1(67.35,101.95) ; v1(106.11,95.73) 106.12,95.73 106.5,96.11 U25.AL7 ; v1(126.1,22.85) 126.1,23.94 125.83,24.2 CN10.30 ; C630.2 104.44,35.44 104.07,35.8 v2(104.07,35.9) ; PC134.2 v1(92.52,125.22) ; C612.1 C616.1 v2(104.96,42.53) ; v1(13.02,80.11) C579.2 RV6.2 ; PR240.2 110.21,72.92 110.04,72.76 v1(110.02,72.76) ; v1(60.39,97.65) 61.02,98.28 62.52,98.28 SW1.2 ; U25.AE10 109.84,97.72 110.3,97.27 110.3,96.73 U25.AC7 ; CN7.7 119.31,47.36 119.57,47.1 120.2,47.1 120.46,47.36 121.6,47.36 ; v1(106.1,88.12) PR220.2 ; v1(131.25,120.26) 130.55,119.55 PQ15.1 ; U25.AG11 U25.AJ11 107.84,98.72 v1(107.48,98.36) 107.12,98.72 U25.AL11 ; U30.H18 89.3,69.19 U30.J19 ; 117.92,49.9 119.57,49.9 120.84,48.63 v1(121.47,48.63) ; U30.M23 85.39,65.51 v2(85.45,65.51) 85.45,65.25 U30.N22 ; PQ12.1 138.04,123.52 137.66,123.14 v1(134.55,123.14) ; U25.AR11 104.4,98.36 v1(104.84,98.79) 104.84,98.96 U25.AP13 ; v1(141.7,45.65) 142.3,46.24 PC243.2 ; R496.2 97.47,113.52 97.72,113.78 v1(97.72,114.03) 97.72,114.16 97.34,114.54 C543.2 ; v1(116.62,102.2) 116.62,102.34 U25.L19 ; C677.2 201.99,19.42 202.09,19.32 v1(202.09,19.29) ; C655.2 209.07,24.25 v1(209.48,23.84) ; U25.L11 117,98.39 v1(116.77,98.16) ; v1(66.48,92.57) U26.2 ; v1(166.74,21.88) 166.52,22.09 C667.2 ; C571.1 129.97,88.64 131.03,87.58 v1(131.92,87.58) ; v1(198.08,17.26) 198.08,17.73 198.09,17.74 C699.1 ; v1(119.75,41.76) 119.75,41.31 119.44,41.01 CN7.17 ; CN2.42 64.92,111.02 63.43,112.51 v1(63.43,112.89) ; v1(88.83,31.1) 88.83,31.85 C638.2 ; v1(96.12,100.82) 96.32,101.02 C563.2 R517.2 ; v1(101.41,120.89) 101.92,121.41 C540.2 ; PC132.1 69.25,125.5 v1(69.33,125.58) ; U31.2 v1(16.83,44.18) ; SW1.1 64.07,104 64.45,103.62 v1(64.96,103.62) ; v1(111.44,16.24) 111.62,16.42 PJ18.9 ; C582.1 140.87,79.09 v1(140.47,79.49) 140.08,79.09 R555.1 ; v1(21.91,19.8) 21.78,19.8 21.39,20.19 C682.2 ; R717.2 v1(212.41,13.7) ; C576.1 83.49,81.02 v1(83.88,80.63) 83.64,80.39 C580.1 ; v1(34.96,117.74) 33.9,116.68 CN1.1 ; v1(10.22,22.08) 10.22,21.83 10,21.61 EC3.2 ; C578.2 v1(91.87,80.02) ; R511.2 C556.1 v1(56.2,102.86) ; R527.2 v1(66.47,90.66) ; v1(104.84,36.18) 104.83,36.18 104.7,36.31 C624.1 ; v1(206.97,14.21) 206.96,14.2 CN18.1 ; U30.AC22 85.7,56.77 v2(86.08,56.39) ; v1(192.17,31.99) 192.73,31.99 C644.1 ; CN4.23 12.61,83.45 13.26,82.8 C574.2 ; v1(73.98,24.5) 73.86,24.38 C661.2 ; CN14.6 115,16.63 v1(114.29,15.91) ; PJ18.10 92.35,15.18 v1(92.01,14.85) ; C558.1 v1(58.35,102.86) ; C625.1 108.65,36.82 v1(109.1,36.36) ; PC198.1 v1(112.2,77.71) 111.81,78.11 PQ29.1 ; v2(93.98,47.6) 93.98,47.57 93.6,47.19 U30.AP13 92.71,46.39 U30.AR14 ; U32.5 19.91,31.39 v1(20.38,31.86) ; CN18.6 201.4,10.95 v1(201.74,11.29) ; Y4.2 105.9,33.09 v1(106.61,32.37) ; U30.AM11 95.71,48.58 95.71,48.38 U30.AN10 ; C649.2 84.74,29.29 v1(84.77,29.32) ; v1(136.8,15.73) 136.8,14.76 ; v1(109.54,109.21) 109.54,109.46 U25.AE32 ; v1(203.39,36.26) 203.13,36 C628.2 ; U25.N32 116.75,109.72 v2(117.21,109.26) 117.01,109.05 117.01,108.73 U25.L31 ; CN18.5 208.46,10.91 v1(209.61,10.91) ; C679.2 200.08,19.44 v1(199.96,19.32) ; C581.1 v1(148.02,79.22) ; R709.1 19.99,15.98 19.62,15.61 v1(18.73,15.61) ; C669.2 199.84,22.41 v1(199.83,22.41) ; v1(116.04,48.8) 116.52,48.8 116.7,48.63 117.92,48.63 ; v1(186.5,10.91) 186.5,11.29 186.26,11.53 CN11.77 ; C557.1 v1(57.21,102.86) ; U24.25 v1(39.22,106.67) ; v1(9.56,12.33) 10.22,12.99 C500.2 ; PQ21.1 73.94,88.44 v1(73.94,87.87) ; J1.2 v1(63.7,26.4) ; v2(94.9,56.49) 95.31,56.9 U30.AC11 ; C636.1 201.3,33.77 v1(200.47,33.77) ; U25.K29 117.56,107.68 v1(117.56,107.56) 117.56,107.45 117,106.89 U25.L27 ; C613.1 v1(15.17,43.17) ; C216.2 v1(23.68,72) ; v1(129.6,34.78) 129.92,34.46 PC267.2 ; U25.L15 v1(116.58,100.3)
  BOTTOM w0.406: PC202.2 141.82,73.74 v1(141.92,73.65) ; PC201.2 140.41,73.67 v1(140.43,73.65) ; PC217.2 142.77,62.74 v2(143,62.74) ; PR302.2 148.04,42.65 v1(148.04,42.65) ; v2(145.33,60.88) 145.33,60.91 PR251.2
  BOTTOM w0.457: v1(65.07,125.59) 66.16,125.59 PC133.1 ; v1(56.7,23.48) 56.15,22.93 EC1.1 ; PC143.2 64.97,119.61 64.96,119.61 64.96,119.01 64.94,118.98 v1(64.94,118.9) ; EC2.2 59.16,23.01 v1(58.71,23.46)
  BOTTOM w0.483: PC203.2 139.17,74.29 v1(139.63,74.74) ; v2(143.48,60.82) 142.83,60.82 PC220.2
  BOTTOM w0.508: PC184.2 68.51,89.13 v1(68.51,88.51) ; PC283.2 153.07,27.68 CN10.2 ; D34.1 171.89,20.56 172.2,20.26 v1(172.2,20.05) ; v1(60.95,89.01) 60.95,88.17 PQ23.1 ; PQ24.1 66.64,87.46 66.99,87.11 v1(66.99,87.08) ; FAN1.4 v1(181.65,31.38) ; D37.2 176.18,19.23 v1(175.58,18.63) ; FAN1.5 174.73,23.8 v1(174.81,23.71) ; v1(72.96,85.08) 72.89,85.14 PQ25.1 ; PQ19.1 63.28,89.74 63.79,90.26 v1(63.82,90.26) ; CN2.41 42.02,109.92 42.35,109.59 v1(43.06,109.59)
  vias: v1(1.56,26.62) v1(2.01,25.44) v1(2.38,23.05) v1(2.6,111.11) v1(2.62,64.95) v1(2.62,63.68) v1(2.62,62.41) v1(2.59,24.31) v1(2.83,26.62) v1(3.79,121.88) v1(3.76,45.37) v1(3.76,44.1) v1(3.8,22.14) v1(3.93,46.62) v1(4.1,26.62) v1(4.18,87.33) v1(4.8,121.22) v1(5.06,121.88) v1(5.15,111.98) v1(5.2,46.62) v1(5.33,86.78) v1(5.3,67.48) v1(5.37,26.62) v1(5.61,20.71) v1(6.07,121.21) v1(6.21,105.62) v1(6.23,84.92) v1(6.16,42.26) v1(6.33,121.88) v1(6.41,112.07) v1(6.42,62.26) v1(6.6,86.78) v1(6.57,67.48) v1(7.34,121.11) v1(7.31,85.59) v1(7.44,105.28) v1(7.43,42.26) v1(7.56,66.69) v1(7.68,87.45) v1(7.69,62.26) v1(8.56,85.78) v1(8.56,42.84) v1(8.83,66.69) v1(8.81,62.85) v1(8.86,46.02) v1(8.9,23.05) v1(9.1,26.02) v1(9.54,10.43) v1(9.66,85.14) v1(9.82,67.48) v1(9.83,42.86) v1(10.08,62.86) v1(10.13,46.02) v1(10.41,120.38) v1(10.37,26.02) v1(11.05,43.19) v1(11.27,63.28) v1(11.32,45.59) v1(11.55,25.54) v1(11.68,120.38) v1(11.73,1.02) v1(12.32,43.24) v1(12.35,88.81) v1(12.54,63.14) v1(12.58,45.77) v1(12.58,10.78) v1(12.76,25.91) v1(12.95,120.38) v1(13,1.02) v1(13.25,62.08) v1(13.19,42.31) v1(13.25,46.84) v1(13.78,11.59) v1(13.98,119.65) v1(14.34,118.43) v1(14.27,1.02) v1(14.92,76.44) v1(14.9,73.32) v1(15.43,113.65) v1(15.43,113.02) v1(15.43,80.05) v1(15.48,117.88) v1(15.54,1.02) v1(15.56,81.01) v1(15.96,76.44) v1(16.06,113.65) v1(16.06,113.02) v1(16.75,117.88) v1(16.83,24.88) v1(16.81,1.02) v1(16.95,34.66) v1(16.95,34.02) v1(17.13,114.08) v1(17.23,74.37) v1(17.84,46.67) v1(18.02,117.88) v1(17.97,16.5) v1(17.97,14.59) v1(18.08,1.02) v1(18.6,79.62) v1(19.24,24.88) v1(19.29,117.88) v1(19.35,1.02) v1(19.62,48.12) v1(19.7,114.87) v1(19.75,16.5) v1(19.75,14.72) v1(20.13,48.63) v1(20.51,78.09) v1(20.51,76.19) v1(20.56,117.88) v1(20.64,49.14) v1(20.64,48.12) v1(20.62,1.02) v1(21.4,24.9) v1(21.65,25.89) v1(21.83,117.88) v1(21.78,28.94) v1(21.78,27.16) v1(22.16,50.91) v1(22.29,25.89) v1(22.41,76.19) v1(22.67,42.02) v1(22.67,41.39) v1(22.67,40.75) v1(22.79,34.28) v1(23.1,117.88) v1(23.18,36.05) v1(23.18,17.51) v1(23.3,44.31) v1(23.43,86.9) v1(23.43,84.82) v1(23.81,17.51) v1(23.94,53.33) v1(24.32,61.2) v1(24.32,59.17) v1(24.37,117.88) v1(24.43,1.02) v1(24.55,38.92) v1(24.55,25.69) v1(24.7,75.42) v1(24.7,36.94) v1(25.64,117.88) v1(25.59,77) v1(25.72,79.39) v1(26.35,104.38) v1(26.6,90.66) v1(26.6,89.9) v1(26.6,88.12) v1(26.6,86.35) v1(26.6,85.71) v1(26.91,117.88) v1(26.99,79.59) v1(26.99,77.46) v1(26.99,75.04) v1(26.99,13.07) v1(27.16,10.81) v1(27.75,12.43) v1(28.18,117.88) v1(28.57,104.4) v1(28.64,13.58) v1(29.12,10.81) v1(29.45,117.88) v1(29.5,104.38) v1(30.62,11.52) v1(30.72,117.88) v1(30.67,13.58) v1(30.92,93.59) v1(31.25,11.52) v1(31.56,104.38) v1(31.56,12.69) v1(31.94,93.59) v1(32.11,15.77) v1(32.49,104.39) v1(32.95,93.59) v1(33.21,7.48) v1(33.66,15.58) v1(33.69,12.69) v1(34.11,118.95) v1(34.18,120.22) v1(34.33,15.58) v1(34.35,7.48) v1(34.86,93.59) v1(35.49,120.64) v1(35.49,120) v1(35.49,119.37) v1(35.62,24.12) v1(36.64,123.94) v1(36.76,93.59) v1(38.67,96.76) v1(38.67,93.71) v1(38.8,30.09) v1(38.8,28.69) v1(38.95,42.4) v1(39.51,107.5) v1(39.56,30.09) v1(39.56,28.69) v1(40.07,26.07) v1(40.19,42.4) v1(40.4,101.51) v1(40.7,93.59) v1(40.75,26.07) v1(40.94,1.02) v1(40.98,2.29) v1(41.14,48.36) v1(42.33,48.38) v1(42.48,93.59) v1(43.42,124.07) v1(43.62,106.29) v1(43.62,105.27) v1(43.62,104.38) v1(43.61,20.75) v1(43.94,20.04) v1(44.08,21.2) v1(44.32,20.6) v1(44.38,92.7) v1(44.64,83.04) v1(44.64,72) v1(44.62,20.04) v1(44.66,105.27) v1(44.66,104.38) v1(44.73,21.18) v1(45,20.6) v1(45.07,28.7) v1(45.32,105.98) v1(45.27,92.7) v1(45.3,20.03) v1(45.35,105.27) v1(45.35,104.38) v1(45.37,21.18) v1(45.4,10.1) v1(45.45,93.64) v1(45.65,49.52) v1(45.67,20.59) v1(46.04,96.89) v1(46,21.18) v1(46.06,7.02) v1(46.29,92.57) v1(46.34,20.08) v1(46.29,8.75) v1(46.8,83.04) v1(46.8,72) v1(46.92,8.75) v1(47.05,92.57) v1(47.33,10.83) v1(47.33,7.02) v1(47.69,9.77) v1(47.69,9.13) v1(48.08,122.47) v1(48.6,7.02) v1(48.88,101.54) v1(49.38,9.29) v1(49.38,8.02) v1(49.46,10.55) v1(50.18,11.6) v1(50.53,101.97) v1(51.33,125.55) v1(51.38,12.02) v1(51.5,102.73) v1(52.64,103.34) v1(52.65,12.02) v1(52.83,32.31) v1(52.89,125.59) v1(53.1,79.86) v1(53.36,82.45) v1(53.57,93.07) v1(53.66,125.59) v1(53.78,76.95) v1(53.82,46.41) v1(53.92,12.02) v1(54.04,67.04) v1(54.16,39.03) v1(54.25,35.89) v1(54.29,40.95) v1(54.44,125.58) v1(54.45,82.41) v1(54.54,42.48) v1(54.67,16.88) v1(54.83,93.8) v1(55.05,39.03) v1(55.18,125.59) v1(55.19,12.02) v1(55.43,16.88) v1(55.69,48.35) v1(55.69,40.95) v1(55.81,86.6) v1(55.96,125.59) v1(56.07,16.88) v1(56.46,12.02) v1(56.58,25.49) v1(56.7,125.59) v1(57.36,125.72) v1(57.72,25.49) v1(57.73,12.02) v1(58.35,25.49) v1(59,12.02) v1(59.12,26.53) v1(59.24,28.18) v1(59.37,27.42) v1(60.27,12.02) v1(60.89,67.93) v1(61.04,121.83) v1(61.53,67.93) v1(61.53,17) v1(61.54,12.02) v1(61.68,121.83) v1(61.78,48.75) v1(62.16,47.36) v1(62.16,17) v1(62.34,67.8) v1(62.8,47.36) v1(62.8,17) v1(62.81,12.02) v1(62.98,67.8) v1(63.56,47.36) v1(64.08,12.02) v1(64.82,12.38) v1(65.35,12.02) v1(65.72,46.34) v1(66.48,46.34) v1(66.62,12.02) v1(66.84,20.69) v1(67.24,46.34) v1(67.47,20.69) v1(67.72,123.53) v1(67.91,84.97) v1(67.89,12.02) v1(68.11,80.91) v1(68.16,78.17) v1(68.36,123.67) v1(68.36,123.01) v1(69.16,12.02) v1(69.4,46.34) v1(70.04,46.34) v1(70.42,99.17) v1(70.43,12.02) v1(70.93,98.67) v1(71.44,98.16) v1(71.7,12.02) v1(71.92,97.67) v1(72.27,113) v1(72.31,111.69) v1(72.37,110.41) v1(72.38,97.22) v1(72.71,92.95) v1(72.74,92.03) v1(72.83,96.73) v1(72.93,112.41) v1(72.97,12.02) v1(73.06,111.01) v1(73.55,111.68) v1(73.56,113.02) v1(73.59,110.38) v1(74.24,12.02) v1(74.36,72.5) v1(74.8,113.02) v1(74.84,111.72) v1(74.84,110.37) v1(75.51,12.02) v1(76.77,62.34) v1(76.78,12.02) v1(77.34,91.17) v1(78.05,12.02) v1(78.29,125.19) v1(78.55,19.67) v1(78.56,118.11) v1(78.57,117.45) v1(78.73,115.35) v1(78.94,11.11) v1(79.18,19.67) v1(79.52,124.88) v1(79.54,116.95) v1(79.68,10.08) v1(79.83,98.79) v1(79.82,19.75) v1(80.14,103.29) v1(80.11,102.04) v1(80.1,100.79) v1(80.11,99.53) v1(80.33,101.42) v1(80.55,102.68) v1(80.48,100.13) v1(80.53,98.8) v1(80.64,104.01) v1(80.56,9.16) v1(80.79,124.88) v1(80.91,103.29) v1(80.89,102.05) v1(80.88,100.75) v1(80.9,99.52) v1(81.24,101.45) v1(81.32,112.99) v1(81.32,104.01) v1(81.32,102.68) v1(81.26,98.8) v1(81.64,100.74) v1(81.57,8.39) v1(81.73,109.95) v1(81.71,108.7) v1(81.7,107.45) v1(81.7,106.18) v1(81.67,104.58) v1(81.7,103.29) v1(81.66,102.05) v1(81.93,108.08) v1(82,104.01) v1(82,102.69) v1(81.96,101.45) v1(82.14,109.34) v1(82.08,106.79) v1(82.5,109.95) v1(82.48,108.71) v1(82.47,107.41) v1(82.49,106.17) v1(82.54,98.84) v1(82.56,124.85) v1(82.68,7.78) v1(82.83,108.1) v1(82.91,109.34) v1(83.09,114.92) v1(83.12,104.91) v1(83.24,107.4) v1(83.33,124.88) v1(83.28,113.27) v1(83.3,109.95) v1(83.25,108.7) v1(83.59,109.34) v1(83.55,108.1) v1(83.82,112.93) v1(83.75,105.27) v1(83.87,7.34) v1(84.03,112.33) v1(84.14,104.76) v1(84.6,124.88) v1(84.77,104.76) v1(85.12,7.08) v1(85.53,109.21) v1(85.86,125.04) v1(86.02,112.48) v1(86.1,116.21) v1(86.38,7.02) v1(86.67,126.02) v1(86.74,116.2) v1(86.68,112.48) v1(87.49,126.98) v1(87.65,7.14) v1(87.82,115.66) v1(88.45,115.63) v1(88.76,126.98) v1(88.88,7.45) v1(89.47,117.59) v1(90.03,126.98) v1(90.05,7.94) v1(90.46,117.08) v1(91.1,117.05) v1(91.14,8.6) v1(91.3,126.98) v1(92.11,9.41) v1(92.57,126.98) v1(93.03,32.73) v1(92.95,10.36) v1(93.15,99.3) v1(93.56,28.31) v1(93.64,11.43) v1(93.84,126.98) v1(94.42,99.3) v1(94.77,12.02) v1(94.96,76.8) v1(95.11,99.3) v1(95.06,74.92) v1(95.64,111.09) v1(95.64,109.18) v1(95.69,114.03) v1(95.69,112.28) v1(96.04,12.02) v1(97.31,12.02) v1(97.62,76.26) v1(97.62,74.41) v1(98.58,12.02) v1(99.85,12.02) v1(99.98,112.31) v1(99.97,111.66) v1(100.12,92.42) v1(100.19,127.21) v1(101.12,12.02) v1(101.46,127.21) v1(101.74,125.59) v1(101.85,124.92) v1(102.39,12.02) v1(102.73,127.21) v1(102.68,120.13) v1(103.29,103.19) v1(103.44,83.93) v1(103.66,12.02) v1(103.87,125.36) v1(104,127.21) v1(103.97,103.16) v1(104.23,82.92) v1(104.76,106.41) v1(104.89,94.19) v1(104.93,12.02) v1(105.27,127.21) v1(105.52,124.8) v1(105.52,106.46) v1(105.5,102.07) v1(106.23,121.78) v1(106.2,12.02) v1(106.28,125.46) v1(106.36,33.87) v1(106.54,127.21) v1(107.47,12.02) v1(107.63,117.33) v1(107.63,116.57) v1(107.63,115.56) v1(107.63,35.37) v1(107.81,127.21) v1(108.14,112.67) v1(108.22,74.15) v1(108.39,76.06) v1(108.39,75.3) v1(108.74,12.02) v1(109.08,127.21) v1(109.51,107.07) v1(110.04,73.65) v1(110.01,12.02) v1(110.35,127.21) v1(110.5,107.05) v1(110.7,106.22) v1(110.7,103.22) v1(110.93,85.46) v1(110.93,83.93) v1(111.28,12.02) v1(111.49,107.05) v1(111.49,106.29) v1(111.52,103.16) v1(111.62,127.21) v1(111.64,38.14) v1(112.41,103.16) v1(112.53,107.07) v1(112.48,106.26) v1(112.55,12.02) v1(112.71,86.98) v1(112.71,85.46) v1(112.71,83.93) v1(112.89,127.21) v1(113.35,102.22) v1(113.45,103.19) v1(113.5,107.07) v1(113.47,106.31) v1(113.82,12.02) v1(114.16,127.21) v1(114.51,107.1) v1(114.51,106.39) v1(114.49,103.19) v1(115.12,61.96) v1(115.09,12.02) v1(115.43,126.98) v1(115.4,103.19) v1(115.38,75.93) v1(115.48,107.12) v1(115.5,106.39) v1(115.73,61.61) v1(116.01,75.93) v1(116.24,62.01) v1(116.39,22.72) v1(116.36,12.02) v1(116.65,75.93) v1(116.7,126.98) v1(117.28,22.72) v1(117.63,12.02) v1(117.97,126.98) v1(118.17,82.92) v1(118.17,77.28) v1(118.17,22.72) v1(118.4,82.13) v1(118.81,82.92) v1(118.81,22.72) v1(118.9,12.02) v1(119.09,117.36) v1(119.24,126.98) v1(119.95,116.24) v1(120.17,12.02) v1(120.25,73.37) v1(120.51,126.98) v1(121.09,82.79) v1(121.32,82.1) v1(121.44,12.02) v1(121.73,117.46) v1(121.73,82.79) v1(121.78,126.98) v1(122.67,73.04) v1(122.71,12.02) v1(123.05,126.98) v1(123.15,115.58) v1(123.76,125.93) v1(123.79,115.61) v1(123.89,45.2) v1(123.89,44.56) v1(123.89,43.93) v1(123.89,43.29) v1(123.96,116.93) v1(123.98,12.02) v1(124.15,70.39) v1(124.15,69.71) v1(124.27,21.32) v1(124.27,19.93) v1(124.47,109.76) v1(124.52,13.91) v1(124.62,125.23) v1(124.73,93.43) v1(124.78,113.93) v1(124.78,70.42) v1(124.79,69.76) v1(125.31,106.39) v1(125.25,12.02) v1(125.56,90.84) v1(125.69,21.32) v1(125.66,19.93) v1(125.89,125.11) v1(125.97,110.59) v1(125.98,109.23) v1(126.22,100.27) v1(126.34,113.86) v1(126.33,103.25) v1(126.27,101.41) v1(126.37,115.63) v1(126.52,12.02) v1(126.65,98.9) v1(126.66,14.01) v1(126.79,112.58) v1(126.88,97.47) v1(127.04,93.23) v1(127.16,125.11) v1(127.24,95.97) v1(127.19,22.85) v1(127.19,21.32) v1(127.19,19.93) v1(127.44,106.32) v1(127.37,105.02) v1(127.45,110.59) v1(127.52,32.45) v1(127.59,93.88) v1(127.67,109.67) v1(127.7,89.52) v1(127.67,30.29) v1(127.79,12.02) v1(128.26,103.21) v1(128.26,100.29) v1(128.33,97.45) v1(128.43,125.11) v1(128.58,98.78) v1(128.59,60.95) v1(128.87,101.21) v1(129.02,92.52) v1(129.02,89.52) v1(129.14,96.02) v1(129.06,12.02) v1(129.7,125.11) v1(130.33,12.02) v1(130.9,37.52) v1(131.6,12.02) v1(132.37,87.13) v1(132.4,38.07) v1(132.88,106) v1(132.9,90.92) v1(132.87,12.02) v1(133.08,58.33) v1(134.14,12.02) v1(135.04,29.09) v1(135.22,38.08) v1(135.41,12.02) v1(135.62,56.35) v1(135.98,107.78) v1(136.68,12.02) v1(137.95,12.02) v1(139.22,12.02) v1(139.42,42.87) v1(140.19,39.74) v1(140.49,12.02) v1(140.76,83.8) v1(141.03,28.79) v1(141.36,73.98) v1(141.76,12.02) v1(143.02,11.84) v1(143.4,31.66) v1(143.4,30.99) v1(143.8,74.03) v1(143.87,67.62) v1(143.96,10.99) v1(144.06,31.65) v1(144.06,30.99) v1(144.45,9.82) v1(144.74,31.66) v1(144.74,30.98) v1(144.79,69.61) v1(145.14,54.89) v1(145.14,53.74) v1(145.12,52.41) v1(145.1,30.16) v1(145.39,31.66) v1(145.4,30.99) v1(145.68,53) v1(145.72,9.82) v1(145.86,32.5) v1(146.22,69.01) v1(146.36,54.88) v1(146.35,53.7) v1(146.37,52.42) v1(146.99,9.82) v1(147.05,54.42) v1(147.13,53.07) v1(147.62,54.92) v1(147.61,53.69) v1(147.63,52.42) v1(148.26,9.82) v1(148.5,22.85) v1(149.13,22.85) v1(149.53,9.82) v1(150.8,9.82) v1(150.98,116.97) v1(150.98,115.7) v1(150.98,114.43) v1(150.98,113.16) v1(150.98,111.89) v1(150.98,110.62) v1(150.98,109.35) v1(150.98,108.08) v1(150.98,106.81) v1(150.98,105.54) v1(150.98,104.27) v1(150.98,103) v1(150.98,101.73) v1(150.98,100.46) v1(150.98,99.19) v1(150.98,97.92) v1(150.98,96.65) v1(150.98,95.38) v1(150.98,94.11) v1(150.98,92.84) v1(150.98,91.57) v1(150.98,90.3) v1(150.98,89.03) v1(150.98,87.76) v1(150.98,86.49) v1(150.98,85.22) v1(150.98,83.95) v1(150.98,82.68) v1(150.98,81.41) v1(150.98,80.14) v1(150.98,78.87) v1(150.98,77.6) v1(150.98,76.33) v1(150.98,75.06) v1(150.98,73.79) v1(150.98,72.52) v1(150.98,71.25) v1(150.98,69.98) v1(150.98,68.71) v1(150.98,67.44) v1(151.05,66.17) v1(151.16,64.9) v1(151.27,18.66) v1(151.52,63.69) v1(151.78,62.29) v1(151.76,61.14) v1(151.9,18.66) v1(152.06,59.91) v1(152.07,9.82) v1(152.31,44.16) v1(152.25,42.89) v1(152.4,58.69) v1(152.45,41.64) v1(152.49,28.84) v1(152.54,18.66) v1(152.63,45.39) v1(152.79,57.48) v1(152.84,37.96) v1(152.89,40.45) v1(153.22,56.28) v1(153.18,46.53) v1(153.34,9.82) v1(153.57,39.37) v1(153.7,55.11) v1(153.96,47.54) v1(154.06,18.66) v1(154.23,53.95) v1(154.42,24.55) v1(154.62,18.27) v1(154.61,9.82) v1(154.8,52.82) v1(154.91,48.38) v1(155.05,24.55) v1(155.79,49.3) v1(155.88,9.82) v1(155.95,50.56) v1(156.66,37.24) v1(157.15,9.82) v1(157.27,28.82) v1(157.91,36.99) v1(158.31,35.29) v1(158.42,9.82) v1(159.18,36.99) v1(159.69,9.82) v1(160.42,37.25) v1(160.96,9.82) v1(161.61,37.91) v1(162.23,9.82) v1(162.63,38.46) v1(163.5,9.82) v1(163.65,39.21) v1(164.77,9.82) v1(164.88,39.51) v1(166.05,39) v1(166.04,9.82) v1(166.26,36.99) v1(167.07,38.25) v1(167.31,9.82) v1(168.12,37.54) v1(168.58,9.82) v1(169.2,36.87) v1(169.85,9.82) v1(170.3,36.24) v1(171.12,9.82) v1(171.51,35.85) v1(172.39,9.82) v1(172.68,35.34) v1(173.66,9.82) v1(174.93,9.82) v1(176.2,9.82) v1(177.48,34.26) v1(177.47,9.82) v1(178.74,9.82) v1(178.75,34.26) v1(180.02,34.26) v1(180.01,9.82) v1(181.29,34.26) v1(181.28,9.82) v1(182.52,9.57) v1(182.56,34.26) v1(183.3,33.23) v1(183.7,9.09) v1(183.83,34.26) v1(184.97,9.09) v1(185.1,34.26) v1(186.24,9.09) v1(186.37,34.25) v1(187.51,9.09) v1(187.64,34.26) v1(188.78,9.09) v1(188.91,34.31) v1(190.05,8.91) v1(190.18,34.4) v1(191.32,8.91) v1(191.44,34.28) v1(192.51,8.91) v1(192.7,34.45) v1(192.97,10.4) v1(193.78,8.91) v1(193.95,34.66) v1(195.05,8.91) v1(195.19,34.91) v1(195.26,11.04) v1(195.26,10.4) v1(196.12,14.72) v1(196.43,35.21) v1(196.4,9.09) v1(196.76,14.72) v1(197.39,14.72) v1(197.66,35.54) v1(197.67,9.09) v1(198.87,35.91) v1(198.94,9.09) v1(199.32,11.03) v1(200.07,36.32) v1(200.21,9.09) v1(201.23,27.16) v1(201.23,24.75) v1(201.26,36.76) v1(201.48,9.09) v1(202.44,37.25) v1(202.37,27.16) v1(202.37,25.92) v1(202.37,24.75) v1(202.75,9.09) v1(203.59,37.77) v1(203.64,24.75) v1(203.77,27.16) v1(203.77,25.92) v1(204.02,9.09) v1(204.15,28.56) v1(204.63,25.92) v1(204.73,38.33) v1(204.66,25.13) v1(204.91,28.56) v1(204.91,27.16) v1(205.29,9.09) v1(206.56,9.09) v1(207.83,9.09) v1(209.1,9.09) v1(209.69,21.83) v1(210.37,21.83) v1(210.37,9.09) v1(211.64,21.96) v1(211.64,9.09) v1(212.02,11.82) v1(212.91,9.09) v1(213.09,44.06) v1(213.17,24.88) v1(213.17,24.24) v1(214.03,44.92) v1(214.18,9.09) v1(214.69,17.39) v1(214.93,45.81) v1(214.95,27.04) v1(214.95,26.02) v1(215.2,17.89) v1(215.45,9.09) v1(215.81,46.72) v1(216.34,17.51) v1(217.1,29.96) v1(217.1,29.32) v1(217.1,28.69) v1(217.1,28.05) v1(217.36,45.58) v1(217.36,13.58) v1(217.36,12.94) v1(218.78,43.1) v1(218.78,41.83) v1(218.78,31.67) v1(218.78,30.4) v1(218.78,29.13) v1(218.78,27.86) v1(218.78,17.7) v1(218.78,16.43) v1(218.78,15.16) v1(218.78,13.89) v1(218.78,12.62) v1(218.78,11.35) v1(218.78,10.08) v2(15.25,56.37) v2(15.43,19.9) v2(16.14,19.9) v2(17.99,9.51) v2(19.26,10.27) v2(25.79,83.17) v2(26.58,81.75) v2(32.53,32.54) v2(35.37,12.94) v2(37.27,12.94) v2(37.78,14.08) v2(39.23,105.37) v2(39.61,14.62) v2(40.93,106.59) v2(42.2,107.38) v2(45.27,99.88) v2(45.91,99.94) v2(47.43,99.94) v2(47.69,100.87) v2(48.32,99.81) v2(53.49,65.41) v2(53.74,63.53) v2(55.54,101.46) v2(55.81,55.96) v2(56.03,57.09) v2(56.07,65.41) v2(56.41,54.49) v2(60.77,35.67) v2(61.53,34.76) v2(62.32,33.77) v2(65.47,36.56) v2(65.97,37.96) v2(66.1,39.99) v2(66.1,39.1) v2(66.48,42.28) v2(66.74,36.56) v2(67.37,39.99) v2(67.37,39.1) v2(67.88,42.28) v2(68.01,36.56) v2(68.77,69.33) v2(69.15,39.13) v2(69.78,68.31) v2(70.06,44.03) v2(70.8,67.55) v2(71.05,39.2) v2(71.51,71.84) v2(71.66,67.7) v2(71.94,67.17) v2(71.97,64.76) v2(72.32,70.88) v2(72.45,61.45) v2(73.21,70.04) v2(73.21,64.76) v2(73.34,63.23) v2(73.7,66.79) v2(73.76,44.81) v2(74.43,61.45) v2(74.36,60.18) v2(74.48,64.76) v2(74.99,44.82) v2(75.12,55.61) v2(75.37,74.54) v2(75.37,73.77) v2(75.37,57.26) v2(76.01,70.37) v2(76.23,58.12) v2(76.26,72) v2(76.31,43.65) v2(76.36,44.81) v2(76.84,69.52) v2(76.9,74.15) v2(77.12,57.2) v2(77.09,55.75) v2(77.53,73.52) v2(77.52,44.81) v2(77.68,68.68) v2(78.01,77.13) v2(78,42.29) v2(78.67,78.09) v2(78.83,76.26) v2(79.44,78.09) v2(80.07,77.08) v2(80.07,75.93) v2(80.14,74.96) v2(81.69,42.95) v2(82.35,77.29) v2(82.35,76.12) v2(82.35,74.96) v2(82.71,37.6) v2(83.35,34.91) v2(83.4,36.82) v2(83.96,38.85) v2(84.14,35.29) v2(84.17,37.68) v2(84.76,46.46) v2(85.13,38.42) v2(85.28,36.31) v2(86.68,37.07) v2(86.68,35.04) v2(87.18,74.65) v2(87.79,75.29) v2(87.79,74.65) v2(88.55,75.29) v2(88.45,37.65) v2(88.45,36.44) v2(88.45,35.17) v2(89.09,29.96) v2(91.02,68.67) v2(93.15,75.55) v2(93.56,27.7) v2(93.99,68.06) v2(103.41,54.08) v2(103.43,53.09) v2(103.85,116.45) v2(104.02,55.85) v2(105.09,116.45) v2(109.54,62.72) v2(109.61,69.71) v2(109.61,63.49) v2(109.66,68.06) v2(109.69,50.81) v2(109.69,49.77) v2(109.79,66.15) v2(109.79,64.88) v2(110.68,102.22) v2(111.34,68.64) v2(111.44,66.76) v2(111.95,50.1) v2(111.98,51.95) v2(112.13,64.76) v2(112.58,66.28) v2(112.89,68.44) v2(112.96,63.44) v2(133.03,56.45) v2(133.03,55.87) v2(133.03,55.28) v2(133.08,20.2) v2(133.75,57.68) v2(133.67,56.45) v2(133.67,55.87) v2(133.67,55.28) v2(133.69,22.26) v2(133.78,60.17) v2(133.78,59.54) v2(133.78,58.9) v2(133.77,58.31) v2(134.3,56.45) v2(134.3,55.87) v2(134.3,55.28) v2(134.39,60.16) v2(134.39,59.54) v2(134.38,58.89) v2(134.36,58.3) v2(134.35,57.66) v2(134.86,60.77) v2(135,60.11) v2(135,59.48) v2(135,58.84) v2(134.99,58.25) v2(134.95,57.66) v2(135.55,57.65) v2(135.56,60.77) v2(135.61,60.1) v2(135.61,59.48) v2(135.6,58.83) v2(135.58,58.24) v2(136.22,55.93) v2(136.19,55.33) v2(136.81,55.92) v2(136.78,55.33) v2(136.85,66.23) v2(136.94,51.04) v2(136.93,50.41) v2(136.96,52.9) v2(136.96,52.27) v2(136.96,51.64) v2(137.5,66.22) v2(137.54,51.03) v2(137.53,50.39) v2(137.57,52.89) v2(137.57,52.27) v2(137.56,51.63) v2(138.12,66.22) v2(138.09,54.06) v2(138.08,53.43) v2(138.13,50.39) v2(138.18,52.84) v2(138.18,52.21) v2(138.18,51.57) v2(138.16,50.98) v2(138.72,66.22) v2(138.69,54.05) v2(138.69,53.43) v2(138.73,50.39) v2(138.79,52.83) v2(138.79,52.21) v2(138.78,51.56) v2(138.76,50.97) v2(143.6,47.73) v2(143.6,47.15) v2(178.85,22.72) v2(179.08,24.34) v2(180.12,24.34) v2(180.1,22.74) v2(180.12,19.49) v2(184.8,16.24) v2(185.41,15.07) v3(67.68,122.84) v3(67.95,122.11) v3(69.04,122.88) v3(69.12,123.62) v3(80.05,114.88) v3(80.35,115.58) v3(80.82,114.88) v3(81.1,115.6) v3(81.6,114.87) v3(81.92,115.57) v3(82.39,114.9) v3(83.33,112.44) v3(84.74,112.5) v3(87.36,112.51) v3(105.25,19.31) v3(105.99,19.29) v3(106.39,20.27) v3(106.77,19.28) v3(107.18,20.27) v3(107.56,19.29) v3(107.93,20.27) v3(108.7,20.27) v3(126.54,31.67) v3(126.57,30.93) v3(127.3,31.67) v3(127.31,30.93) v3(128.06,31.67) v3(128.06,30.93) v3(136.22,63.94) v3(136.22,63.2) v3(136.26,64.68) v3(136.73,62.51) v3(137.04,64.69) v3(136.96,63.96) v3(136.95,63.22) v3(137.47,62.46) v3(137.71,63.92) v3(137.69,63.16) v3(137.8,64.68) v3(138.21,62.5) v3(138.43,63.21) v3(138.46,63.95) v3(138.56,64.69) v3(139.37,42.08) v3(139.91,40.47) v3(140.1,42.87) v3(140.1,42.07) v3(140.11,41.23) v3(143.93,68.31) v3(144.28,68.97) v3(144.82,68.4) v3(145.32,68.97) v3(145.88,68.39)
