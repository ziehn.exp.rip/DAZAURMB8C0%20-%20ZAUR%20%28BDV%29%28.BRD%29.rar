# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
C_TX2_HDMI+: length 4.4
  TOP w0.102: R143.1 17.49,80.41 17.14,80.06 16.89,80.06 16.41,80.54 16.41,80.59 v1(16.83,81.01)
  BOTTOM w0.102: U28.23 17.04,79.87 16.39,80.51 16.39,80.63 16.78,81.01 v1(16.83,81.01)
C_TX2_HDMI-: length 4.5
  TOP w0.102: R146.1 16.8,79.84 16.19,80.45 16.19,81.01 v1(16.19,81.01)
  BOTTOM w0.102: U28.22 17.15,79.47 16.19,80.43 v1(16.19,81.01)
C_TXC_HDMI+: length 2.4
  TOP w0.102: v1(16.55,75.83) 16.13,75.41 15.92,75.41 15.82,75.52 R169.2
  BOTTOM w0.102: U28.14 17.13,76.27 16.7,75.83 v1(16.55,75.83)
C_TXC_HDMI-: length 2.4
  TOP w0.102: v1(16.55,75.2) 15.96,75.2 15.82,75.05 R171.2
  BOTTOM w0.102: U28.13 17.05,75.87 16.95,75.77 16.95,75.6 v1(16.55,75.2)
CASA0B: length 26
  TOP w0.102: 123.19,104.29 v1(121.39,104.29)
  TOP w0.127: v1(138.42,107.78) 137.97,107.33 132.65,107.33 132.12,106.79 131.94,106.79 131.74,107 131.53,107 131.31,106.77 131.31,106.59 131.93,105.97 131.93,105.77 131.76,105.6 131.58,105.6 130.95,106.23 130.77,106.23 130.59,106.05 130.59,105.88 131.26,105.21 131.26,105.03 131.08,104.85 130.9,104.85 130.23,105.52 130.05,105.52 129.87,105.34 129.87,105.16 130.48,104.55 130.48,104.34 130.31,104.18 130.13,104.18 129.51,104.8 129.33,104.8 128.66,104.13 123.35,104.13 123.19,104.29
  BOTTOM w0.102: v1(121.39,104.29) 121.2,104.48 U25.D23
  BOTTOM w0.127: VRAM1.L3 138.78,107.38 138.42,107.74 v1(138.42,107.78)
CASA1B: length 30
  TOP w0.102: v1(121.39,100.95) 122.5,100.95 123.58,99.86 124.4,99.86
  TOP w0.127: v1(139.18,92.59) 139.3,92.72 139.3,93.75 138.93,94.13 138.93,94.54 137.58,95.9 135.47,95.9 135.34,96.02 135.34,96.38 135.47,96.51 136.43,96.51 136.56,96.63 136.56,96.89 136.43,97.01 135.47,97.01 135.34,97.14 135.34,98.03 135.22,98.16 134.46,98.16 134.34,98.28 134.34,98.56 134.21,98.69 133.96,98.69 133.83,98.56 133.83,98.28 133.7,98.16 133.45,98.16 133.32,98.28 133.32,98.56 133.19,98.69 132.94,98.69 132.81,98.56 132.81,98.28 132.69,98.16 132.26,98.16 132.14,98.28 132.14,98.56 132.01,98.69 131.76,98.69 131.63,98.56 131.63,98.28 131.5,98.16 131.25,98.16 131.12,98.28 131.12,98.56 130.99,98.69 130.74,98.69 130.61,98.56 130.61,98.28 130.49,98.16 130.07,98.16 129.88,98.35 125.91,98.35 124.4,99.86
  BOTTOM w0.102: v1(121.39,100.95) 121.2,101.13 U25.D17
  BOTTOM w0.127: VRAM2.G3 v1(139.18,92.59)
CCDPWRON#: length 280.8
  TOP w0.102: v1(87.92,123.25) 87.92,122.9 87.82,122.8 86.04,122.8 85.71,123.13 82.13,123.13 81.77,122.77 Q43.2 81.4,122.33 81.09,122.64 78.95,122.64 78.66,122.94 R734.1 ; v1(193.76,33.69) 193.99,33.46 193.99,32.65 193.43,32.09 193.43,31.13 191.91,29.6 191.91,28.01 192.02,27.9 192.21,27.9 192.39,27.72 192.39,27.21 192.13,26.95 191.98,26.95 191.41,26.37 191.41,23.78 191.98,23.2 191.98,21.02 193.61,19.39 193.61,17.66 193.36,17.41 193.36,15.51 193.91,14.95 193.91,14.03 194.4,13.54 196.01,13.54 196.12,13.42 196.12,12.51 196.84,11.8 v1(196.84,10.49) 196.84,10.02 196.4,9.59 196,9.59 195.77,9.36 190.18,9.36 189.22,10.32 171.54,10.32 171.03,10.83 162.19,10.83 160.84,12.18 160.84,13.71 161.85,14.72 163.38,14.72 164.82,16.16 U15.31
  IN3 w0.089: v1(193.76,33.69) 192.62,33.69 192.52,33.79 174.43,33.79 173.94,34.28 173.03,34.28 171.96,35.34 169.1,35.34 166.69,37.76 162.67,37.76 161.15,36.23 156.65,36.23 154.03,38.85 153.45,38.85 152.18,40.12 152.18,40.8 151.57,41.41 151.57,44.66 150.91,45.32 150.91,45.79 154.87,49.75 154.87,51.49 153.2,53.17 153.2,55.43 151.57,57.05 151.57,60.13 150.18,61.53 150.18,77.34 150.51,77.67 150.51,117.73 149.64,118.6 146.08,118.6 142.37,122.31 139.98,122.31 137.11,125.18 133.34,125.18 132.86,124.7 123.73,124.7 122.18,126.25 115.02,126.25 114.46,126.81 99.72,126.81 99.53,127 95.11,127 92.78,124.67 88.73,124.67 87.92,123.86 v1(87.92,123.25)
CKEA0: length 27.8
  TOP w0.102: 123.54,102.66 123.3,102.9 122.73,102.9 122.15,103.48 121.06,103.48 v1(120.69,103.1)
  TOP w0.127: v1(140.78,107.78) 139.36,106.36 139.36,105.8 135.81,102.25 135.32,102.25 135.2,102.37 135.2,102.91 135.07,103.03 134.82,103.03 134.69,102.91 134.69,102.37 134.56,102.25 134.31,102.25 134.18,102.37 134.18,102.91 134.05,103.03 133.8,103.03 133.67,102.91 133.67,102.37 133.55,102.25 123.95,102.25 123.54,102.66
  BOTTOM w0.102: U25.G21 119.89,103.72 120.51,103.1 v1(120.69,103.1)
  BOTTOM w0.127: VRAM1.J3 140.38,107.38 v1(140.78,107.78)
CKEA1: length 30
  TOP w0.102: v1(120.15,102.13) 120.31,102.13 120.81,101.63 122.67,101.63 123.91,100.39 124.83,100.39
  TOP w0.127: 124.83,100.39 125.41,99.81 129.36,99.81 129.48,99.94 129.48,100.14 129.61,100.27 129.86,100.27 129.99,100.14 129.99,99.94 130.12,99.81 130.37,99.81 130.5,99.94 130.5,100.14 130.63,100.27 130.88,100.27 131.01,100.14 131.01,99.94 131.13,99.81 131.39,99.81 131.52,99.94 131.52,100.14 131.64,100.27 131.9,100.27 132.02,100.14 132.02,99.94 132.15,99.81 132.59,99.81 132.72,99.94 132.72,100.16 132.85,100.29 133.1,100.29 133.23,100.16 133.23,99.94 133.35,99.81 133.71,99.81 133.84,99.94 133.84,100.19 133.96,100.32 134.22,100.32 134.34,100.19 134.34,99.94 134.47,99.81 135.23,99.81 140.33,94.71 140.33,93.05 v1(140.78,92.59)
  BOTTOM w0.102: v1(120.15,102.13) 120.4,102.38 U25.E19
  BOTTOM w0.127: VRAM2.J3 v1(140.78,92.59)
CLK_LPC_DEBUG: length 130.7
  IN1 w0.089: v1(193.48,14.72) 192.02,13.26 192.02,11.11 191.31,10.4 187.85,10.4 186.84,11.42 179.16,11.42 v1(178.55,12.03) 178.5,11.97 178.5,11.29 178.09,10.88 145.88,10.88 143.62,13.14 98.79,13.14 v1(98.23,13.7)
  BOTTOM w0.102: R620.1 95.77,34.81 95.82,34.76 C635.1 96.25,33.85 96.25,33.18 95.49,32.42 95.49,24.93 94.8,24.24 94.8,20.71 97.6,17.92 97.6,14.34 v1(98.23,13.7) ; 179.9,14.71 180.32,14.71 180.33,14.72 R716.1 ; 179.9,14.71 179.9,13.84 178.55,12.48 v1(178.55,12.03) ; 179.9,14.71 C701.1 ; v1(193.48,14.72) 193.48,14.87 192.99,15.37 192.99,16.09 192.68,16.4 R706.1
CLK_LPC_DEBUG_C: length 3.7
  BOTTOM w0.102: CN11.71 182.1,13.63 181.54,14.18 181.54,14.46 181.29,14.72 R716.2 181.14,15.1 v1(180.73,15.51)
CLK_PCI_EC: length 100
  TOP w0.102: v1(161.86,22.34) 161.96,22.24 162.78,22.24 R322.2 163.64,22.72 164.28,23.36 U15.13
  IN3 w0.089: v1(92.14,18.15) 93.13,17.16 99,17.16 100.34,15.81 105.4,15.81 111.67,22.08 119.32,22.08 119.94,22.69 121.11,22.69 124.24,25.82 131.53,25.82 131.83,25.52 134.42,25.52 134.78,25.16 136.82,25.16 140.09,21.89 161.41,21.89 v1(161.86,22.34)
  BOTTOM w0.102: R614.1 90.21,35.42 89.34,34.56 89.34,33.14 C638.1 89.65,32.58 89.65,31.91 89.32,31.58 89.32,30.64 90.23,29.73 v1(90.23,26.53) 90.23,20.05 v1(92.14,18.15)
CLK_PCIE_LANN: length 114.4
  TOP w0.102: U2.16 46.04,102.73 45.91,102.6 45.91,102.4 46.72,101.59 47.94,101.59 48.32,101.2 48.32,100.53 48.53,100.32 v1(48.72,100.32)
  IN3 w0.089: v1(48.72,100.32) 48.47,100.32 48.32,100.47 48.32,102.6 47.43,103.49 47.43,105.27 48.86,106.69 61.38,106.69 62.04,106.03 62.04,105.49 62.84,104.68 64.62,104.68 66.53,102.77 66.53,101.63 67.13,101.04 67.13,99.41 76.05,90.49 83.93,90.49 85.05,89.37 88.37,89.37 90.02,87.72 90.63,87.72 91.72,86.63 94.83,86.63 95.52,85.94 96.56,85.94 98.59,83.91 98.59,79.78 100.9,77.47 100.9,73.1 106.23,67.77 106.23,62.82 108.62,60.43 108.62,52.58 110.07,51.13 110.07,50.64 109.78,50.35 109.19,50.35 109.08,50.47 v1(109.08,50.67)
  BOTTOM w0.102: v1(109.08,50.67) 109.08,50.49 108.98,50.39 108.98,50.39 108.91,50.32 108.47,50.32 108.36,50.42 R581.1
CLK_PCIE_LANN_R: length 8.4
  BOTTOM w0.102: R581.2 107.69,50.43 106.84,50.43 105.22,52.06 103.05,52.06 102.8,52.3 102.36,52.3 102.01,52.64 101.71,52.64 101.55,52.8 101.35,52.8 100.96,52.64 U30.AH4
CLK_PCIE_LANP: length 114.4
  TOP w0.102: U2.15 45.64,102.75 45.69,102.69 45.69,102.31 46.63,101.37 47.85,101.37 48.11,101.12 48.11,100.48 v1(47.94,100.32)
  IN3 w0.089: v1(109.08,49.9) 109.33,50.15 109.87,50.15 110.27,50.56 110.27,51.22 108.82,52.67 108.82,60.51 106.44,62.9 106.44,67.85 101.1,73.19 101.1,77.56 98.79,79.87 98.79,83.99 96.64,86.14 95.6,86.14 94.91,86.83 91.81,86.83 90.71,87.92 90.1,87.92 88.45,89.57 85.13,89.57 84.02,90.69 76.13,90.69 67.33,99.49 67.33,101.12 66.74,101.71 66.74,102.86 64.7,104.89 62.93,104.89 62.24,105.57 62.24,106.12 61.46,106.89 48.77,106.89 47.23,105.35 47.23,103.41 48.12,102.52 48.12,100.49 v1(47.94,100.32)
  BOTTOM w0.102: R582.1 108.57,50.1 108.89,50.1 109.08,49.91 v1(109.08,49.9)
CLK_PCIE_LANP_R: length 8.5
  BOTTOM w0.102: U30.AH2 101.29,52.49 101.19,52.39 101.19,52.24 101.3,52.13 101.48,52.13 101.78,52.43 101.93,52.43 102.27,52.08 102.72,52.08 102.96,51.84 105.13,51.84 106.75,50.21 107.8,50.21 107.91,50.1 R582.2
CLK_PCIE_SSDN: length 116.9
  IN3 w0.089: v1(111.94,50.71) 112.22,50.71 112.41,50.52 112.41,47.85 110.07,45.51 110.07,45.26 109.2,44.39 108.28,44.39 106.36,42.46 106.36,41.35 105.85,40.84 105.85,38.63 104.93,37.71 103.91,37.71 102.83,36.62 102.83,33.26 101.94,32.38 101.94,29.25 100.8,28.11 100.8,27.27 99.24,25.72 96.62,25.72 94.44,23.53 81.55,23.53 76.11,18.1 70.72,18.1 70.46,17.84 68.98,17.84 68.62,18.2 57.45,18.2 57.22,18.43 50.23,18.43 43.17,11.37 40.5,11.37 39.43,10.3 26.92,10.3 26.58,10.64 26.58,12.02 26.65,12.09 26.97,12.09 27.01,12.12 v1(27.01,12.42)
  BOTTOM w0.102: R728.1 26.81,11.74 26.73,11.82 26.73,12.14 v1(27.01,12.42) ; v1(111.94,50.71) 111.73,50.71 111.63,50.81 111.63,51.02 111.52,51.13 111.3,51.13 111.01,51.42 110.75,51.42 110.65,51.32 R580.1
CLK_PCIE_SSDN_C: length 1.9
  BOTTOM w0.102: R728.2 27.01,11.29 26.73,11.01 26.73,10.53 26.85,10.41 CN19.53
CLK_PCIE_SSDN_R: length 11.7
  BOTTOM w0.089: U30.AF4 101.35,54.18 101.47,54.18 101.77,54.3 101.94,54.3 102.2,54.05 102.2,53.74 102.18,53.73 102.18,53.71
  BOTTOM w0.102: R580.2 110.01,51.23 106.93,51.23 105.69,52.48 103.15,52.48 103.03,52.59 102.56,52.59 102.18,52.97 102.18,53.71
CLK_PCIE_SSDP: length 116.9
  IN3 w0.089: v1(111.94,51.34) 111.94,51.28 112.61,50.61 112.61,47.76 110.27,45.43 110.27,45.17 109.28,44.18 108.37,44.18 106.56,42.38 106.56,41.26 106.06,40.75 106.06,38.54 105.01,37.5 104,37.5 103.03,36.53 103.03,33.18 102.14,32.29 102.14,29.17 101,28.03 101,27.19 99.33,25.51 96.71,25.51 94.52,23.33 81.63,23.33 76.19,17.89 70.8,17.89 70.55,17.64 68.9,17.64 68.54,17.99 57.36,17.99 57.14,18.22 50.31,18.22 43.25,11.16 40.58,11.16 39.52,10.1 26.83,10.1 26.38,10.55 v1(26.38,12.42)
  BOTTOM w0.102: R727.1 26.52,11.93 26.52,12.28 v1(26.38,12.42) ; v1(111.94,51.34) 111.39,51.34 111.1,51.64 110.82,51.64 R579.1
CLK_PCIE_SSDP_C: length 1.9
  BOTTOM w0.102: R727.2 26.4,11.29 26.52,11.18 26.52,10.56 26.35,10.4 CN19.55
CLK_PCIE_SSDP_R: length 11.6
  BOTTOM w0.089: U30.AF2 102.02,54.49 102.39,54.13 102.39,53.74 102.4,53.73 102.4,53.71
  BOTTOM w0.102: 102.4,53.71 102.4,53.06 102.65,52.81 103.12,52.81 103.24,52.69 105.78,52.69 107.02,51.45 109.69,51.45 109.79,51.55 109.79,52.06 109.92,52.18 110.09,52.18 110.2,52.07 R579.2
CLK_PCIE_VGA_N: length 67.1
  IN1 w0.089: v1(103.32,110.86) 103.06,110.6 103.06,109.97 101.99,108.9 101.99,107.76 101.74,107.5 101.74,106.14 101.89,105.99 101.89,99.07 103.19,97.78 103.19,92.95 102.68,92.44 102.68,90.44 103.9,89.22 103.9,88.08 106.46,85.52 106.46,81.93 109.41,78.98 109.41,75.3 110.68,74.03 110.68,71.14 112.19,69.62 112.19,66.03 112.71,65.51 112.71,64.24 v1(112.86,64.09)
  BOTTOM w0.102: v1(112.86,64.09) 112.64,63.87 112.64,63.72 111.95,63.03 111.95,60.82 109.21,58.08 109.21,52.69 108.85,52.34 108.52,52.34 R577.1 ; U25.AU33 103.32,110.61 v1(103.32,110.86)
CLK_PCIE_VGA_N_R: length 12.5
  IN3 w0.089: v2(102.8,53.21) 102.58,53.43 101.16,53.43 100.6,52.87 97.97,52.87 97.77,53.06 97.77,53.19 v2(97.48,53.48)
  BOTTOM w0.102: v2(102.8,53.21) 103.06,53.48 106.16,53.48 107.27,52.36 107.74,52.36 R577.2 ; U30.AF9 96.97,53.99 v2(97.48,53.48)
CLK_PCIE_VGA_P: length 67
  IN1 w0.089: v2(102.68,110.87) 102.86,110.69 102.86,110.05 101.79,108.99 101.79,107.84 101.53,107.59 101.53,106.06 101.69,105.9 101.69,98.99 102.98,97.69 102.98,93.03 102.47,92.53 102.47,90.36 103.69,89.14 103.69,88 106.26,85.43 106.26,81.84 109.21,78.9 109.21,75.21 110.48,73.94 110.48,71.06 111.99,69.54 111.99,65.95 112.51,65.43 112.51,64.43 v1(112.2,64.12)
  BOTTOM w0.102: R575.1 108.36,52.67 108.48,52.55 108.76,52.55 108.99,52.78 108.99,58.17 111.73,60.91 111.73,63.12 112.43,63.81 112.43,64.02 112.33,64.12 v1(112.2,64.12) ; U25.AV33 102.8,110.74 v2(102.68,110.87)
CLK_PCIE_VGA_P_R: length 12.5
  IN3 w0.089: v2(102.8,53.85) 102.58,53.63 101.08,53.63 100.52,53.07 98.05,53.07 97.97,53.15 97.97,53.37 98.08,53.48 v2(98.24,53.48)
  BOTTOM w0.102: U30.AF8 97.7,53.8 98.03,53.48 v2(98.24,53.48) ; R575.2 107.91,52.69 107.8,52.58 107.36,52.58 106.25,53.7 102.97,53.7 102.97,53.69 102.95,53.69 v2(102.8,53.85)
CLK_PCIE_WLANN: length 104.8
  IN1 w0.089: v1(111.95,48.85) 112.15,49.05 112.64,49.05 113.22,48.47 113.22,42.15 113.07,42 113.07,37.32 113.65,36.73 113.65,31.4 114.79,30.25 114.79,26.57 116.08,25.28 118.9,25.28 119.54,24.65 120.27,24.65 122.54,22.38 122.54,18.06 122.84,17.77 124.27,17.77 124.6,18.1 132.92,18.1 133.45,17.56 136.94,17.56 137.4,17.11 146.06,17.11 147.05,18.1 147.69,18.1 148.78,17 175.21,17 178.41,20.2 178.98,20.2 179.13,20.05 179.13,19.89 v1(178.88,19.64)
  BOTTOM w0.102: R584.1 110.94,49.05 111.75,49.05 v1(111.95,48.85) ; v1(178.88,19.64) 179.08,19.43 179.08,19.06 179.39,18.76 180.94,18.76 181.46,19.28 182.36,19.28 182.52,19.13 CN11.49
CLK_PCIE_WLANN_R: length 10.9
  BOTTOM w0.102: U30.AJ4 100.64,51.47 101.34,51.18 101.56,51.18 101.68,51.29 101.94,51.29 102.22,51.01 104.74,51.01 106.48,49.27 108.75,49.27 108.89,49.14 109.78,49.14 109.88,49.05 110.13,49.05 110.2,48.98 R584.2
CLK_PCIE_WLANP: length 104.8
  IN1 w0.089: v1(179.51,19.64) 179.34,19.81 179.34,20.14 179.06,20.41 178.33,20.41 175.13,17.21 148.86,17.21 147.77,18.3 146.97,18.3 145.98,17.31 137.48,17.31 137.03,17.77 133.54,17.77 133.01,18.3 124.51,18.3 124.18,17.97 122.92,17.97 122.74,18.15 122.74,22.47 120.36,24.85 119.62,24.85 118.98,25.49 116.17,25.49 115,26.66 115,30.34 113.85,31.48 113.85,36.82 113.27,37.4 113.27,41.91 113.42,42.07 113.42,48.55 112.72,49.25 112.18,49.25 v1(111.95,49.48)
  BOTTOM w0.102: R583.1 111.03,49.26 111.73,49.26 v1(111.95,49.48) ; v1(179.51,19.64) 179.3,19.43 179.3,19.15 179.48,18.97 180.85,18.97 181.37,19.5 182.39,19.5 182.52,19.63 CN11.47
CLK_PCIE_WLANP_R: length 10.9
  BOTTOM w0.102: R583.2 110.2,49.34 110.12,49.26 109.97,49.26 109.87,49.36 108.98,49.36 108.84,49.49 106.56,49.49 104.83,51.23 102.31,51.23 102.03,51.51 101.83,51.51 101.52,51.81 101.27,51.81 101.15,51.69 101.15,51.56 101.21,51.49 U30.AJ2
CLKA0: length 28.8
  TOP w0.102: R49.2 141.95,113.22 141.85,113.12 141.16,113.12 140.5,113.78 140.5,113.9 v1(140.78,114.18) 140.47,114.49 140.47,114.65 140.27,114.86 138.7,114.86 137.89,115.67 132.36,115.67 128.73,112.04 123.24,112.04 122.01,110.81 122.01,109.59 121.77,109.35 120.56,109.35 120.32,109.11 120.32,108.94 v1(120.08,108.69)
  BOTTOM w0.102: v1(120.08,108.69) 120.4,109.01 U25.E31 ; VRAM1.J12 v1(140.78,114.18)
CLKA0B: length 29.1
  TOP w0.102: v1(120.81,108.66) 120.6,108.66 120.54,108.72 120.54,108.99 120.7,109.16 121.85,109.16 122.2,109.51 122.2,110.73 123.32,111.85 128.81,111.85 132.44,115.48 137.81,115.48 138.62,114.67 140.19,114.67 140.28,114.58 140.28,114.44 v1(140.02,114.18) 140.31,113.89 140.31,113.7 141.08,112.93 141.85,112.93 141.95,112.83 R51.2
  BOTTOM w0.102: VRAM1.J11 140.38,114.08 140.28,114.18 v1(140.02,114.18) ; U25.D31 120.9,109.22 120.67,108.99 120.67,108.81 v1(120.81,108.66)
CLKA1: length 32.4
  TOP w0.102: v1(120.97,95.48) 121.07,95.58 121.07,95.8 121.17,95.9 121.93,95.9 122.43,95.41 122.43,94.65 124.44,92.63 125.03,92.63 127.07,90.59 129.41,90.59 129.92,90.08 129.92,88.68 132.21,86.39 132.21,85 134.04,83.16 138.81,83.16 140.48,84.82 140.48,85.09 v1(140.78,85.39) 140.68,85.5 140.68,85.64 140.87,85.83 141.15,85.83 141.39,85.59 141.39,85.09 141.6,84.87 141.85,84.87 141.95,84.77 R127.2
  BOTTOM w0.102: U25.D7 121.2,95.72 v1(120.97,95.48) ; VRAM2.J12 v1(140.78,85.39)
CLKA1B: length 32.9
  TOP w0.102: v1(120.95,96.52) 120.97,96.52 121.07,96.42 121.07,96.19 121.17,96.09 122.01,96.09 122.62,95.49 122.62,94.73 124.52,92.82 125.11,92.82 127.15,90.78 129.49,90.78 130.11,90.16 130.11,88.76 132.4,86.47 132.4,85.08 134.12,83.35 138.73,83.35 140.29,84.9 140.29,85.09 v1(139.98,85.39) 140.33,85.74 140.43,85.74 140.73,86.05 141.2,86.05 141.58,85.67 141.58,85.16 141.68,85.06 141.85,85.06 141.95,85.16 R125.2
  BOTTOM w0.102: U25.D9 121.2,96.62 121.1,96.52 v1(120.95,96.52) ; VRAM2.J11 140.38,85.52 140.25,85.39 v1(139.98,85.39)
CLKRUN#: length 115.1
  TOP w0.102: U15.93 180.35,26.96 180.15,27.16 180.15,28.31 180.53,28.69 v1(181.21,28.69)
  IN2 w0.089: v1(181.21,28.69) 180.47,29.43 172.58,29.43 171.35,30.66 170.34,30.66 169.91,31.09 169.91,31.71 169.13,32.49 169.13,32.93 168.47,33.59 166.36,33.59 166.18,33.76 159.89,33.76 159.73,33.92 159.27,33.92 158.99,33.64 157.67,33.64 156.94,34.37 155.19,34.37 153.15,36.41 148.39,36.41 147.46,35.48 146.12,35.48 144.02,33.39 141.49,33.39 139.52,31.42 137.95,31.42 136.59,30.05 136.59,29.07 136.21,28.69 135.7,28.69 135.32,29.07 133.32,29.07 132.91,28.66 129.97,28.66 129.67,28.36 128.79,28.36 128.13,29.02 120.38,29.02 119.44,29.96 112.84,29.96 111.57,28.69 109.03,28.69 107.73,27.39 106.39,27.39 106.11,27.67 104.33,27.67 103.44,28.56 99.25,28.56 98.49,29.32 96.96,29.32 94.54,31.75 94.05,31.75 93.08,32.73 93.08,38.09 v2(93.53,38.54)
  BOTTOM w0.089: 93.59,39.69 93.98,39.29
  BOTTOM w0.099: 93.59,39.69 93.59,40.6 U30.BD13
  BOTTOM w0.102: R618.1 94.17,36.31 93.53,36.94 v2(93.53,38.54) 93.98,38.99 93.98,39.29
CLR_CMOS: length 82
  TOP w0.102: Q16.2 104.31,32.87 104.19,32.75 R262.1 104.7,31.48 105.73,31.48 105.98,31.23 105.98,30.85 107.25,29.58 v1(107.25,27.8) ; v1(168.18,21.88) 168.06,21.88 167.13,20.96 U15.19
  IN1 w0.089: v1(107.25,27.8) 107.4,27.65 107.4,24.09 112.58,18.91 v1(114.36,18.91)
  IN2 w0.089: v1(114.36,18.91) 115.15,18.12 123.61,18.12 124.22,18.73 133.03,18.73 134.25,19.95 134.97,19.95 135.29,19.63 135.91,19.63 136.47,20.19 140.8,20.19 142.31,21.7 144.67,21.7 146.29,23.33 155.79,23.33 157.87,21.25 162.14,21.25 163.3,22.4 165.61,22.4 166.75,21.26 167.56,21.26 v1(168.18,21.88)
CODEC_VREF: length 2.4
  BOTTOM w0.203: U35.28 206.97,27.66 207.36,28.05 v1(207.51,28.05) 207.96,28.05 C651.2
CORE_PWM_PROCHOT#: length 178.3
  TOP w0.102: PR53.1 154.25,49.64 154.12,49.52 153.95,49.52 153.44,49.01 151.83,49.01 150.05,47.23 146.24,47.23 145.73,46.72 145.73,45.71 147.31,44.13 147.31,40.04 145.12,37.86 143.6,37.86 143.19,37.45 143.19,35.93 142.56,35.29 142.56,34.91 141.03,33.39 141.03,31.61 v1(140.37,30.95) 138.95,30.95 v1(138.9,30.9) 138.9,30.47 138.72,30.28 PR81.2 ; v1(158.3,26.15) 157.8,25.64 157.8,23.74 158.46,23.08 158.46,22.7 158.74,22.42 159.02,22.42 159.87,21.56 Q35.3
  IN2 w0.089: v1(83.75,77.21) 83.4,77.21 82.48,78.12 82.48,79.23 82.74,79.49 84.77,79.49 85.41,80.12 85.41,80.63 85.66,80.89 85.66,83.17 85.91,83.43 85.91,84.82 86.93,85.84 93.41,85.84 93.66,85.58 93.66,84.7 93.91,84.44 94.55,84.44 94.85,84.75 100.68,84.75 101.37,84.06 102.17,84.06 102.8,84.7 106.79,84.7 107.36,84.13 v1(107.36,84.11)
  IN3 w0.089: v1(158.3,26.15) 158.15,26 154.74,26 154.32,26.41 143.34,26.41 142.81,26.94 142.81,27.7 139.79,30.72 139.08,30.72 v1(138.9,30.9) 138.9,30.95 139,31.05 139,35.29 136.98,37.31 132.52,37.31 132.45,37.38 131.98,37.38 131.25,38.11 130.22,38.11 128.46,39.86 125.74,39.86 123.33,42.28 123.33,63.16 124.78,64.6 124.78,67.8 123.68,68.9 123.68,71.46 122.78,72.36 118.18,72.36 114.36,76.19 114.36,77.56 112.56,79.36 110.81,79.36 108.14,82.03 108.14,83.33 v1(107.36,84.11)
  BOTTOM w0.102: U30.B25 82.93,72.96 82.93,73.58 83.11,73.76 83.11,76.57 v1(83.75,77.21) 83.55,77.41 R562.1
CSA0B_0: length 28.1
  TOP w0.127: v1(141.58,115.01) 141.11,115.48 139.2,115.48 138.11,116.57 138.11,116.83 137.86,117.08 132.37,117.08 v1(131.32,116.03) 129.72,114.43 128.62,114.43 127.39,113.19 123.47,113.19 121.35,111.07 121.35,110.86 120.94,110.45 120.2,110.45 119.98,110.22 119.26,110.22 v1(118.86,109.82)
  BOTTOM w0.102: v1(118.86,109.82) 118.8,109.76 U25.H31
  BOTTOM w0.127: v1(141.58,115.01) 141.58,114.98 VRAM1.G12
CSA1B_0: length 32.1
  TOP w0.102: 120.88,94.68 120.27,95.29 v1(120.27,95.48)
  TOP w0.127: 120.88,94.68 120.99,94.56 120.99,94.39 123.13,92.24 123.13,91.87 125.99,89.01 128.46,89.01 131.38,86.09 131.38,84.77 134.38,81.77 v1(141.39,81.77)
  BOTTOM w0.102: v1(120.27,95.48) 120.4,95.62 U25.E7
  BOTTOM w0.127: VRAM2.L12 141.54,84.56 141.54,81.92 v1(141.39,81.77)
CSCL: length 1.9
  BOTTOM w0.102: R540.2 19.93,82.44 19.59,82.1 19.59,81.78 19.93,81.44 U28.29
CSDA: length 1.5
  BOTTOM w0.102: R539.2 19.37,81.62 19.53,81.45 U28.28
CTL2: length 2.2
  TOP w0.102: R193.2 23.51,48.88 23.51,48.88 v1(23.07,48.88) U10.7
CTL3: length 2.8
  TOP w0.102: R190.2 23,50.68 v1(22.69,50.38) 22.69,49.66 22.41,49.38 U10.8
DBGDATA_0: length 7.6
  BOTTOM w0.102: R476.2 R490.2 120.2,118.6 120.05,118.45 119.27,118.45 117.18,116.37 117.18,114.9 117.5,114.57 U25.L40
DBGDATA_1: length 10.1
  BOTTOM w0.102: R477.2 R491.2 123.58,118.6 v1(123.12,119.06) 122.29,118.22 119.36,118.22 117.5,116.36 U25.L41
DBGDATA_2: length 8.4
  BOTTOM w0.102: U25.M40 116.95,114.23 116.65,114.54 116.65,114.82 116.72,114.9 116.72,116.56 118.78,118.61 118.78,120 119.09,120.31 R463.2 R454.2
DBGDATA_3: length 6
  BOTTOM w0.102: U25.M41 116.95,116.46 119.09,118.6 R487.2 R473.2
DBGDATA_4: length 6.5
  BOTTOM w0.102: U25.N40 116.4,114.58 116.08,114.9 116.08,116.56 118.27,118.75 R486.2 R472.2
DBGDATA_5: length 7.3
  BOTTOM w0.102: R453.2 R462.2 118.27,120.31 118.55,120.03 118.55,118.71 116.4,116.56 U25.N41
DBGDATA_6: length 8.8
  BOTTOM w0.102: v1(116.88,122.06) 116.3,121.48 R452.2 R461.2 116.3,120.42 116.01,120.14 116.01,118.35 115.61,117.94 115.61,114.87 115.53,114.79 115.53,114.57 115.85,114.24 U25.P40
DBGDATA_7: length 5.3
  BOTTOM w0.102: U25.P41 115.85,117.81 116.3,118.25 R485.2 R471.2
DBRDY1: length 6.7
  BOTTOM w0.102: CN7.15 120.08,42.28 120.46,41.9 120.46,40.25 119.03,38.82 R603.2
DBRDY2: length 4.1
  TOP w0.102: v1(119.82,43.67) R216.2
  BOTTOM w0.102: CN7.13 119.7,43.55 v1(119.82,43.67)
DBRDY3: length 4.4
  TOP w0.102: v1(119.82,44.31) 119.7,44.44 v1(118.43,44.44) R209.2
  BOTTOM w0.102: v1(119.82,44.31) 119.31,44.82 CN7.11
DC-DET: length 3.5
  TOP w0.102: v1(198.69,25.13) R304.1 R315.1
  BOTTOM w0.102: U35.4 199.34,25.66 198.82,25.13 v1(198.69,25.13)
DCIN_ENB: length 2.9
  TOP w0.102: v1(21.93,74.26) 21.93,75.57 21.65,75.86 R165.1
  BOTTOM w0.178: U28.3 v1(21.93,74.26)
DDBIA0_0: length 31.7
  IN3 w0.114: v1(144.78,107.78) 143.76,107.78 141.75,109.79 138.75,109.79 137.47,111.07 132.36,111.07 130.49,112.94 130.49,113.39 129.77,114.11 127.49,114.11 127.23,114.37 122.23,114.37 121.84,113.98 120.15,113.98 119.57,113.4 119.57,113.02 v1(119.05,112.5)
  BOTTOM w0.102: v1(119.05,112.5) 119.03,112.5 U25.J38
  BOTTOM w0.127: VRAM1.D2 144.78,106.98 v1(144.78,107.78)
DDBIA0_1: length 29.2
  IN3 w0.114: v1(120.63,116.87) 121.17,116.87 121.37,116.67 122.46,116.67 123.47,117.68 129.04,117.68 129.52,117.21 130.78,117.21 132.19,115.8 134.99,115.8 135.4,115.39 137.78,115.39 138.25,114.92 139.76,114.92 140.09,114.59 141.97,114.59 142.06,114.67 142.68,114.67 142.94,114.41 143.41,114.41 v1(143.98,114.98)
  BOTTOM w0.102: v1(120.63,116.87) 120.64,116.86 120.64,116.07 120.48,115.91 120.48,114.88 120.58,114.78 120.58,114.56 120.25,114.23 U25.F40
  BOTTOM w0.127: VRAM1.D13 v1(143.98,114.98)
DDBIA0_2: length 16.4
  IN1 w0.114: v1(135.23,116.63) 135.13,116.63 134.96,116.8 134.95,116.8 134.69,117.06 128.46,117.06 v1(127.04,115.63)
  BOTTOM w0.102: v1(127.04,115.63) 126.12,114.72 125.64,114.72 125.18,114.26 125.18,113.76 124.94,113.52 124.45,113.52 124.19,113.27 123.69,113.27 123.49,113.07 U25.A38
  BOTTOM w0.127: VRAM1.P13 135.95,115.81 135.47,115.81 135.23,116.04 v1(135.23,116.63)
DDBIA0_3: length 17.2
  IN1 w0.114: v1(125.04,107.83) 125.73,107.15 130.64,107.15 131.82,105.97 131.82,105.44 132.7,104.56 134.35,104.56 134.72,104.93 134.72,105.03 134.82,105.12 134.98,105.28 135.17,105.28 135.64,105.76 135.64,105.82 v1(136,106.18)
  BOTTOM w0.102: U25.B30 122.49,108.67 122.79,108.37 123.12,108.37 123.27,108.51 124.36,108.51 v1(125.04,107.83)
  BOTTOM w0.127: v1(136,106.18) 136,106.21 VRAM1.P2
DDBIA1_0: length 23.2
  IN3 w0.114: v1(124.7,105.07) 124.75,105.07 125.21,104.6 126.52,104.6 126.88,104.23 130.6,104.23 135.57,99.26 135.57,95.5 134.72,94.65 134.72,94.3 134.96,94.06 135.3,94.06 v1(135.95,93.41)
  BOTTOM w0.102: U25.B25 122.85,105.92 123.18,105.6 123.86,105.6 124.39,105.07 v1(124.7,105.07)
  BOTTOM w0.127: v1(135.95,93.41) 136.37,92.99 VRAM2.D2
DDBIA1_1: length 30.7
  IN3 w0.114: v1(124.78,101.22) 124.35,100.79 123.96,100.79 122.78,99.62 122.78,94.79 124.62,92.95 125.13,92.95 126.48,91.6 126.48,89.18 132.49,83.17 135.36,83.17 v1(135.99,83.81)
  BOTTOM w0.102: U25.B18 122.51,102.07 122.85,101.74 123.07,101.74 123.18,101.84 123.43,101.84 123.66,101.61 124.38,101.61 v1(124.78,101.22)
  BOTTOM w0.127: VRAM2.D13 v1(135.99,83.81)
DDBIA1_2: length 24.5
  IN1 w0.114: v1(143.96,92.57) 142.64,93.89 142.24,93.89 141.33,94.8 138.63,94.8 136.92,96.51 128.49,96.51 v1(127.55,97.45)
  BOTTOM w0.102: U25.A12 123.52,98.77 123.93,98.36 124.63,98.36 125.95,97.05 127.15,97.05 v1(127.55,97.45)
  BOTTOM w0.127: VRAM2.P2 v1(143.96,92.57)
DDBIA1_3: length 28.1
  IN1 w0.114: v1(125.54,91.48) 126.45,90.57 131.22,90.57 132.94,88.85 133.58,88.85 134.17,88.25 134.98,88.25 135.95,87.28 135.95,86.98 136.67,86.26 137.56,86.26 137.98,85.84 137.98,85.25 138.26,84.98 141.53,84.98 141.82,84.7 142.52,84.7 143.02,84.2 143.58,84.2 v1(143.98,83.79)
  BOTTOM w0.102: v1(125.54,91.48) 125.23,91.78 125.23,93.56 124.45,94.35 123.8,94.35 123.57,94.58 123.2,94.58 122.95,94.83 122.7,94.83 U25.B5
  BOTTOM w0.127: VRAM2.P13 v1(143.98,83.79)
DDR4_SUSON_2V5: length 196.4
  TOP w0.102: v1(170.17,28.45) 169.62,29 U15.122
  IN1 w0.089: v1(67.4,125.55) 66.31,125.55 64.94,124.18 64.94,120.65 65.85,119.74 65.85,118.6 64.58,117.33 64.58,116.19 64.07,115.68 v1(64.07,115.05)
  IN3 w0.089: v1(170.17,28.45) 169.68,28.94 165.42,28.94 165.19,29.17 163.54,29.17 162.77,28.41 159.56,28.41 158.75,27.6 158.75,27.01 158.3,26.55 157.14,26.55 156.78,26.2 154.81,26.2 154.4,26.61 144.43,26.61 141.16,29.87 141.16,32.75 141.87,33.46 141.87,35.18 141.5,35.56 139.01,35.56 137,37.57 132.06,37.57 131.33,38.3 130.3,38.3 128.48,40.12 125.92,40.12 124.39,41.64 124.39,45.33 123.53,46.19 123.53,63 124.97,64.43 124.97,67.42 125.21,67.66 125.21,72 124.65,72.56 118.27,72.56 117.05,73.77 117.05,76.29 116.89,76.45 115.75,76.45 112.58,79.62 110.83,79.62 108.39,82.06 108.39,88.48 106.61,90.26 106.61,91.74 105.63,92.71 102.97,92.71 100.67,95.01 99.98,95.01 98.72,96.27 97.72,96.27 96.93,97.06 93.58,97.06 93.03,96.51 89.19,96.51 88.96,96.28 78.38,96.28 76.24,98.41 76.24,103.04 74.95,104.34 74.95,106.96 74.61,107.3 74.61,108.46 74.05,109.02 72.02,109.02 70.74,110.3 70.74,111.44 69.64,112.55 67.59,112.55 66.74,113.4 65.72,113.4 v1(64.07,115.05)
  BOTTOM w0.203: PR120.1 67.11,125.26 v1(67.4,125.55)
DE1: length 4.5
  TOP w0.102: U18.9 207.84,15.87 207.41,15.44 207.41,15.16 207.1,14.85 206.21,14.85 205.96,15.1 R390.2 R389.1
DE2: length 4.5
  TOP w0.102: R380.1 205.04,15.99 v1(205.29,15.73) 205.55,15.99 R381.2 205.96,15.83 206.18,15.61 206.59,15.61 206.84,15.86 207.33,15.86 207.83,16.37 U18.8
DEBUG_CLK: length 2
  BOTTOM w0.102: R706.2 192.23,16.85 191.76,16.38 CN11.60
DEBUG_IRQ: length 1.8
  BOTTOM w0.102: R712.2 192.1,15.83 192.05,15.88 CN11.62
DEVSLP0: length 146.9
  IN2 w0.089: v1(206.01,19.32) 205.27,19.32 203.72,17.77 201.87,17.77 200.89,18.74 199.85,18.74 199.57,19.01 197.32,19.01 193.99,22.34 193.99,26.15 193.08,27.06 192.49,27.06 192.26,26.83 191.76,26.83 190.79,27.8 188.66,27.8 187.51,28.94 187.51,30.09 185.48,32.12 181.77,32.12 180.4,30.75 176.81,30.75 176.13,31.42 173.92,31.42 173.16,32.18 171.18,32.18 170.71,32.64 170.71,33.32 168.79,35.24 166.74,35.24 166.53,35.44 163.94,35.44 163.21,34.71 160.28,34.71 160.08,34.91 158.91,34.91 158.59,34.59 158.07,34.59 157.34,35.32 155.63,35.32 152.97,37.98 151.15,37.98 148.89,40.25 148.27,40.25 147.76,39.74 139.4,39.74 138.25,38.59 131.76,38.59 131.44,38.91 129.43,38.91 127.23,41.11 119.72,41.11 119.19,41.64 119.19,46.47 120.33,47.61 120.33,48.75 117.31,51.78 114.72,51.78 112.96,50.02 112.96,48.37 112.38,47.79 111.64,47.79 111.31,48.12 111.31,50.91 110.6,51.62 108.6,51.62 107.5,50.53 103.69,50.53 103.31,50.91 101.79,50.91 100.77,51.93 96.07,51.93 v2(95.69,51.55)
  BOTTOM w0.102: R693.1 205.55,19.52 205.42,19.39 v1(205.42,19.04) 205.45,19.01 205.7,19.01 v1(206.01,19.32) ; U30.AK10 95.69,51.4 v2(95.69,51.55)
DEVSLP1: length 99.4
  TOP w0.102: v1(50.73,25.77) 50.23,25.26 50.23,22.36 48.8,20.93 v1(47.29,20.93) 46.88,20.93 46.19,21.63 43.8,21.63 43.08,20.91 42.7,20.91 42.34,20.55 42.34,16.47 40.98,15.11 36.79,15.11 34.86,13.18 34.86,12.31 35.62,11.54 35.62,9 34.78,8.16 34.78,6.63 34.18,6.03 32.83,6.03 R430.1 32.24,5.01 32.35,4.89 D25.1
  IN2 w0.089: v1(92.64,29.07) 91.53,27.95 84.54,27.95 83.75,27.16 66.41,27.16 65.01,25.77 62.04,25.77 61.78,26.02 55.81,26.02 55.56,25.77 52,25.77 51.5,26.28 51.24,26.28 v1(50.73,25.77)
  IN3 w0.089: v1(92.64,29.07) 93.53,29.96 96.2,29.96 96.84,30.59 96.84,32.24 97.45,32.85 97.45,38.19 98.94,39.69 v2(99.68,39.69)
  BOTTOM w0.102: v2(99.68,39.69) 99.2,40.17 99.2,40.9 U30.BC6
DEVSLP_HDD: length 10.9
  BOTTOM w0.102: Q39.1 206.88,17.98 206.49,17.59 v1(206.49,17.26) 206.93,16.81 207.14,16.81 207.53,16.42 207.53,15.86 208.8,14.59 209.99,14.59 210.09,14.69 R715.2 210.76,14.97 R718.2 211.27,14.85 211.53,15.11 R717.1 213.19,14.32 HD1.5
DEW1: length 11.9
  TOP w0.102: U18.16 212.77,15.37 213.04,15.1 213.04,15.1 v1(213.14,15) 212.71,14.56 v1(212.71,14.49) ; R410.1 205.17,12.69 v1(205.42,12.43) 205.67,12.69 R411.2
  IN3 w0.089: v1(213.14,15) 212.05,15 211.58,14.53 208.76,14.53 207.05,12.81 205.8,12.81 v1(205.42,12.43)
DEW2: length 3.8
  TOP w0.102: R364.1 205.6,17.44 205.67,17.51 R365.2 205.96,17.83 206.27,18.15 v1(207.2,18.15) 207.98,17.37 U18.6
DGPU_DP_HPD: length 10.6
  BOTTOM w0.102: U25.AV25 102.48,105.6 101.97,105.6 101.88,105.69 101.6,105.69 101.51,105.6 101.28,105.6 101.18,105.7 100.92,105.7 100.8,105.57 100.32,105.57 98.98,104.24 98.98,102.46 97.34,100.82 96.84,100.82 96.33,100.32 TP49.1
DGPU_OPP#: length 160.3
  TOP w0.102: U15.71 180.53,18.16 180.05,18.63 177.8,18.63 177.4,19.03 177.4,19.79 176.85,20.35 176.85,21.58 176.21,22.21 176.21,24.69 177.86,26.34 177.86,26.78 180.27,29.2 v1(180.27,29.6) 180.27,29.73 v1(181.04,30.49) ; R43.2 v1(128.59,120.38) 128.56,120.41 R33.1 R34.2 129.25,120.99 129.73,120.51 129.73,120.26 129.98,120 130.49,120 130.74,120.26 D1.1
  IN2 w0.089: v1(128.59,120.38) 129.22,119.75 138.36,119.75 139.63,118.48 144.46,118.48 144.71,118.22 146.87,118.22 148.78,116.32 148.78,77.2 149.37,76.61 149.37,63.02 150.26,62.12 150.26,60.81 151.27,59.8 151.27,56.81 152.06,56.01 152.61,54.68 152.61,49.91 151.76,49.06 151.76,46.93 150.75,45.91 150.75,44.55 v1(150.63,44.44)
  IN3 w0.089: v1(150.63,44.44) 150.68,44.44 151.09,44.03 151.09,39.33 152.41,38.01 153.86,38.01 157.26,34.61 164.6,34.61 166.33,36.33 167.42,36.33 168.98,34.77 171.73,34.77 172.88,33.62 173.72,33.62 176.36,30.97 180.55,30.97 v1(181.04,30.49)
DGPU_PW_CTRL#: length 12.7
  IN2 w0.089: v2(92.07,42.97) 92.64,42.4 92.64,41.54 92.8,41.39 92.8,39.53 92.31,39.05 92.31,33.69 91.91,33.29 v2(91.91,33.26)
  BOTTOM w0.102: U30.AW14 92.38,43.29 v2(92.07,42.97) ; R648.2 R643.1 92.15,33.02 v2(91.91,33.26)
DGPU_PWREN: length 81.5
  TOP w0.102: v1(111.95,72.25) 110.78,71.08 105.09,71.08 103.29,72.88 93.03,72.88 92.52,73.39 92.52,74.03 v1(91.25,75.3) ; R302.1 90.97,25.89 90.94,25.92 90.94,29.81 90.61,30.14 90.61,32.09 v1(90.28,32.42) 90.74,32.88 90.74,36.82 91.37,37.45 91.37,38.98 90.87,39.48 90.87,41.64 90.59,41.92 90.59,43.35 v2(90.97,43.74)
  IN3 w0.089: v1(91.25,75.3) 91.12,75.17 91.12,73.57 90.54,72.99 90.54,66.28 90.1,65.85 90.1,64.65 90.08,64.63 90.08,63.11 89.98,63 89.98,62.06 90.08,61.96 90.08,58 91.76,56.32 91.76,50.15 91.63,50.02 91.63,44.44 90.97,43.78 v2(90.97,43.74)
  BOTTOM w0.102: v2(90.97,43.74) 91.23,43.99 U30.AV15 ; PR239.2 112.77,74.44 112.6,74.27 PR238.2 110.96,74.27 PR240.1 111.44,73.48 111.44,72.76 v1(111.95,72.25)
DGPU_PWREN_R: length 22.3
  IN1 w0.089: v1(118.82,87.87) 118.53,87.59 118.27,87.59 114.49,83.81 v1(114.49,82.41)
  BOTTOM w0.102: v1(114.49,82.41) 114.74,82.16 114.74,80.91 113.19,79.36 110.04,79.36 109.72,79.04 PQ28.2 109.72,78.11 v1(110.42,77.41) 110.93,76.9 111.31,76.9 112.03,76.18 PC198.2 PR236.1 113.22,75.18 113.09,75.05 PR239.1 ; PR222.1 v1(118.82,87.87)
DGPU_PWROK: length 96.5
  IN1 w0.089: v1(147.58,63.76) 148.3,63.76 148.52,63.54 148.52,62.65 147.46,61.58 147.46,60.49 148.52,59.42 149.54,59.42 150.18,58.79 150.18,56.45 149.99,56.26 149.17,56.26 148.27,55.36 148.27,51.93 146.87,50.53 146.87,49.64 146.37,49.14 146.37,48.5 145.35,47.48 144.84,47.48 143.7,46.34 143.7,44.44 145.1,43.04 145.1,41.64 145.6,41.13 145.6,38.98 v1(145.1,38.47)
  IN2 w0.089: v1(145.1,38.47) 144.97,38.59 139.06,38.59 137.73,37.26 132.84,37.26 131,35.42 127.67,35.42 126.99,36.1 124.73,36.1 124.17,36.66 124.17,38.06 123.99,38.24 122.97,38.24 122.24,38.98 119.06,38.98 117.16,40.88 117.16,42.48 117.11,42.53 117.11,45.63 116.39,46.34 115.73,46.34 113.19,43.8 111.19,43.8 110.55,44.44 108.27,44.44 107.17,43.34 105.6,43.34 105.17,42.91 104.71,42.91 102.36,45.26 101.03,45.26 100.33,45.96 98.36,45.96 98.09,46.23 v2(97.06,46.23)
  BOTTOM w0.102: v2(97.06,46.23) 96.72,45.89 U30.AT10
  BOTTOM w0.152: v1(147.58,63.76) 147.58,63.04 148.06,62.55 PR247.1
  BOTTOM w0.203: PR247.1 148.19,62.27 148.25,62.32 PR246.2
DGPUT_CLK: length 12
  IN3 w0.089: v1(109.66,125.46) 110.35,124.78 112.14,124.78 112.23,124.69 112.23,122.85 112.03,122.64 110.27,122.64 109.66,122.03 109.66,121.12 v1(109.18,120.64)
  BOTTOM w0.102: v1(109.18,120.64) 109.18,120.86 109.03,121.02 R456.1 R447.1 ; Q29.1 109.42,124.72 109.66,124.95 v1(109.66,125.46)
DGPUT_CLK_R: length 11.7
  TOP w0.102: v1(101.97,117) 102.42,117.46 104.76,117.46 105.93,118.63 107.07,118.63 v1(107.25,118.81)
  BOTTOM w0.102: U25.AW40 102.1,114.55 102.42,114.87 102.42,115.18 102.13,115.47 102.13,116.84 v1(101.97,117) ; R456.2 107.88,120.61 107.88,119.75 107.68,119.54 107.68,119.24 v1(107.25,118.81)
DGPUT_DATA: length 3.1
  BOTTOM w0.102: Q29.4 107.65,123.42 107.79,123.27 v1(107.79,122.59) 107.79,121.84 R446.1 R455.1
DGPUT_DATA_R: length 10.9
  TOP w0.102: v1(107.25,119.44) 106.79,118.99 105.78,118.99 104.63,117.84 102.17,117.84 101.53,117.21 101.53,116.8 101.66,116.67 v1(101.66,116.45)
  BOTTOM w0.102: v1(107.25,119.44) 107.66,119.85 107.66,120.43 107.28,120.81 R455.2 ; v1(101.66,116.45) 101.93,116.18 101.93,115.15 U25.AW41
DIECRACKMON: length 7.1
  BOTTOM w0.102: U25.B2 123.15,92.58 123.15,91.92 123.38,91.68 123.38,90.92 122.87,90.41 122.87,88.15 TP52.1 123.66,88.13 R530.2
DISP_ON: length 3
  BOTTOM w0.102: U26.4 67.43,90.6 67.25,90.42 R527.1 67.27,90.01 R529.2 v1(66.58,89.01)
DMIC-DATA34: length 0.9
  TOP w0.102: R317.1 200.5,23.83 TP33.1
DMIC_CLK: length 2.5
  BOTTOM w0.102: U35.3 199.45,25.26 198.82,24.62 198.56,24.62 198.28,24.34 R680.1
DMIC_CLK_3V3: length 2.5
  TOP w0.102: U8.3 118.79,50.39 118.27,49.87 R191.2 R189.2 117.38,50.43 v1(117.28,50.53)
DMIC_CLK_L: length 235.2
  TOP w0.102: L1.2 41.85,114.29 42.28,114.72 43.09,114.72 v1(43.22,114.59)
  IN1 w0.089: v1(196.35,22.67) 196.35,23.68 193.73,26.3 193.25,26.3 192.85,25.89 191.28,25.89 190.13,24.75 186.12,24.75 185.48,24.12 184.34,24.12 183.83,24.62 183.83,25.13 183.55,25.41 181.9,25.41 180.61,26.71 178.67,26.71 177,25.03 174.84,25.03 173.82,24.01 167.8,24.01 167.45,24.37 163,24.37 162.65,24.73 157.74,24.73 157.51,24.95 146.95,24.95 146.49,24.5 145.53,24.5 144.93,23.9 139.59,23.9 136.88,26.61 136.88,27.51 136.59,27.8 136.59,29.04 136.13,29.5 135.7,29.5 135.56,29.36 134.42,29.36 134,28.94 132.37,28.94 130.24,31.08 130.24,32.29 128.31,34.22 128.31,35.32 129.11,36.12 129.11,37.45 125.55,41.01 123,41.01 121.47,42.53 121.47,46.72 121.09,47.1 119.82,47.1 119.06,47.87 119.06,52.9 123.25,57.09 123.25,63.49 124.01,64.25 124.01,67.45 123.29,68.18 123.29,70.21 122.68,70.81 116.18,70.81 v1(115.73,71.26)
  IN3 w0.089: v1(43.22,114.59) 42.73,114.11 42.73,113.65 42.99,113.4 47.05,113.4 47.84,114.18 49.44,114.18 51.03,112.6 53.21,112.6 53.4,112.41 57.34,112.41 58.54,111.21 61.85,111.21 65.16,107.91 66.7,107.91 69.11,105.49 69.11,103.94 70.9,102.15 70.9,99.96 77.1,93.76 84.62,93.76 86.54,91.85 89.44,91.85 90.77,90.51 91.79,90.51 93.22,89.08 95.81,89.08 96.51,88.38 97.57,88.38 100.62,85.32 101.83,85.32 102.54,84.61 102.54,81.02 103.38,80.19 105.71,80.19 107.11,78.79 108.12,78.79 110.72,76.19 110.81,76.19 v1(115.73,71.26)
  BOTTOM w0.102: R680.2 197.15,23.99 C659.2 196.53,23.64 196.53,22.85 v1(196.35,22.67)
DMIC_CLK_L_C: length 12.9
  TOP w0.102: R52.2 41.46,112.16 C28.1 41.73,111.5 v1(42.1,111.87)
  IN2 w0.089: v1(40.83,115.43) 41.59,114.67 41.59,112.38 v1(42.1,111.87)
  BOTTOM w0.102: v1(42.1,111.87) 42.61,111.37 42.61,110.68 44.28,109 44.28,108.22 43.72,107.65 CN2.1 ; v1(40.83,115.43) 40.83,115.68 40.08,116.44 L8.1
DMIC_DAT: length 2.7
  BOTTOM w0.102: R685.2 198.28,23.43 198.69,23.84 198.69,24.12 199.43,24.86 U35.2
DMIC_DAT_L: length 230.1
  TOP w0.102: v1(43.22,113.91) 42.83,114.29 L2.2
  IN1 w0.089: v1(116.46,71.26) 116.51,71.21 122.85,71.21 123.68,70.37 123.68,68.34 124.41,67.62 124.41,64.08 124.12,63.79 124.12,57.4 119.45,52.74 119.45,50.21 120.46,49.21 120.46,48.12 120.97,47.61 121.6,47.61 121.98,47.23 121.98,42.79 123.06,41.71 125.41,41.71 129.5,37.61 129.5,35.95 128.71,35.16 128.71,34.38 130.84,32.24 131,32.24 132.65,30.59 132.65,30.09 132.98,29.75 135.39,29.75 135.53,29.89 136.29,29.89 136.98,29.21 136.98,27.96 137.27,27.67 137.27,26.77 139.75,24.29 144.75,24.29 145.36,24.9 146.34,24.9 146.79,25.35 157.68,25.35 157.91,25.12 162.81,25.12 163.17,24.76 167.69,24.76 168.05,24.41 173.66,24.41 174.68,25.42 176.84,25.42 178.51,27.1 180.77,27.1 182.06,25.81 183.71,25.81 184.13,25.39 190.21,25.39 191.46,26.63 192.18,26.63 192.56,27.01 193.21,27.01 193.52,26.69 193.89,26.69 197.42,23.17 v1(197.42,22.08)
  IN3 w0.089: v1(116.46,71.26) 111.02,76.69 110.77,76.69 108.28,79.18 107.28,79.18 104.68,81.77 103.31,81.77 102.93,82.16 102.93,84.77 101.99,85.72 100.79,85.72 97.73,88.77 96.67,88.77 95.97,89.47 93.38,89.47 91.95,90.91 90.93,90.91 89.6,92.24 86.7,92.24 84.77,94.17 77.25,94.17 71.31,100.11 71.31,102.3 69.51,104.1 69.51,105.68 66.86,108.32 65.31,108.32 62.01,111.62 58.69,111.62 57.47,112.84 53.53,112.84 53.38,112.99 51.24,112.99 49.66,114.58 47.68,114.58 47,113.91 v1(43.22,113.91)
  BOTTOM w0.102: v1(197.42,22.08) 197.42,22.97 197.67,23.23 R685.1
DMIC_DAT_L_C: length 13
  TOP w0.102: v1(43.5,110.6) 43.37,110.73 43.37,111.24 43.11,111.5 C29.1 42.84,112.05 R53.2
  IN2 w0.089: v1(43.5,110.6) 42.73,110.6 41.34,112 41.34,114.29 v1(40.83,114.79)
  BOTTOM w0.102: v1(40.83,114.79) 40.46,114.79 L9.1 ; v1(43.5,110.6) 43.5,110.11 44.51,109.1 44.51,108.06 44.22,107.77 CN2.2
DNBSWON#: length 142.4
  TOP w0.102: v1(93.91,29.45) v1(94.52,28.84) R294.1 94.52,23.51 101.53,16.5 v1(102.04,16.5) ; v1(170.93,21.88) 171.36,21.45 171.61,21.45 172.88,20.18 175.15,20.18 176.08,19.25 176.08,18.45 177.25,17.28 178.09,17.28 178.75,16.63 179.14,16.63 180.54,15.23 v1(182.03,15.23) ; v1(173.04,22.97) 173.04,25.64 170.65,28.02 169.99,28.02 169.22,28.79 U15.123
  IN1 w0.089: v2(93.96,45.13) 94.55,44.54 94.55,42.79 94.99,42.34 94.99,38.02 94.09,37.12 94.09,35.5 94.04,35.44 94.04,33.01 93.93,32.9 93.93,29.47 v1(93.91,29.45) ; v1(182.03,15.23) 182.03,15.2 179.77,12.95 168.25,12.95 167.75,12.44 160.08,12.44 158.6,13.92 114.08,13.92 113.18,14.82 103.72,14.82 v1(102.04,16.5)
  IN3 w0.089: v1(170.93,21.88) 171.72,21.88 172.81,22.97 v1(173.04,22.97)
  BOTTOM w0.102: v2(93.96,45.13) 94.42,45.59 U30.AT12
DP_STEREOSYNC: length 7.5
  BOTTOM w0.102: U30.B23 84.9,73 84.9,73.77 85.11,73.98 ; R559.2 R556.2
  BOTTOM w0.112: 85.11,73.98 85.11,75.3 87.18,77.38 87.18,78.22 87.41,78.44 R559.2
DPB_DDCCLK: length 105.4
  TOP w0.102: Q6.4 18.46,84.48 R129.2 18.51,83.52 18.73,83.3 19.24,83.3 20,84.06 20.38,84.06 21.14,84.82 v1(21.14,88.25) v1(21.78,88.89)
  IN1 w0.089: v1(21.78,88.89) 29.02,96.13 46.25,96.13 47.94,97.81 49.6,97.81 51.64,99.85 51.98,99.85 52.89,100.76 57.36,100.76 57.66,100.46 59.13,100.46 59.62,100.95 62.19,100.95 63.56,99.58 65.89,99.58 69.69,95.78 69.69,93.93 72.48,91.14 74.3,91.14 76.51,88.94 81.73,88.94 84.61,86.06 84.61,84.98 85.79,83.8 85.79,83.43 85.53,83.17 85.53,81.77 86.4,80.91 86.4,78.37 86.96,77.81 86.96,76.08 86.29,75.42 86.29,72.63 87.37,71.55 87.37,69.06 v2(87.02,68.71)
  BOTTOM w0.112: U30.J20 87.4,68.39 87.07,68.72 87.04,68.72 87.03,68.71 v2(87.02,68.71)
DPB_DDCDATA: length 99.8
  TOP w0.102: v1(21.78,89.52) 21.52,89.27 R116.2 19.72,88.91 19.76,88.87 Q6.1
  IN1 w0.089: v2(87.01,68.11) 87.04,68.11 87.56,68.63 87.56,71.65 86.5,72.71 86.5,75.25 87.18,75.93 87.18,77.96 86.6,78.55 86.6,80.99 85.76,81.83 85.76,83.02 86.04,83.3 86.04,83.93 84.9,85.08 84.9,86.05 81.81,89.14 76.66,89.14 74.38,91.43 72.58,91.43 69.95,94.06 69.95,95.86 66.01,99.8 63.68,99.8 62.11,101.36 57.97,101.36 57.57,100.96 52.82,100.96 51.9,100.04 51.54,100.04 49.51,98 47.81,98 46.16,96.35 28.98,96.35 22.14,89.52 v1(21.78,89.52)
  BOTTOM w0.112: v2(87.01,68.11) 87.03,68.11 87.51,67.64 U30.K20
DQA0_0: length 34.6
  IN3 w0.114: v1(144.39,104.1) 143.65,103.36 142.45,103.36 142.11,103.69 135.11,103.69 134.68,104.13 134.68,105.13 134.43,105.39 133.8,105.39 133.67,105.52 132.77,105.52 129.03,109.26 127.42,109.26 127.01,109.67 125.73,109.67 124.86,108.8 123.18,108.8 121.79,110.19 119.98,110.19 v1(119.52,110.65)
  BOTTOM w0.102: v1(119.52,110.65) 119.44,110.73 118.93,110.73 118.76,110.91 117.89,110.91 U25.L34
  BOTTOM w0.127: VRAM1.E2 143.96,106.2 143.96,104.53 v1(144.39,104.1)
DQA0_1: length 30.4
  IN3 w0.114: v1(118.02,112.56) 118.6,113.14 118.6,113.68 119.29,114.36 121.68,114.36 122.09,114.77 127.37,114.77 127.65,114.5 129.87,114.5 130.87,113.5 130.87,113.05 132.5,111.42 137.62,111.42 138.84,110.19 141.95,110.19 v1(142.17,109.97)
  BOTTOM w0.102: v1(118.02,112.56) 117.58,112.12 U25.L37
  BOTTOM w0.127: v1(142.17,109.97) 142.34,109.8 142.34,108.62 VRAM1.F4
DQA0_2: length 33.6
  IN3 w0.114: v1(116.93,112.56) 117.41,113.04 117.41,113.32 118.88,114.79 121.58,114.79 121.92,115.14 127.49,115.14 127.79,114.84 130.7,114.84 132.14,113.4 132.14,112.26 132.65,111.76 139.11,111.76 140.12,110.75 141.88,110.75 142.15,110.48 142.43,110.48 142.79,110.11 143.52,110.11 v1(143.52,110.09)
  BOTTOM w0.102: v1(116.93,112.56) 117.29,112.92 U25.L38
  BOTTOM w0.127: v1(143.52,110.09) 143.52,109.62 143.15,109.26 143.15,108.61 VRAM1.E4
DQA0_3: length 30.3
  IN3 w0.114: v1(119.13,111.85) 119.49,111.49 121.09,111.49 121.32,111.26 122.72,111.26 122.85,111.4 129.2,111.4 133.36,107.24 133.99,107.24 134.27,106.96 137.43,106.96 137.97,106.43 137.97,106.01 139.25,104.72 142.63,104.72 v1(142.9,104.45)
  BOTTOM w0.102: U25.J35 v1(119.13,111.85)
  BOTTOM w0.127: v1(142.9,104.45) 142.9,105.11 143.16,105.37 143.16,106.2 VRAM1.F2
DQA0_4: length 31.8
  IN3 w0.114: v1(146.38,105.38) 146.33,105.33 143.06,105.33 142.62,105.77 139.81,105.77 138.91,106.67 138.24,106.67 137.6,107.31 134.93,107.31 134.78,107.45 134.78,108.73 134.08,109.43 131.68,109.43 129.33,111.78 122.6,111.78 122.44,111.62 121.47,111.62 121.22,111.87 120.46,111.87 v1(120.31,112.03)
  BOTTOM w0.102: v1(120.31,112.03) 119.8,112.03 U25.G37
  BOTTOM w0.127: v1(146.38,105.38) 146.38,106.18 145.99,106.58 VRAM1.B2
DQA0_5: length 32.2
  IN3 w0.114: v1(121.07,112.36) 121.19,112.48 122.39,112.48 122.72,112.15 129.45,112.15 131.82,109.78 136.94,109.78 138.01,108.7 138.01,107.66 138.01,107.65 138.01,107.61 138.45,107.17 139.11,107.17 139.63,106.65 142.44,106.65 143.4,105.7 145.81,105.7 146.83,106.71 146.83,107.33 v1(146.38,107.78)
  BOTTOM w0.102: U25.E38 121.07,112.66 v1(121.07,112.36)
  BOTTOM w0.127: VRAM1.B4 v1(146.38,107.78)
DQA0_6: length 36.6
  IN3 w0.114: v1(120.13,110.88) 120.48,110.53 122,110.53 123.22,109.31 124.83,109.31 125.64,110.12 129.47,110.12 133.04,106.55 133.71,106.55 133.95,106.31 133.95,105.91 134.13,105.73 135.85,105.73 137.54,104.04 142.25,104.04 142.59,103.7 143.28,103.7 144.14,104.56 147.32,104.56 147.85,105.09 147.85,107.44 v1(147.68,107.61)
  BOTTOM w0.102: v1(120.13,110.88) 120.4,111.16 U25.E35
  BOTTOM w0.127: VRAM1.A4 147.11,108.18 v1(147.68,107.61)
DQA0_7: length 32.2
  IN3 w0.114: v1(147.42,106.16) 146.83,105.57 146.83,105.18 146.58,104.93 144.02,104.93 143.13,104.04 142.73,104.04 142.39,104.38 139.11,104.38 137.6,105.89 137.6,106.16 137.14,106.62 134.13,106.62 133.85,106.9 133.18,106.9 129.05,111.03 123.02,111.03 122.9,110.91 120.94,110.91 120.86,110.98 v1(120.84,110.98)
  BOTTOM w0.102: U25.D35 120.84,111.06 v1(120.84,110.98)
  BOTTOM w0.127: v1(147.42,106.16) 147.01,106.58 VRAM1.A2
DQA0_8: length 32.7
  IN3 w0.114: v1(145.58,114.98) 145.54,114.98 144.84,115.68 143.9,115.68 143.32,116.27 142.12,116.27 141.99,116.13 139.06,116.13 138.62,116.57 138.62,116.68 137.17,118.13 135.63,118.13 134.89,117.39 132.37,117.39 131.51,118.25 130.08,118.25 129.6,118.74 122.9,118.74 122.26,118.09 121.09,118.09 119.57,116.57 119.14,116.57 118.78,116.22 v1(118.63,116.22)
  BOTTOM w0.102: U25.H41 119.15,114.9 119.11,114.95 119.11,115.73 v1(118.63,116.22)
  BOTTOM w0.127: VRAM1.B13 v1(145.58,114.98)
DQA0_9: length 35.2
  IN3 w0.114: v1(118.6,115.58) 118.17,116.01 118.17,116.45 118.37,116.65 118.7,116.65 118.98,116.93 119.44,116.93 120.95,118.44 122.12,118.44 122.78,119.11 131.13,119.11 131.77,118.47 138.09,118.47 140.09,116.47 141.82,116.47 141.97,116.62 143.47,116.62 144.03,116.06 145.1,116.06 145.22,116.19 145.98,116.19 146.39,115.78 v1(147.18,115.78)
  BOTTOM w0.102: U25.H40 119.15,114.22 118.83,114.54 118.83,114.82 118.91,114.9 118.91,115.28 v1(118.6,115.58)
  BOTTOM w0.127: VRAM1.A13 v1(147.18,115.78)
DQA0_10: length 35.3
  IN3 w0.114: v1(147.18,113.38) 147.18,112.65 145.64,111.11 143.19,111.11 142.91,110.83 142.3,110.83 141.9,111.24 140.12,111.24 139.26,112.1 132.79,112.1 132.48,112.4 132.48,113.54 130.84,115.18 128.15,115.18 127.25,116.09 122.87,116.09 122.77,115.99 121.93,115.99 121.12,115.18 119.49,115.18 119.29,115.38 v1(119.29,116.14)
  BOTTOM w0.102: v1(119.29,116.14) 119.34,116.09 119.34,115.39 U25.G41
  BOTTOM w0.127: v1(147.18,113.38) VRAM1.A11
DQA0_11: length 29.9
  IN3 w0.114: v1(119.77,115.61) 120.99,115.61 121.72,116.33 122.63,116.33 122.77,116.47 127.39,116.47 127.68,116.18 130.35,116.18 133.47,113.06 143.28,113.06 143.44,112.89 145.09,112.89 v1(145.58,113.38)
  BOTTOM w0.102: U25.G40 119.7,114.59 120.03,114.92 120.03,115.35 v1(119.77,115.61)
  BOTTOM w0.127: v1(145.58,113.38) VRAM1.B11
DQA0_12: length 28.2
  IN3 w0.114: v1(143.2,115.79) 142.71,115.3 142.05,115.3 141.93,115.42 138.5,115.42 137.98,115.94 135.34,115.94 135.13,116.14 132.53,116.14 131.13,117.55 129.66,117.55 129.19,118.03 123.31,118.03 122.31,117.03 121.52,117.03 121.13,117.42 v1(121,117.42)
  BOTTOM w0.102: v1(121,117.42) 121.45,116.98 121.45,116.09 121.12,115.76 121.12,114.91 120.94,114.73 120.94,114.46 U25.E40
  BOTTOM w0.127: v1(143.2,115.79) 143.2,115.76 VRAM1.E13
DQA0_13: length 25.7
  IN3 w0.114: v1(122.34,117.69) 122.49,117.69 123.17,118.37 129.33,118.37 129.81,117.89 131.27,117.89 132.12,117.05 135.03,117.05 135.19,117.21 137.6,117.21 138.11,116.7 138.11,116.45 138.78,115.77 142.39,115.77 v1(142.39,115.77)
  BOTTOM w0.102: v1(122.34,117.69) 122.34,117.31 121.75,116.72 121.75,116.11 121.35,115.71 U25.D41
  BOTTOM w0.127: v1(142.39,115.77) VRAM1.F13
DQA0_14: length 25.9
  IN3 w0.114: v1(123.33,116.95) 123.72,117.34 128.9,117.34 129.38,116.86 130.64,116.86 132.04,115.46 134.78,115.46 135.82,114.41 135.82,113.87 135.95,113.74 141.94,113.74 v1(142.38,114.18)
  BOTTOM w0.102: U25.D40 121.35,114.2 121.66,114.5 121.66,114.82 121.58,114.9 121.58,115.64 122.89,116.95 v1(123.33,116.95)
  BOTTOM w0.127: v1(142.38,114.18) 142.78,113.78 VRAM1.F11
DQA0_15: length 25.4
  IN3 w0.114: v1(143.98,113.38) 143.96,113.4 133.62,113.4 130.5,116.52 127.88,116.52 127.47,116.93 v1(124.6,116.93)
  BOTTOM w0.102: v1(124.6,116.93) 123.84,116.17 122.39,116.17 121.78,115.56 121.78,115.2 U25.C41
  BOTTOM w0.127: v1(143.98,113.38) VRAM1.E11
DQA0_16: length 21.3
  IN1 w0.114: v1(122.39,115.56) 122.99,116.06 124.44,116.4 124.74,116.52 127.37,117.99 128,118.22 133.21,118.63 134.59,118.63 135.92,118.14 137.3,117.36 137.6,117.06 138.02,115.5 138.02,114.84 137.73,114.33 v1(137.58,114.18)
  BOTTOM w0.102: v1(122.39,115.56) 122.31,115.07 122.31,114.9 U25.C40
  BOTTOM w0.127: VRAM1.M11 v1(137.58,114.18)
DQA0_17: length 20.1
  IN1 w0.114: v1(137.61,114.98) 137.61,115.55 137.3,115.86 137.3,116.88 137.09,117.08 136.59,117.08 136.28,117.39 135.34,117.39 134.45,118.28 133.85,118.28 133.34,117.77 128.05,117.77 126.76,116.47 125.89,116.47 125.06,115.63 v1(124.52,115.63)
  BOTTOM w0.102: v1(124.52,115.63) 124.52,115.12 123.43,114.03 123.01,114.03 U25.B39
  BOTTOM w0.127: VRAM1.M13 137.98,115.34 v1(137.61,114.98)
DQA0_18: length 16.9
  IN1 w0.114: v1(125.69,115.61) 126.17,116.09 126.91,116.09 128.22,117.4 134.83,117.4 135.09,117.15 135.1,117.15 135.2,117.05 136.12,117.05 136.54,116.63 v1(136.88,116.63)
  BOTTOM w0.102: v1(125.69,115.61) 125.31,115.61 123.38,113.67 U25.A39
  BOTTOM w0.127: v1(136.88,116.63) 136.78,116.53 136.78,115.78 VRAM1.N13
DQA0_19: length 19
  IN1 w0.114: v1(136.78,114.18) 137.19,114.59 137.19,115.43 136.42,116.19 128.33,116.19 127.34,115.19 124.79,115.19 124.14,114.55 v1(124.14,113.85)
  BOTTOM w0.102: U25.B38 122.53,113.07 122.83,113.38 123.1,113.38 123.16,113.32 123.45,113.32 123.61,113.47 123.76,113.47 v1(124.14,113.85)
  BOTTOM w0.127: VRAM1.N11 137.18,113.78 v1(136.78,114.18)
DQA0_20: length 14.7
  IN1 w0.114: v1(134.38,114.98) 133.92,114.52 133.92,114.03 133.54,113.65 132.78,113.65 132.31,114.12 129.58,114.12 128.85,113.39 126.32,113.39 125.98,113.04 124.99,113.04 v1(124.55,112.6)
  BOTTOM w0.102: U25.B36 122.52,111.97 122.85,112.3 123.07,112.3 123.16,112.2 124.15,112.2 v1(124.55,112.6)
  BOTTOM w0.127: VRAM1.T13 v1(134.38,114.98)
DQA0_21: length 12.6
  IN1 w0.114: v1(127.07,113.81) 128.79,113.81 129.6,114.62 133.16,114.62 133.28,114.73 v1(133.28,115.05)
  BOTTOM w0.102: U25.A36 122.98,112 124.52,112 125.77,113.24 126.5,113.24 v1(127.07,113.81)
  BOTTOM w0.127: v1(133.28,115.05) 133.61,115.38 VRAM1.U13
