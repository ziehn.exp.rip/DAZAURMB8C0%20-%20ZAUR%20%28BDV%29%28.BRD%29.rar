# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V3A_BOOT: length 4.1
  BOTTOM w0.356: 147.23,33.77 147.54,34.08 147.54,35.39 v1(147.36,35.57) 147.54,35.75 147.54,37.34 PR312.2
V3A_BOOT_R: length 1.8
  BOTTOM w0.356: PR312.1 148.92,36.6 148.66,36.34 PC263.1
V3A_EN: length 5.2
  TOP w0.102: v1(145.35,33.43) 145.82,33.9 v1(145.86,33.9)
  TOP w0.203: PR71.2 144.52,33.54 144.72,33.34 PC87.2
  TOP w0.254: v1(145.35,33.43) 144.99,33.07 PC87.2 144.4,33.07 143.87,33.59 PR73.2
  BOTTOM w0.229: v1(145.35,33.43) 145.28,33.35 PU13.6
V3A_PWRGD: length 1.4
  BOTTOM w0.203: 144.17,34.86 144.16,34.86 143.71,35.32 PR318.2
  BOTTOM w0.229: PU13.7 144.17,34.86
V3A_VBYP: length 6.5
  TOP w0.305: PR66.2 145.96,34.75 v1(146.29,35.08)
  TOP w0.483: PR63.2 148.74,35.93 148.74,35.13 v1(148.37,34.76) 148.04,34.43 146.7,34.43 146.34,34.79 146.34,35.03 v1(146.29,35.08)
  BOTTOM w0.229: PU13.11 145.97,34.71 146.25,34.99 146.25,35.05 v1(146.29,35.08)
  BOTTOM w0.356: v1(146.29,35.08) 146.29,35.13 146.31,35.15 PC262.1
V3A_VOUT: length 10.8
  TOP w0.305: PR62.2 144.92,36.77 v1(145.25,37.1) 145.6,37.45 145.77,37.45 PR59.2
  BOTTOM w0.152: PR309.1 150,39.61 149.26,38.87 147.25,38.87 146.48,38.1 146.48,37.82 v1(145.98,37.32) 145.76,37.1 v1(145.25,37.1)
  BOTTOM w0.229: v1(145.25,37.1) 145.25,37.1 PC261.2 145.25,36.46 145.73,35.98 145.73,35.16 145.52,34.95 PU13.10
V5P5A_BOOT: length 2.9
  BOTTOM w0.279: PR347.2 42.4,15.62 42.4,17.03 v1(41.92,17.51) 41.92,17.72 42.23,18.02
V5P5A_BOOT_R: length 1.4
  BOTTOM w0.381: PC299.1 41.88,16.02 PR347.1
V5P5A_EN: length 4.9
  TOP w0.203: PR111.2 46.8,18.15 v1(46.67,18.02) 46.46,17.81 v1(45.71,17.81) 45.45,17.81 44.64,17.01 PR113.2
  BOTTOM w0.229: PC298.2 46.18,17.35 v1(45.71,17.81) 45.5,18.02 PU15.6
V5P5A_PWRGD: length 5.9
  BOTTOM w0.102: v1(46.9,12.86) 46.9,13.63 47.21,13.93 PR351.2
  BOTTOM w0.152: PU15.7 45.42,17.46 46.59,16.29 46.77,16.29 46.89,16.18 46.89,14.76 47.21,14.44 PR351.2
V5P5A_VOUT: length 13.3
  BOTTOM w0.152: PR349.2 43.48,14.12 42.68,13.32 v1(42.23,13.32) 41.44,14.11 PR348.2
  BOTTOM w0.203: PU15.10 43.78,16.91 44.22,16.47 44.22,14.45 PR349.2
  BOTTOM w0.229: PR349.2 43.89,13.82 43.6,13.52 43.6,13.09 44,12.69 46.24,12.69 46.39,12.84 PR350.2 46.43,14.16 PC306.2
VBUS_EN: length 19.8
  TOP w0.102: R314.1 25.31,24.8 v1(25.89,25.39) 26.58,24.7 26.58,23.16 25.77,22.34 25.77,20.24 24.89,19.36 24.64,19.36 24.06,18.78 24.06,17.89 25,16.95 25,15.15 24.6,14.75 R405.2 24.45,13.7 23.94,14.21 22.72,14.21 21.57,15.36 U19.15
VBUS_EN_EC_R: length 14.1
  TOP w0.102: v1(23.68,21.58) 23.68,21.96 24.06,22.34 Q18.3 24.06,23.63 v1(24.19,23.76) 24.29,23.86 R314.2
  IN1 w0.089: v1(16.19,24.88) 16.22,24.88 17.42,23.67 21.86,23.67 23.68,21.85 v1(23.68,21.58)
  BOTTOM w0.102: v1(16.19,24.88) 16.62,25.31 17.03,25.31 17.27,25.07 U36.4
VDD08_PG: length 15.2
  TOP w0.203: v2(84.52,116.32) PR19.2 PR20.1
  IN3 w0.089: v2(84.52,116.32) 82.21,116.32 82.08,116.45 81.42,116.45 79.18,118.68 77.79,118.68 76.13,120.34 v2(76.13,120.71)
  BOTTOM w0.102: v1(75.96,122.95) 75.53,122.95 PR128.1 75.13,122.13 76.13,121.12 v2(76.13,120.71)
VDDBT_RTC: length 45.1
  IN2 w0.508: v1(102.3,26.4) 96.96,26.4 94.61,28.75 94.61,29.64 93.98,30.28 93.6,30.28 92.14,31.74 91.63,31.74 91.12,31.23 91.12,30.34 89.47,28.69 84.01,28.69 83.15,27.82 81.44,27.82 81.34,27.72 66.15,27.72 64.83,26.4 v1(64.45,26.4)
  BOTTOM w0.356: U30.AJ11 95.31,51.92 94.95,51.56 94.92,51.56 v2(94.9,51.54)
  BOTTOM w0.508: v1(64.45,26.4) 64.44,26.39 J1.1
  vias: v1(101.74,35.22)
VDDCI_CORE_SENSE: length 65
  TOP w0.203: v1(63.28,115.53) 63.84,116.09 64.22,116.09 64.5,115.81 65.97,115.81 66.41,116.24 67.58,116.24 v1(67.78,116.45) PR18.2
  IN2 w0.254: v1(63.28,115.53) 63.28,115.07 65.21,113.14 65.21,112.13 64.7,111.62 64.7,108.7 65.59,107.81 65.59,106 68.66,102.93 68.66,100.18 75.13,93.71 85.79,93.71 87.95,95.87 88.85,95.87 90.12,97.14 91.76,97.14 93.38,98.77 102.09,98.77 v1(103.16,99.83)
  BOTTOM w0.254: U25.AV13 102.8,99.37 103.16,99.73 v1(103.16,99.83)
VDDP: length 7.5
  BOTTOM w0.508: v1(113.85,66.05) 113.37,66.05 112.84,65.52 111.82,65.52 110.42,64.12 110.42,62.6 109.92,62.09 109.28,62.09 109.15,62.22 R570.2
  vias: v1(104.15,78.09) v1(104.15,77.46) v1(104.96,78.73) v1(104.96,78.09) v1(128.23,37.65) v3(125.51,36.82) v3(126.25,36.82) v3(126.99,36.82) v3(127.72,36.82) v3(128.46,36.82)
VDDP_S5:
  vias: v1(97.9,27.09) v1(125.54,38.42) v1(126.17,38.42) v1(126.81,38.42) v1(127.44,38.42) v3(97.78,28.69) v3(97.78,27.93)
VDDQ_PG: length 2.7
  TOP w0.203: PU1.8 67.5,121.24 67.52,121.27 v1(68.01,121.27)
  BOTTOM w0.102: v1(66.97,122.11) 67.47,121.6 PR134.2 v1(68.01,121.27)
VDDQ_SLP_S4: length 3.8
  TOP w0.229: PU1.11 66.29,123.3 66.4,123.41 66.4,123.42 v1(66.43,123.45)
  BOTTOM w0.203: PR121.2 PR120.2 66.74,124.57 66.6,124.71 PC133.2 66.27,124.24 66.43,124.08 v1(66.43,123.45)
VDDQ_SW: length 1.1
  BOTTOM w0.508: v1(60.15,121.76) 60.15,122.27 PR126.1
  vias: v1(60.51,121.12)
VDDQ_VCC:
  vias: v1(67.7,124.65)
VDDQ_VDDQSNS: length 3.5
  TOP w0.102: PR12.1 67.42,117.69 v1(67.55,117.82) 67.55,118.17 66.85,118.87 PR6.2
  TOP w0.152: PU1.5 66.29,119.53 66.73,119.09 PR6.2
VDDQ_VLDOIN: length 2.7
  BOTTOM w0.102: PC142.1 63.82,121.89 v1(63.99,122.06)
  BOTTOM w0.457: PC142.1 63.82,120.64 63.56,120.38 v1(63.56,119.49)
VDDQ_VTT: length 7
  TOP w0.152: PR5.2 65.64,118.04 65.22,118.04 65,117.82 64.42,117.82 PC21.1
  TOP w0.241: v1(64.2,118.91) 64.22,118.91 64.79,119.48 PU1.2
  TOP w0.381: v1(64.2,118.91) 64.12,118.91 63.96,118.75 PC21.1
  BOTTOM w0.457: v1(64.2,118.91) 64.2,119.01 64.19,119.02 PC143.1 64.19,120.12 65.01,120.94 PR132.1
VDDQ_VTT_CNTL: length 5.3
  TOP w0.229: PU1.10 66.79,122.98 67.03,123.22 67.03,123.42 v1(67.06,123.45)
  BOTTOM w0.203: v1(67.06,123.45) 67.06,123.93 67.34,124.21 68.14,124.21 68.65,124.72 PC132.2 69.16,124.24 v1(69.51,124.24) 69.51,124.62 69.45,124.67 PR122.2
VDDQ_VTTSNS: length 1.1
  TOP w0.152: PR5.1 65.97,119.35 65.79,119.53 PU1.4
VSS_GPU_SENSE: length 26.2
  IN2 w0.254: v1(83.08,92.15) 83.08,92.27 83.88,93.08 85.66,93.08 88.07,95.49 88.97,95.49 90.23,96.76 91.88,96.76 93.53,98.41 95.69,98.41 97.85,96.25 99.25,96.25 100.01,97.01 100.9,97.01 102.68,98.79 v2(103.16,98.79)
  BOTTOM w0.152: v1(83.08,92.15) 83.08,92.13 83.43,91.77 PR209.2
  BOTTOM w0.254: v2(103.16,98.79) 103.6,99.23 U25.AU13
VSS_SENSEA: length 16.6
  IN2 w0.254: v2(85.02,68.87) 85.02,68.89 84.56,69.35 84.56,71.4 85.38,72.22 85.38,78.57 87.06,80.25 87.06,80.38 87.95,81.27 v1(88.45,81.27)
  BOTTOM w0.178: v1(88.45,81.27) 88.36,81.36 R546.1 R543.1
  BOTTOM w0.254: U30.J22 85.02,68.87 v2(85.02,68.87)
2D_ACCEL_INT#: length 9
  BOTTOM w0.102: R591.1 107.81,44.94 107.43,44.56 v1(107.05,44.56) 107.05,44.59 104.48,47.15 103.11,47.15 102.85,47.42 102.85,48.44 102.3,48.99 U30.AM1
2ND_MBCLK: length 236.5
  TOP w0.102: U15.115 172.42,31.49 R260.1 172.3,31.89 172.4,31.99 172.4,32.63 172.45,32.68 172.45,33.21 v1(172.02,33.64) ; v1(93.66,83.55) 93.66,83.43 93.04,82.81 Q7.3
  IN1 w0.089: v1(93.66,83.55) 93.05,84.16 93.05,85.18 91.63,86.6 91.63,88.68 90.92,89.39 90.91,89.39 85.05,95.25 79.93,95.25 76.01,99.17 76.01,102.94 74.74,104.21 74.74,106.03 74.26,106.51 71.59,106.51 70.46,107.64 70.46,114.49 68.49,116.46 68.49,117.29 69.99,118.78 73.29,118.78 75.12,116.95 83.27,116.95 86.03,119.71 90.18,119.71 92.68,117.21 95.31,117.21 96.26,118.16 100.38,118.16 100.86,118.64 101.85,118.64 104.35,121.14 105.01,121.14 106.74,122.87 106.74,124.57 107.17,125 v1(107.17,125.46)
  IN2 w0.089: v1(93.66,83.55) 94.07,83.15 94.52,83.15 95.31,83.93 100.34,83.93 101.03,83.25 102.03,83.25 102.23,83.04 103.77,83.04 104.15,83.43 104.89,83.43 105.08,83.23 109.6,83.23 110.17,82.66 110.73,82.66 v1(111.31,83.25)
  IN3 w0.089: v1(172.02,33.64) 171.82,33.64 171.36,34.1 170.32,34.1 169.98,33.76 160.57,33.76 159.99,33.17 159.99,32.79 159.38,32.18 159,32.18 158.3,31.48 158.3,30.47 156.68,28.84 153.12,28.84 152.67,28.38 146.04,28.38 145.48,28.94 145.48,29.83 146.24,30.59 146.24,31.96 144.84,33.36 144.84,34.66 141.81,37.69 141.81,39.47 140.9,40.37 140.9,44.79 138.99,46.7 135.11,46.7 134.44,47.37 126.04,47.37 125.51,47.89 125.51,60.03 127.4,61.92 127.4,73.13 125.97,74.56 119.07,74.56 119.02,74.61 119.02,77.95 117.92,79.05 117.92,80.12 116.46,81.58 115.7,81.58 115.28,82 113.04,82 111.8,83.25 v1(111.31,83.25)
  BOTTOM w0.102: Q29.6 107.52,124.72 107.63,124.83 107.63,125.34 107.5,125.46 v1(107.17,125.46)
2ND_MBDATA: length 248.1
  TOP w0.102: v1(111.81,123.07) 112.36,123.07 113.12,122.32 113.12,121.3 112.08,120.26 110.3,120.26 109.79,119.75 109.79,116.95 109.54,116.7 108.77,116.7 108.14,117.33 108.14,117.46 v1(107.63,117.97) ; v1(171.18,33.69) 171.59,33.29 171.59,32.57 171.64,32.52 171.64,31.99 171.54,31.89 R259.1 171.49,31.66 171.69,31.66 172.02,31.33 U15.116 ; v1(94.3,83.55) 94.3,83.93 92.85,85.38 92.44,85.38 91.74,84.68 Q7.6
  IN1 w0.089: v1(94.3,83.55) 93.41,84.44 93.41,85.43 92.01,86.83 92.01,88.81 85.23,95.59 80.22,95.59 76.39,99.43 76.39,103.24 75.12,104.51 75.12,106.29 74.38,107.02 71.84,107.02 70.83,108.03 70.83,114.61 68.87,116.57 68.87,117.18 70.06,118.38 73.06,118.38 74.86,116.57 83.37,116.57 86.17,119.37 90.03,119.37 93.34,116.06 96.84,116.06 98.59,117.82 100.52,117.82 101,118.3 101.99,118.3 104.07,120.38 105.98,120.38 106.49,119.87 106.49,118.73 107.25,117.97 v1(107.63,117.97)
  IN2 w0.089: v1(94.3,83.55) 94.35,83.55 95.07,84.28 100.49,84.28 101.17,83.59 102.17,83.59 102.37,83.39 103.63,83.39 104.01,83.77 105.03,83.77 105.22,83.58 110.35,83.58 v1(110.68,83.25)
  IN3 w0.089: v1(171.18,33.69) 170.8,33.69 170.52,33.41 160.72,33.41 160.34,33.03 160.34,32.65 159.53,31.84 159.14,31.84 158.65,31.34 158.65,30.32 157.67,29.35 157.67,28.66 157.44,28.42 153.19,28.42 152.74,27.98 145.93,27.98 145.1,28.82 145.1,30.09 145.86,30.85 145.86,31.84 144.46,33.23 144.46,34.55 141.4,37.62 138.88,37.62 136.96,39.53 131.23,39.53 130.85,39.91 130.85,40.73 130.73,40.86 126.59,45 126.59,46.18 125.16,47.61 125.16,60.69 126.92,62.46 126.92,72.9 125.61,74.2 118.93,74.2 118.68,74.46 118.68,77.81 117.54,78.95 117.54,80 116.39,81.14 115.63,81.14 115.12,81.65 112.89,81.65 111.69,82.84 111.09,82.84 v1(110.68,83.25)
  BOTTOM w0.102: v1(111.81,123.07) 110.04,123.07 109.7,123.42 Q29.3
2ND_S5ON: length 61.8
  TOP w0.102: v1(171.32,20.12) 170.7,20.74 169.15,20.74 168.87,20.46 168.87,19.64 168.65,19.42 167.75,19.42 167.22,18.88 167.22,17.76 168.08,16.9 168.08,16.5 165.77,14.18 161.68,14.18 161.12,13.63 161.12,12.86 v1(161.95,12.04) 162.9,11.09 171.21,11.09 171.64,10.65 173.54,10.65 173.82,10.93 173.82,11.34 173.75,11.42 173.75,11.42 173.52,11.64 173.42,11.64 173.4,11.67 173.14,11.67 173.04,11.77 R733.1 173.04,12.94 173.22,13.12 U15.48
  IN2 w0.089: v1(157.75,20.03) 158.56,20.84 162.28,20.84 163.46,22.02 165.45,22.02 166.63,20.84 167.77,20.84 168.03,21.09 170.34,21.09 v1(171.32,20.12)
  BOTTOM w0.102: v1(157.75,20.03) 158.18,20.46 158.18,24.5 158.81,25.13 158.81,27.44 158.53,27.72 157.87,27.72 156.78,26.63 155.84,26.63 155.79,26.68 PR329.1
6D_ACCEL_GYRO_INT#: length 7.1
  BOTTOM w0.102: R594.1 108.07,43.95 106.25,43.95 106,44.21 104.84,44.21 104.79,44.16 103.72,44.16 103.33,44.54 101.46,44.54 U30.AU2
32K_X1: length 10.3
  BOTTOM w0.102: Y3.1 107.02,40 R600.1 106.37,40.01 C619.1 105.85,40.49 105.85,39.74 105.73,39.61 105.47,39.61 105.34,39.74 105.34,40.28 105.22,40.4 104.98,40.4 103.95,41.44 103.95,41.9 103.69,42.15 102.14,42.15 U30.AY1
32K_X2: length 10.7
  BOTTOM w0.102: Y3.2 107.02,39.22 R600.2 106.37,39.21 C622.1 104.96,39.62 104.96,40.12 103.19,41.89 101.75,41.89 101.32,42.32 100.78,42.32 U30.AY4
48M_X1: length 13.9
  BOTTOM w0.102: Y4.1 107.2,34.27 107.2,36.1 106.84,36.46 R610.2 107.12,36.69 107.25,36.82 C625.2 107.47,37.1 105.9,37.1 104.79,38.21 103.85,38.21 101.53,40.52 101.53,41.03 100.98,41.59 U30.BB3
48M_X2: length 13
  BOTTOM w0.102: U30.BA5 100.13,41.89 100.77,41.25 100.92,41.25 101.28,40.89 101.28,40.47 103.92,37.83 104.58,37.83 105.48,36.93 C624.2 105.73,36.82 105.85,36.69 R610.1 106.39,36.33 106.79,35.93 106.79,34.45 106.61,34.28 106.11,34.28 105.9,34.49 Y4.3
256_I2C_SCL: length 2.6
  BOTTOM w0.102: TP80.1 196.15,29.78 196.71,30.34 197.68,30.34 197.69,30.34 R654.2
256_I2C_SDA: length 3
  BOTTOM w0.102: R655.2 197.58,29.8 197.5,29.88 196.63,29.88 195.72,28.97 TP79.1
3622AC_PVCC: length 7.6
  TOP w0.203: PR51.1 139.6,50.68 139.6,53.51 139.93,53.84 140.92,53.84 141.46,54.38 PC68.2 141.51,54.44 v1(142.5,54.44) 142.64,54.3 PU3.34
3622AM_PVCC_GPU: length 3.1
  BOTTOM w0.203: PU8.34 77.47,112.28 77.57,112.37 77.59,112.37 PC162.2
  BOTTOM w0.381: PR167.1 77.74,112.7 PC162.2
3662AC_BOOT1: length 4
  TOP w0.203: PR46.1 140.66,51.81 141.04,52.19 141.79,52.19 141.83,52.23 142.6,52.23 v1(142.68,52.31) 142.96,52.31 143.35,52.7 PU3.38
3662AC_BOOT2: length 4.1
  TOP w0.102: v1(142.92,48.7) 142.83,48.8 PR54.1
  TOP w0.203: PU3.2 144.95,50.77 144.89,50.71 144.88,50.71 144.75,50.58 143.9,50.58 143.49,50.18 143.24,50.18 PR54.1
3662AC_CPU_HG1: length 1.4
  BOTTOM w0.61: PR254.2 139.34,61.02 138.58,61.02 PQ32.1
3662AC_CPU_HG2: length 3.3
  BOTTOM w0.102: v1(144,53.28) 143.68,52.95 PR266.2
  BOTTOM w0.406: PQ33.1 141.37,53.8 141.88,53.29 142.48,53.29 142.83,52.95 PR266.2
3662AC_CPU_LG1: length 12.6
  TOP w0.203: v1(142.79,53.81) 142.89,53.9 PU3.35
  IN2 w0.508: v1(142.79,53.81) 142.79,54.19 142.49,54.49 142.2,54.49 141.84,54.85 141.84,55.31 135.39,61.76 v1(135.39,62.1)
  vias: v1(134.43,62.42)
3662AC_CPU_LG2: length 10.6
  TOP w0.203: v1(142.11,51.74) 142.86,51.74 143.42,52.3 PU3.39
  IN2 w0.508: v1(135.42,54.7) 137.71,54.7 138.33,55.32 138.83,55.32 141.49,52.66 141.49,52.36 v1(142.11,51.74)
3662AC_CPU_LX1: length 60.7
  TOP w0.203: v1(142.16,53.88) 142.16,53.74 142.57,53.33 142.99,53.33 143.17,53.5 PU3.36
  TOP w0.305: PC71.1 141.72,53.44 v1(142.16,53.88)
  IN2 w0.152: v1(150.09,46.54) 150.33,46.31 150.33,45.21 150.01,44.89 148.75,44.89 148.28,45.36 148.26,45.87 148.26,46.52 147.83,46.95 145.2,46.95 143.97,48.18 143.4,48.18 142.88,47.66 136.16,47.66 135.83,47.99 132.44,47.99 131.34,49.09 131.34,50.12 130.82,50.64 127.7,50.64 127.25,51.08 127.25,56.3 127.74,56.78 128.61,56.78 128.84,57.01 129.36,57.01 v1(129.82,56.54)
  IN2 w0.508: v1(142.16,53.88) 141.37,53.88 138.21,57.05 132.64,57.05 v1(131.88,57.8)
  BOTTOM w0.178: PR288.2 151.63,47.4 151.63,47.04 151.31,46.71 150.54,46.71 150.37,46.54 v1(150.09,46.54)
  BOTTOM w0.203: PL11.1 128.88,60.01 128.24,59.37 128.24,58.12 v1(129.82,56.54)
  vias: v1(131.86,57.14)
3662AC_CPU_LX2: length 38.2
  TOP w0.203: PU3.40 143.56,51.9 142.74,51.09 v1(142.1,51.09)
  TOP w0.229: v1(142.1,51.09) 142.05,51.09 PC73.1
  IN2 w0.152: v1(148.96,45.65) 149.16,45.84 149.16,45.96 148.93,46.19 148.93,47.09 148.2,47.82 145.53,47.82 144.34,49.02 143.01,49.02 142.49,48.5 136.59,48.5 136.21,48.88 133.15,48.88 132.41,49.63 132.41,50.19 v1(132.55,50.33)
  IN2 w0.508: v1(135.12,50.63) 135.95,49.8 138.97,49.8 140.25,51.09 v1(142.1,51.09)
  BOTTOM w0.178: PR297.2 148.68,44.97 148.96,45.26 v1(148.96,45.65)
  BOTTOM w0.203: PL12.1 131.74,52.83 131.1,52.19 131.1,51.16 131.92,50.33 v1(132.55,50.33)
3662AC_CPUISEN1N: length 10.8
  TOP w0.203: v1(149.28,48.6) 149.2,48.68 PC75.1
  BOTTOM w0.178: PR292.2 149.75,46.22 149.9,46.07 149.94,46.07 149.97,46.04 PR295.1 150.41,46.04 150.58,46.21 v1(151.06,46.21) 151.24,46.21 151.95,46.92 151.95,48.37 152.09,48.51 152.09,49.2 151.91,49.38 150.64,49.38 150.24,49.77 150.24,49.78 150.22,49.8 150.22,50.25 ; 150.22,50.25 149.83,49.86 149.82,49.86 149.73,49.77 149.59,49.77 149.13,49.31 PR279.1 149.13,48.75 v1(149.28,48.6) ; 150.22,50.25 PR275.2
3662AC_CPUISEN1P: length 0.9
  BOTTOM w0.203: PR280.2 151.34,48.62 PR288.1
3662AC_CPUISEN2N: length 6.2
  TOP w0.102: v1(148.4,47.87) 148.4,48.56 v1(148.36,48.59)
  TOP w0.203: PC77.1 148.24,48.84 148.36,48.72 v1(148.36,48.59)
  BOTTOM w0.178: PR290.1 149.98,47.37 149.98,47.69 PR287.2 149.72,47.94 149.26,47.48 148.47,47.48 PR286.1 148.21,48.16 148.21,48.42 148.36,48.57 v1(148.36,48.59) 148.19,48.76 PR278.1
3662AC_CPUISEN2P: length 1.7
  BOTTOM w0.102: v1(147.59,45.48) 147.64,45.42 PR297.1
  BOTTOM w0.178: PR297.1 148.4,46.12 PR291.2
3662AC_EN: length 3
  TOP w0.203: PU3.29 144.95,56.64 144.61,56.99 v2(144.61,57.02)
  TOP w0.254: v2(144.61,57.02) 144.61,58.02 PR36.2
  BOTTOM w0.203: v2(144.61,57.02) 144.78,56.85 PC222.1
3662AC_HG1: length 10.4
  TOP w0.203: v1(142.13,52.71) 142.37,52.95 143.12,52.95 143.28,53.1 PU3.37
  IN3 w0.508: v1(142.13,52.71) 140.01,54.84 v2(140.01,60.31)
3662AC_HG2: length 1.2
  TOP w0.203: v1(143.51,50.95) 143.79,51.23 PU3.1
  vias: v1(143.93,51.62)
3662AC_IMON_CPU: length 3.3
  TOP w0.203: v1(149.92,52.86) 149.68,52.86 149.43,53.1 PU3.14
  BOTTOM w0.178: PR268.2 150.34,51.94 PC232.1 149.64,52.28 149.92,52.56 v1(149.92,52.86)
3662AC_IMON_NB: length 2.9
  TOP w0.203: v1(149.91,54.18) 149.81,54.18 149.7,54.08 149.28,53.9 PU3.16
  BOTTOM w0.203: PR259.2 150.29,54.58 149.91,54.2 ; 149.91,54.2 149.54,54.57 PC230.1 ; 149.91,54.2 v1(149.91,54.18)
3662AC_ISEN1N_CPU: length 5.6
  TOP w0.203: PU3.10 148.15,50.53 148.34,50.35 v1(148.34,50.19)
  BOTTOM w0.152: PR286.2 148.78,48.4 148.82,48.44 148.82,48.85 148.66,49.01 148.66,49.87 v1(148.34,50.19)
  BOTTOM w0.178: PR275.1 148.86,50.85 148.78,50.85
  BOTTOM w0.203: v1(148.34,50.19) 148.78,50.63 PC234.2
3662AC_ISEN1P_CPU: length 8.2
  TOP w0.102: v1(149.91,48.61) 149.67,48.37 v1(149.67,47.99)
  TOP w0.203: v1(149.91,48.61) 149.72,48.81 149.72,49.49 149.2,50 PC75.2 148.9,49.71 148.04,49.71 147.86,49.89 147.86,50.32 147.75,50.42 PU3.9
  BOTTOM w0.178: v1(149.91,48.61) 149.91,49.3 ; 149.91,49.3 150.3,48.91 PR280.1 ; 149.91,49.3 PR279.2
  BOTTOM w0.203: PR287.1 150.5,48.56 PR280.1
3662AC_ISEN2P_CPU: length 8
  TOP w0.102: v1(147.13,47.87) 147.13,47.98 v1(147.73,48.58)
  TOP w0.203: PU3.7 146.95,50.38 146.89,50.32 146.89,49.92 147.06,49.75 147.06,49.64 147.46,49.24 PC77.2 147.46,48.84 v1(147.73,48.58)
  BOTTOM w0.178: PR292.1 PR291.1 148.01,47.48 147.67,47.48 147.54,47.61 147.54,48.4 v1(147.73,48.58) 147.41,48.9 PR278.2
3662AC_ISENP_NB: length 4.3
  TOP w0.178: PR35.1 PC61.1 147.03,57.84 146.9,57.84 146.63,57.57 146.63,57.05 146.55,56.98 PU3.25
  TOP w0.203: PR31.2 147.92,59.69 147.55,59.32 147.54,59.32 147.14,58.92 PR35.1
3662AC_NB_HG1: length 23.4
  TOP w0.508: v1(144,56.01) 143.82,56.19 142.82,56.19 142.48,56.54 PR39.2
  IN3 w0.508: v1(144,56.01) 142.64,56.01 141.22,57.42 141.22,60.81 140.33,61.71 136.52,61.71 136.05,62.18 136.05,62.33 134.65,63.73 134.65,69.78 v1(134.22,70.21)
3662AC_NB_LG1: length 15.7
  TOP w0.203: PU3.33 143.14,54.7 143.05,54.79 v1(143.05,54.79)
  IN2 w0.508: v1(135.98,66.22) 135.55,65.8 135.55,62.86 136.05,62.37 136.05,62.18 142.52,55.71 142.71,55.71 143.06,55.35 143.06,54.81 v1(143.05,54.79)
3662AC_NB_LX1: length 56.2
  TOP w0.178: v1(144.84,60.44) 145.22,60.06 145.22,59.68 145.53,59.37 146,59.37 PR30.2
  TOP w0.203: v1(142.45,55.1) 142.59,55.1 142.77,55.28 143.24,55.28 143.42,55.1 PU3.32
  TOP w0.305: PC65.1 141.71,55.1 v1(142.45,55.1)
  IN2 w0.178: v1(144.84,60.44) 144.59,60.44 144.2,60.05 142.56,60.05 139.44,63.17 139.44,72 137.76,73.68 137.76,76.31 137.53,76.54 134.65,76.54 v1(134.38,76.81)
  IN3 w0.508: v1(142.45,55.1) 140.61,56.94 140.61,60.56 140.15,61.02 136.34,61.02 135.9,61.46 135.05,61.46 134.04,62.47 134.04,69.11 132.92,70.22 v1(132.9,70.22)
  BOTTOM w0.203: PL9.1 133.86,75.17 133.61,75.41 133.61,76.32 134.11,76.81 v1(134.38,76.81)
3662AC_PGOOD: length 11
  TOP w0.152: PR52.2 137.78,49.87 137.96,49.69 137.96,49.29 139.13,48.12 v1(140.14,48.12) 143.11,48.12 143.52,48.53 143.52,49.74 144.03,50.25 144.87,50.25 145.26,50.64 145.35,50.74 PU3.3
3662AC_PWROK: length 1.9
  TOP w0.203: PR42.2 149.96,55.38 149.29,54.7 PU3.18
3662AC_RGND: length 70.6
  TOP w0.203: PU3.4 145.75,50.71 145.49,50.44 145.49,50.25 145.36,50.12 v1(145.36,50.09)
  IN2 w0.203: v1(123.07,81.29) 123.25,81.29 124.6,79.95 129.4,79.95 129.6,79.74 129.6,71.11 127.7,69.2 127.7,62.09 126.59,60.99 126.59,49.71 126.41,49.52 126.41,49.49 v1(126.42,49.48)
  IN3 w0.127: v1(126.42,49.48) 126.89,49.95 127.39,49.95 127.58,49.76 128.55,49.76 129.96,48.35 135.73,48.35 136.32,47.75 142.49,47.75 144.41,49.67 144.94,49.67 v1(145.36,50.09)
  BOTTOM w0.203: v1(123.07,81.29) 123.12,81.29 123.51,80.91 PR230.1 ; PC233.2 146.58,51.71 146.17,51.31 146.16,51.31 145.99,51.14 PR269.1 145.62,50.36 v1(145.36,50.09) ; PR271.1 121.19,51.16 121.38,51.24 121.91,51.24 123.51,49.63 125.73,49.63 125.88,49.48 v1(126.42,49.48)
3662AC_SVC: length 2.4
  TOP w0.102: PR40.2 150.06,56.47 149.44,55.85 149.44,55.32 149.22,55.1 PU3.19
3662AC_SVD: length 2.8
  TOP w0.102: PU3.20 148.83,56.59 149.47,57.23 150.01,57.23 150.03,57.21 PR38.2
3662AC_SVT: length 1.5
  TOP w0.102: PR37.2 148.96,57.14 148.15,56.34 PU3.21
3662AC_TSEN: length 28.9
  TOP w0.203: v1(149.29,51.32) 149.49,51.52 149.49,52.1 149.29,52.3 PU3.12
  IN3 w0.127: v1(149.29,51.32) 149.93,51.32 150.18,51.07 150.18,50.65 149.96,50.43 149.23,50.43 148.49,51.17 145.26,51.17 142.3,48.21 136.63,48.21 135.98,48.85 130.42,48.85 130.15,49.12 130.15,49.39 v1(129.51,50.03)
  BOTTOM w0.203: PR281.2 PR282.2 128.35,48.91 129.47,50.03 v1(129.51,50.03)
3662AC_TSEN_NB: length 36.8
  TOP w0.178: v1(148.54,58.73) 148.54,57.77 148.25,57.48 147.86,57.48 147.59,57.21 147.59,56.99 147.35,56.76 PU3.23
  IN2 w0.127: v1(148.54,58.73) 147.69,58.73 146.47,59.96 146.47,61.08 145.8,61.75 142.47,61.75 142.39,61.75 140.43,63.7 140.43,72.41 138.75,74.09 138.75,77.11 138.29,77.57 136.03,77.57 134.59,79.01 133.33,79.01 v1(132.88,78.56)
  BOTTOM w0.203: v1(132.88,78.56) 132.42,79.02 PR235.2
  BOTTOM w0.305: PR231.2 PR235.2
3662AC_VCC: length 3
  TOP w0.203: PR43.2 150.32,53.85 150.58,54.11 PC67.2 150.53,54.67 150.2,54.67 150.19,54.68 149.79,54.68 149.78,54.67 149.7,54.67 149.33,54.3 PU3.17
3662AC_VDDIO: length 3.4
  TOP w0.203: v1(148.06,57.01) 147.75,56.71 PU3.22
  BOTTOM w0.457: PR256.2 148.06,57.71 v1(148.06,57.01) 147.99,57.01 PC225.1
3662AC_VRHOT: length 7.2
  TOP w0.127: PR53.2 153.8,49.71 153.34,49.25 150.23,49.25 150.12,49.36 150.12,49.83 148.83,51.13 PU3.11
3662ACCOMP_CPU: length 3.9
  TOP w0.102: PR276.1 144.8,49.05 v1(145.22,48.63)
  TOP w0.203: PU3.5 146.15,50.62 145.86,50.33 145.86,49.62 PC76.1 145.74,49.49 PR276.1
3662ACCOMP_NB: length 2.9
  TOP w0.178: PC60.1 145.42,57.48 145.65,57.25 145.65,57.04 145.75,56.94 PU3.27
  TOP w0.203: PC60.1 PR34.1
3662ACFB_CPU: length 9.1
  TOP w0.203: PU3.6 146.55,50.69 146.51,50.65 146.51,50.31 146.35,50.15 v1(146.35,50.13) 146.52,49.95 PC76.2 146.24,49.21 146.24,48.75 145.6,48.12 144.77,48.12 144.02,48.86 PR276.2
  BOTTOM w0.152: v1(146.35,49.29) 146.35,48.61 146.61,48.35 PC240.2
  BOTTOM w0.203: v1(146.35,49.29) v1(146.35,50.13) ; PR289.2 PC240.2
3662ACFB_NB: length 4.5
  TOP w0.203: PU3.26 146.15,57.21 v1(146.12,57.24) 146.15,57.27 146.15,57.31 146.18,57.34 146.18,57.38 146.2,57.39 PC60.2 PR34.2
  BOTTOM w0.203: v1(146.12,57.24) 146.42,57.54 PC221.2 PR255.2
3662ACNBISENN: length 5.6
  TOP w0.178: PR35.2 PC61.2 147.88,57.95 147.3,57.37 147.15,57.37 v1(147.1,57.32) 147.1,57.17 147.06,57.13 147.06,57.07 147.04,57.04 147.04,57.04 146.95,56.95 PU3.24
  TOP w0.203: PR35.2 148.31,59.31 PR32.1
  BOTTOM w0.203: v1(147.1,57.32) 146.45,56.67 PC224.1
3662ACNBISENP: length 1.6
  TOP w0.102: v1(146.31,60.82) PR30.1
  TOP w0.203: PR31.1 146.94,59.87 146.67,60.13 PR30.1
3662ACSET1: length 4
  TOP w0.203: PU3.13 149.36,52.7 149.82,52.25 149.82,51.53 150.55,50.8 PR49.2 PR55.2
3662AM_BOOT1_GPU: length 3
  BOTTOM w0.203: PR174.1 77.79,108.87 77.16,109.5 77.16,110.09 76.58,110.68 PU8.38
3662AM_BOOT2_GPU: length 3.1
  BOTTOM w0.203: PU8.2 74.95,108.58 75.53,108 75.53,106.95 75.35,106.77 PR186.1
3662AM_BOOT_VDDCI: length 4
  BOTTOM w0.203: PR158.1 76.87,116.67 76.74,116.54 76.74,115.24 v1(76.29,114.79) 76.19,114.7 75.55,114.7 75.35,114.5 PU8.30
3662AM_COMP_GPU: length 3.9
  BOTTOM w0.152: PU8.5 73.75,108.72 73.59,108.57 73.59,107.94 73.7,107.83 73.7,107.05 PR183.1
  BOTTOM w0.203: PR183.1 PC171.1
3662AM_COMP_VDDCI: length 3
  BOTTOM w0.203: PR154.1 PC155.1 75.05,115.84 74.6,115.39 74.6,115.34 74.15,114.88 PU8.27
3662AM_EN_GPU: length 86.2
  IN2 w0.152: v1(135.44,123.94) 132.27,123.94 132.01,123.68 125.28,123.68 124.65,123.05 123.89,123.05 123.25,123.68 123.25,124.45 122.74,124.95 122.74,125.46 121.83,126.38 111.26,126.38 108.95,124.07 107.63,124.07 106.11,122.54 104.2,122.54 103.01,121.35 100.47,121.35 99.1,119.98 96.15,119.98 94.17,121.96 94.17,123.18 92.9,124.45 92.14,124.45 90.79,125.79 88.45,125.79 86.28,123.62 73.02,123.62 v1(72.96,123.56)
  BOTTOM w0.127: PC149.1 75.94,118.85 76.44,118.35 76.44,115.6 75.84,114.99 75.17,114.99 74.95,114.76 PU8.29
  BOTTOM w0.152: v1(72.96,123.56) 73.79,123.56 74.35,122.99 PR128.2 ; PR119.1 135.31,124.07 v1(135.44,123.94) ; PR128.2 74.35,122.02 74.31,121.98 PR135.2 ; PR128.2 75.25,121.6 75.7,121.14 75.7,119.52 75.93,119.3 PC149.1
3662AM_FB_GPU: length 8.8
  BOTTOM w0.152: PC172.2 74.04,104.38 72.78,104.38 PR191.2 71.74,105.41 71.74,107.1 71.96,107.32 PC171.2 PR183.2 73.19,107.88 73.29,107.98 73.29,108.65 73.35,108.7 PU8.6
3662AM_FB_VDDCI: length 5.8
  BOTTOM w0.203: PU8.26 73.75,114.94 74.27,115.47 PC155.2 PR154.2 74.2,116.89 PC151.2 PR146.2 PR139.1
3662AM_GPU_ISEN1N: length 5
  BOTTOM w0.203: PR187.2 66.2,105.88 66.65,105.44 67.34,105.44 67.47,105.57 PR188.1 68.38,105.85 PR189.2 68.5,106.12 68.66,106.27 68.66,106.28 69.06,106.69 ; 69.06,106.69 PC168.1 ; 69.06,106.69 PR181.1
3662AM_GPU_ISEN1P: length 1.7
  BOTTOM w0.152: PR184.1 66.17,107.59 67.02,107.59 PR180.2
3662AM_GPU_ISEN2N: length 4.2
  BOTTOM w0.152: PR190.2 70.22,106.1 70.03,106.29 PR182.2 PC169.2
  BOTTOM w0.203: PR196.1 69.28,104.77 PR194.1 69.28,104.8 PR190.2
3662AM_GPU_ISEN2P: length 1
  BOTTOM w0.152: PR195.1 70.7,104.48 PR197.1
3662AM_HG1_VDDCI:
  vias: v1(77.58,120.97)
3662AM_IMON_GPU: length 4.8
  BOTTOM w0.203: PR171.2 PC165.1 67.67,111.29 68.14,110.82 69.78,110.82 69.87,110.73 70.17,110.73 70.51,111.08 PU8.14
3662AM_IMON_VDDCI: length 13.1
  BOTTOM w0.178: PC161.1 67.67,113.23 67.19,113.71 65.82,113.71 64.99,114.54 64.99,117.26 65.64,117.91 65.64,119.31 66.1,119.77 PR138.2
  BOTTOM w0.203: PC161.1 68.44,113.22 v1(68.51,113.14) 68.92,112.74 69.61,112.74 70.47,111.88 PU8.16
3662AM_ISEN1N_GPU: length 31.8
  IN2 w0.203: v1(71.23,108.53) 70.74,109.02 70.74,111.1 69.34,112.51 67.63,112.51 66.28,113.85 66.28,117.02 65.72,117.59 65.21,117.59 64.8,117.17 64.8,116.06 64.58,115.84 64.58,114.26 65.54,113.29 65.54,111.7 65.21,111.37 65.21,108.7 65.92,107.99 65.92,106.16 66.83,105.25 v1(67.95,105.25)
  BOTTOM w0.203: PR194.2 68.43,104.78 v1(67.95,105.25) ; PR194.2 68.72,104.55 PC173.2 ; PR194.2 68.5,104.96 68.87,105.32 68.88,105.32 69.28,105.73 PR189.1 ; PU8.10 71.75,108.84 71.47,108.56 71.26,108.56 v1(71.23,108.53)
3662AM_ISEN1P_GPU: length 7.3
  BOTTOM w0.152: 69.08,107.47 PR182.1 ; 69.08,107.47 PC168.2 ; 69.08,107.47 69.53,107.91 70.53,107.91 70.66,108.05 71.45,108.05 72.15,108.75 PU8.9
  BOTTOM w0.203: PC168.2 PR181.2 68.1,107.47 67.7,107.06 67.7,107.05 67.33,106.69 PR180.1
3662AM_ISEN2P_GPU: length 18.2
  BOTTOM w0.152: PR190.1 71.44,105.29 71.44,104.44 71.51,104.38 72.02,104.38 72.18,104.22 72.18,103.73 71.91,103.46 67.78,103.46 67.45,103.79 67.45,104.99 67.3,105.13 66.52,105.13 66.22,105.43 65.86,105.43 65.42,105.87 PR187.1 ; PR190.1 71.46,106.2 71.46,107 PC169.1 71.28,107.76 71.94,107.76 71.99,107.81 72.71,107.81 73,108.1 73,108.66 72.95,108.71 PU8.7 ; PR190.1 70.22,104.96 PR195.2
3662AM_ISENP_VDDCI: length 6.2
  BOTTOM w0.203: PR147.2 73.25,117.36 PR151.1 ; PU8.25 73.35,115.45 PR161.2 73.57,115.48 73.77,115.68 73.77,116.28 PR151.1 ; PC154.1 71.93,116.04 PR151.1
3662AM_LG1_GPU: length 15.5
  IN2 w0.559: v1(78.12,111.92) 78.63,111.42 84.86,111.42 85.41,110.86 85.41,106.09 v1(84.77,105.45)
  BOTTOM w0.203: PU8.35 76.8,111.88 76.83,111.91 77.63,111.91 77.64,111.92 v1(78.12,111.92)
3662AM_LG1_VDDCI: length 4.9
  IN1 w0.508: v1(79.4,115.62) 78.96,115.19 78.96,114.72 v1(77.13,112.89)
  BOTTOM w0.203: PU8.33 76.92,112.68 v1(77.13,112.89)
3662AM_LG2_GPU: length 16.8
  IN2 w0.559: v1(83.9,99) 84.26,99.36 84.26,103.72 82.5,105.49 81.4,105.49 79.83,107.06 79.83,107.93 78.68,109.07 v1(76.9,109.07)
  BOTTOM w0.203: PU8.39 76.51,110.28 76.83,109.95 76.83,109.13 v1(76.9,109.07)
3662AM_LX1_GPU: length 61.3
  TOP w0.381: PR23.1 84.38,110.87 v1(84.49,110.76)
  IN2 w0.152: v1(66.52,107.14) 67.98,107.14 69.28,105.84 69.28,101.33 76.13,94.47 85.66,94.47 87.69,96.51 88.64,96.51 89.94,97.81 91.41,97.81 91.69,98.09 91.69,102.29 91.37,102.6 89.6,102.6 88.83,103.36 88.83,104.78 v1(88.46,105.16)
  IN2 w0.559: v1(77.11,111.42) 77.57,111.42 78.23,110.76 v1(84.49,110.76)
  BOTTOM w0.152: PR184.2 66.03,106.69 66.47,107.14 v1(66.52,107.14)
  BOTTOM w0.203: v1(77.11,111.42) 77.05,111.48 PU8.36 ; PL7.1 88.7,108.45 89.18,107.97 89.18,105.88 v1(88.46,105.16)
  BOTTOM w0.381: v1(77.11,111.42) 77.26,111.27 77.54,111.27 77.55,111.26 PC166.1
3662AM_LX1_VDDCI: length 32.1
  IN2 w0.152: v1(87.73,122.09) 87.3,122.09 87.13,122.26 74.67,122.26 73.24,120.82 73.24,120.64 v1(72.93,120.33)
  IN2 w0.559: v1(76.95,113.88) 77.54,114.47 77.54,115.13 81.03,118.61 v1(83.59,118.61)
  BOTTOM w0.203: v1(87.73,122.09) 88.07,121.74 88.07,120.5 87.85,120.28 PL6.1 ; v1(76.95,113.88) 76.95,113.54 76.48,113.08 PU8.32 ; v1(72.93,120.33) 72.99,120.28 PR140.2
  BOTTOM w0.381: v1(76.95,113.88) 77.35,113.47 PC159.1
3662AM_LX2_GPU: length 48.6
  IN2 w0.152: v1(71.72,103.92) 71.06,104.58 70.14,104.58 69.76,104.2 69.76,101.43 76.33,94.86 85.41,94.86 87.57,97.01 88.63,97.01 89.43,97.81 89.43,98.58 88.2,99.81 87.5,99.81 v1(87,99.3)
  IN2 w0.559: v1(82.99,104.02) 82.3,104.71 80.92,104.71 78.46,107.17 77.52,107.17 76.54,108.15 76.54,108.2 v1(76.54,108.2)
  BOTTOM w0.203: PU8.40 76.02,109.24 76.54,108.72 v1(76.54,108.2) ; v1(71.72,103.92) 71.72,103.92 PR197.2 ; PL8.1 87.27,101.26 87.8,100.72 87.8,100.11 v1(87,99.3)
  BOTTOM w0.381: v1(76.54,108.2) 76.57,108.17 76.57,107.79 PC167.1
3662AM_PGOOD_GPU: length 1.6
  BOTTOM w0.152: PU8.3 74.55,108.48 75.02,108.01 PR179.2
3662AM_PWROK_GPU: length 1.6
  BOTTOM w0.178: PU8.18 70.56,112.68 69.88,113.35 PR168.2
3662AM_RGND_GPU: length 30
  IN2 w0.102: v1(81.67,96.7) 81.45,96.48 76.82,96.48 74.2,99.1 74.2,104.28 72.07,106.41 72.07,108.7 72.17,108.8 72.86,108.8 73.47,108.19 v1(74.05,108.19)
  BOTTOM w0.152: PU8.4 74.15,108.23 74.1,108.19 74.08,108.19 ; v1(81.67,96.7) 81.67,96.43 82.07,96.03 82.07,92.73 82.62,92.18 82.62,91.94 82.98,91.58 PR209.1
  BOTTOM w0.203: PR209.1 82.43,91.49 82.41,91.5 PR207.1 ; v1(74.05,108.19) 74.08,108.19 74.1,108.16 74.1,107.49 PC170.2
3662AM_SET1_GPU: length 2.7
  BOTTOM w0.178: PU8.13 70.57,110.68 70.23,110.34 PR173.2
  BOTTOM w0.203: PR173.2 PR176.2
3662AM_SVC_GPU: length 2.9
  BOTTOM w0.203: PR163.2 69.66,114.84 v1(70.22,114.29) 70.41,114.1 70.41,113.28 70.61,113.08 PU8.19
3662AM_SVD_GPU: length 3.2
  BOTTOM w0.203: PU8.20 71.07,114.13 70.14,115.06 70.14,115.63 69.93,115.85 PR155.2
3662AM_SVT_GPU: length 2.1
  BOTTOM w0.203: PR159.2 70.64,115.03 71.52,114.15 PU8.21
3662AM_TSEN_GPU: length 32.8
  IN2 w0.102: v1(70.06,109.68) 69.92,109.68 69.56,109.31 69.56,108.31 73.78,104.1 73.78,98.94 76.78,95.95 85.19,95.95 86.64,97.39 86.64,97.67 v1(86.92,97.96)
  BOTTOM w0.178: PU8.12 70.6,110.28 70.08,109.75 70.08,109.69 v1(70.06,109.68)
  BOTTOM w0.203: v1(86.92,97.96) 87.41,98.45 87.81,98.45 88.09,98.16 88.09,97.76 88.07,97.74 PR201.2 PR203.2
3662AM_TSEN_VDDCI: length 28.3
  IN2 w0.102: v1(89.97,123.75) 89,122.78 74.5,122.78 73.1,121.38 71.93,121.38 71.82,121.27 71.82,115.63 v1(72.45,115)
  BOTTOM w0.203: v1(72.45,115) 72.55,114.9 PU8.23 ; PR118.2 90.38,124.84 90.38,124.84 PR123.2 90.38,124.21 89.97,123.81 v1(89.97,123.75)
3662AM_UGATE1_GPU: length 4.4
  IN1 w0.559: v1(77.18,108.41) 77.47,108.41 77.91,108.85 77.91,110.03 v1(77.24,110.69)
  BOTTOM w0.203: v1(77.24,110.69) 77.07,110.69 76.69,111.08 PU8.37
3662AM_UGATE2_GPU: length 12.2
  IN2 w0.559: v1(75.37,100.06) 78.42,103.11 78.42,105.9 77.85,106.48 77.21,106.48 75.88,107.81 75.88,108.52 v1(75.93,108.57)
  BOTTOM w0.203: v1(75.93,108.57) 75.93,108.78 75.5,109.2 PU8.1
3662AM_UGATE_VDDCI: length 7.6
  IN2 w0.559: v1(76.91,120.71) 76.91,115.6 76.82,115.51 76.82,114.76 v1(76.07,114.01)
  BOTTOM w0.203: v1(76.07,114.01) 76.02,113.96 PU8.31
3662AM_VCC_GPU: length 5
  BOTTOM w0.178: PU8.17 70.52,112.28 69.74,113.06 69.34,113.06 68.74,113.65 68.34,113.65 67.82,114.17 PR166.2
  BOTTOM w0.203: PR166.2 PC157.2
3662AM_VDDCI_ISENN: length 4.8
  BOTTOM w0.203: PR142.1 PC148.1 72.53,118.78 72.76,118.55 72.76,117.65 PR151.2 72.19,117.07 71.79,116.67 71.79,116.58 71.41,116.2 PC154.2 PR162.2
3662AM_VDDCI_ISENP: length 0.9
  BOTTOM w0.203: PR140.1 73.44,119.01 PR147.1
3662AM_VDDIO_GPU: length 9.3
  BOTTOM w0.203: PU8.22 72.15,114.62 71.85,114.91 71.24,114.91 71.06,115.09 71.06,116.32 71.41,116.66 PC152.1 71.46,117.21 71.84,117.59 71.84,119.39 71.79,119.44 71.79,120.81 v1(72.13,121.16) 72.22,121.24 PR131.2
3662AM_VRHOT_GPU: length 1.5
  TOP w0.102: PR24.2 70.98,109.43 v1(71.23,109.18)
  BOTTOM w0.178: v1(71.23,109.18) 71.23,109.28 71.07,109.44 PU8.11
3662AM_VSEN_GPU: length 5.6
  IN2 w0.203: v1(74.03,105.27) 73.85,105.27 73.21,105.9 73.21,107.71 72.55,108.37 v1(72.52,108.37)
  BOTTOM w0.152: PR192.1 73.54,105.6 73.87,105.27 v1(74.03,105.27)
  BOTTOM w0.203: PU8.8 72.55,108.4 v1(72.52,108.37)
3662NBBOOTNB: length 5.8
  TOP w0.203: PR41.1 139.77,56.53 140.41,57.17 142.65,57.17 142.94,56.88 v1(143.24,56.88) 144.03,56.88 144.55,56.35 PU3.30
3662NBUGATENB: length 3.5
  TOP w0.203: PR39.1 140.92,56.41 141.48,55.84 142.13,55.84 142.3,55.67 143.39,55.67 143.55,55.5 PU3.31
5213EN_VDD08: length 3.3
  TOP w0.203: PU2.7 90.02,114.54 90.28,114.79 90.28,115.92 PC23.1 89.18,116.09 PR17.1
5213FB_1.8V:
  vias: v1(41.57,25.77)
5213FB_1.8V_S: length 10.5
  TOP w0.254: PR99.1 35.11,22.34 35.49,21.96 v1(38.92,21.96) 40.4,23.43 40.4,23.74 40.82,24.16 PC124.1 41.43,24.16 41.59,24.32 PR100.1
5213FB_VDD08: length 4
  TOP w0.203: PR13.1 PR14.2 PC22.2 87.44,116.19 v1(87.39,116.14) 87.18,115.93 PU2.1
5213LX_VDD08:
  vias: v1(90.05,112.71)
5213PG_1.8V: length 2
  TOP w0.102: PR94.2 43.21,27.16 43.08,27.29 42.48,27.29 42.28,27.09 PU7.2
5213PG_VDD08: length 2.1
  TOP w0.203: PR20.2 85.94,115.08 v1(86.04,114.97) 86.48,114.54 PU2.2
5447_CC1_CON: length 24.6
  TOP w0.203: U19.12 20.11,12.93 20.64,12.4 20.64,12.18 20.92,11.9 C515.1 v1(21.14,12.56)
  IN2 w0.508: v1(21.14,12.56) 17.26,12.56 16.83,12.13 15.23,12.13 13.4,13.96 13.4,14.59 12.51,15.48 11.05,15.48 10.22,16.3 10.22,17.29 v1(9.76,17.75)
  IN3 w0.508: v1(8.48,14.71) 8.48,14.78 8.55,14.85 8.82,14.85 9.76,15.78 v1(9.76,17.75)
  BOTTOM w0.254: v1(8.48,14.71) 8.08,14.71 7.63,15.15 CN15.A5
  BOTTOM w0.508: v1(9.76,17.75) 9.76,18.21 D35.2 C692.2
5447_CC2_CON: length 35.8
  TOP w0.203: U19.14 21.49,14.86 22.13,14.21 22.13,13.83 v1(22.34,13.63) 22.39,13.58 C499.1 23.08,13.1 v1(22.91,12.94)
  IN1 w0.127: v1(8.57,18.27) 7.05,18.27 6.54,17.77 6.01,17.77 5.67,17.43 5.5,17.03 CN15.B5
  IN2 w0.127: 6.03,18.02 6.03,17.79 5.74,17.5 5.57,17.09 CN15.B5
  IN2 w0.508: 6.03,18.02 8.32,18.02 v1(8.57,18.27) 8.57,17.84 9.46,16.95 9.46,15.99 10.55,14.9 10.55,14.06 9.59,13.09 ; v1(22.91,12.94) 22.67,12.94 21.53,11.8 17.59,11.8 17.08,11.29 14.92,11.29 14.54,10.91 13.52,10.91 12.38,12.05 12.38,12.33 11.62,13.09 9.59,13.09 ; 9.59,13.09 v1(9.46,13.09)
  BOTTOM w0.508: v1(9.46,13.09) 9.46,13.27 10.03,13.84 C704.2 D38.2
8801EN: length 30.1
  BOTTOM w0.102: PR221.1 v1(97.25,88.15) 99,89.9 103.31,89.9 104.58,88.63 110.48,88.63 111.19,89.34 118.43,89.34 118.68,89.09 118.68,88.35 118.32,87.99 PR218.2 118.17,87.54 118.04,87.41 PR222.2 117.52,86.46 PC185.1 116.38,86.46 116.01,86.09 PU9.2
24780_ACDET: length 8.7
  TOP w0.198: PR70.2 135.25,34.64 v1(135.54,34.93)
  TOP w0.305: PQ7.3 137.78,35.82 v1(137.4,35.44) 137.15,35.19 137.15,34.93 136.95,34.73 135.74,34.73 v1(135.54,34.93)
  BOTTOM w0.198: PU14.6 135.02,33.85 135.54,34.37 v1(135.54,34.93) 135.8,34.67 PR321.2
24780_ACDRV: length 1.6
  BOTTOM w0.198: PU14.4 134.22,34.32 PR320.2
24780_ACN: length 142.3
  TOP w0.203: v1(51.88,113.52) 52.21,113.85 53.01,113.85 PR22.2
  TOP w0.254: v1(131.91,35.31) 131.91,35.14 132.37,34.68 PC82.1
  IN3 w0.203: v1(51.88,113.52) 52.59,113.52 53.83,114.77 56.58,114.77 58.61,112.74 61.63,112.74 64.94,109.43 66.51,109.43 69.4,106.54 70.78,106.54 73.54,103.77 73.54,98.63 77.47,94.7 84.99,94.7 86.92,92.77 89.88,92.77 90.97,91.68 92.04,91.68 93.72,90 96.19,90 96.89,89.3 99.15,89.3 104.84,83.61 104.84,82.75 107.23,80.35 107.86,80.35 110.72,77.49 111.1,77.49 117.61,70.98 122.11,70.98 122.31,70.78 122.31,68.13 123.32,67.13 123.32,65.6 121.93,64.22 121.93,41.31 124.46,38.78 124.46,38.28 125.16,37.58 128.83,37.58 129.47,36.94 129.47,35.67 129.83,35.31 v1(131.91,35.31)
  BOTTOM w0.198: v1(131.91,35.31) 131.91,34.91 131.88,34.88 PC265.2 131.88,34.67 132.39,34.16 132.42,34.16 133.02,33.56 PU14.1
24780_ACP: length 142
  TOP w0.203: PR21.2 v1(51.88,114.23)
  TOP w0.254: v1(132.58,35.31) 132.92,34.98 132.92,34.72 PC83.2
  IN3 w0.203: v1(132.58,35.31) 132.26,35.64 132.26,35.71 132.05,35.93 131.25,35.93 131,35.67 130.19,35.67 129.78,36.08 129.78,37.06 128.89,37.96 125.28,37.96 124.9,38.34 124.9,38.85 122.26,41.49 122.26,64.01 123.63,65.38 123.63,67.24 122.62,68.26 122.62,70.98 122.31,71.28 117.74,71.28 111.19,77.84 110.81,77.84 107.99,80.66 107.36,80.66 105.17,82.85 105.17,83.72 99.28,89.6 97.02,89.6 96.26,90.36 93.79,90.36 92.09,92.06 91.02,92.06 90,93.08 87.04,93.08 85.11,95.01 77.6,95.01 73.85,98.76 73.85,103.9 70.9,106.84 69.53,106.84 66.63,109.74 65.06,109.74 61.76,113.04 58.74,113.04 56.68,115.1 53.3,115.1 52.43,114.23 v1(51.88,114.23)
  BOTTOM w0.198: PU14.2 133.42,33.62 132.66,34.38 PC265.1 132.58,34.76 v1(132.58,35.31)
24780_BATDRV: length 4.8
  TOP w0.508: v1(133.79,27.56) 133.77,27.53 132.79,27.53 132.34,27.98 132.34,28.11 131.47,28.98 PR85.2
  BOTTOM w0.198: v1(133.79,27.56) 134.22,27.99 PU14.18
24780_BATSRC: length 5.5
  TOP w0.508: v1(134.57,27.64) 134.57,27.3 133.92,26.66 v1(133.16,26.66) 132.41,26.66 PR92.2
  BOTTOM w0.198: v1(134.57,27.64) 134.62,27.7 PU14.17
24780_BM#: length 4.9
  BOTTOM w0.198: PU14.16 135.02,28.17 v1(135.22,27.98) 135.38,27.81 137.28,27.81 137.41,27.94 137.41,28.64 PR334.1
24780_BST: length 2.2
  BOTTOM w0.198: PU14.25 131.39,31.18 131.31,31.26 130.84,31.26 130.64,31.06 PR328.1
24780_CMPIN: length 2.7
  TOP w0.203: PR80.1 137.38,30.06 137.97,30.65 v1(137.97,30.65)
  BOTTOM w0.198: PU14.13 136.99,30.38 137.28,30.67 137.94,30.67 137.97,30.65 v1(137.97,30.65)
24780_CMPOUT: length 1.6
  BOTTOM w0.198: PR332.1 137.22,30.02 137.18,29.98 PU14.14
24780_CMSRC: length 1.6
  BOTTOM w0.198: PR319.2 133.6,34.66 133.6,34.02 133.82,33.8 PU14.3
24780_DH: length 11.9
  IN2 w0.533: v1(130.79,31.75) 129.5,33.04 127.32,33.04 126.84,33.51 122.19,33.51 v1(121.42,32.74)
  BOTTOM w0.198: v1(130.79,31.75) 130.95,31.58 131.44,31.58 131.45,31.58 PU14.26
24780_DL: length 7
  BOTTOM w0.198: 131.31,30.21 131.48,30.38 PU14.23
  BOTTOM w0.381: PQ36.4 126.44,29.24 126.45,29.22 128.1,29.22 v1(128.87,29.99) 129.09,30.21 131.31,30.21
24780_ILIM: length 5.6
  TOP w0.102: v1(135.06,26.78) 135.11,26.83 PR91.1
  TOP w0.254: v1(132.49,29.46) 132.49,28.73 133.05,28.17 PR89.1 PC103.2 134.53,28.17 134.54,28.18 134.93,28.18 135.03,28.08 PR91.1
  BOTTOM w0.198: PU14.21 132.77,29.18 v1(132.49,29.46)
24780_LX: length 9.7
  IN2 w0.533: v1(123.67,32.22) 124.2,32.75 126.4,32.75 126.81,32.34 129.04,32.34 v1(129.52,31.87)
  BOTTOM w0.198: PC271.1 130.44,32.23 130.99,32.23 131.24,31.98 PU14.27
  BOTTOM w0.406: v1(129.52,31.87) 130.12,32.47 PC271.1
24780_PROCHOT: length 8.4
  TOP w0.152: PR81.1 138.27,30.3 138.42,30.46 138.42,31.08 139.61,32.27 v1(139.61,32.4) 139.13,32.87 138.29,32.87 v1(137.96,32.53)
  TOP w0.203: PR81.1 138.27,29.54 138.58,29.23 PR84.1
  BOTTOM w0.198: PU14.10 136.73,31.58 137.18,32.03 137.18,32.39 137.29,32.51 137.93,32.51 v1(137.96,32.53)
24780_SRN: length 14.6
  BOTTOM w0.152: PR343.1 118.52,25.35 118.77,25.59 118.86,25.59 119.01,25.75 119.04,25.75 119.42,26.13 124.86,26.13 126.11,27.38 128.38,27.38 PC282.1 129.23,28.23 130.31,28.23 PC285.2
  BOTTOM w0.198: PC285.2 130.93,27.94 131.37,27.94 PR339.1
24780_SRP: length 14.7
  BOTTOM w0.152: 130.77,28.98 130.32,28.54 128.77,28.54 PC282.2 128.76,28.55 128.27,28.07 128.27,27.83 128.12,27.67 126,27.67 124.76,26.44 119.25,26.44 118.83,26.02 PR342.1
  BOTTOM w0.198: PC278.2 130.77,28.82 131.09,28.5 PR336.1
24780_VCC: length 2.8
  TOP w0.457: PR74.1 130.18,31.18 130.18,32.03 130.92,32.78 v1(131.04,32.78)
25810_POL#_EC: length 2.3
  TOP w0.102: TP37.1 14.51,19.52 15.05,20.05 R336.2 R337.1
+601_VCC: length 36.9
  TOP w0.203: v1(213.17,17.77) 213.3,17.64 C459.1 213.7,17.99 213.55,18.15 C452.1 C451.1 212.81,18.14 212.66,17.98 212.66,17.64 212.39,17.37 U18.20 ; R364.2 R371.2 204.69,16.47 204.48,16.47 204.18,16.17 R380.2 R389.2 R398.2 204.18,14.21 204.43,13.95 R406.2 204.43,12.94
  TOP w0.254: C516.1 207.06,12.17 207.61,12.71 C504.1 C498.1 207.61,14.47 v1(207.68,14.54) 207.83,14.69 207.83,15.18 208.03,15.37 U18.10 ; R417.2 205.05,11.89 204.43,12.5 R410.2 204.43,12.94
  TOP w0.508: R417.2 205.67,11.67 205.93,11.42 206.44,11.42 206.69,11.67 C516.1 207.06,11.03 v1(206.94,10.91)
  IN3 w0.508: v1(213.17,17.77) 213.55,17.77 213.93,17.39 213.93,17.26 214.44,16.75 216.34,16.75 216.72,16.37 216.72,13.07 215.83,12.18 212.93,12.18 212.66,12.44 210.37,12.44 209.75,13.07 208.09,13.07 206.94,11.92 v1(206.94,10.91)
+APU_VDD_33: length 26.6
  TOP w0.508: R295.2 C399.1 87.22,27.7 87.22,28.22 87.68,28.69 C392.1 C388.1 v1(87.68,30.71) 87.68,32.31 89.06,33.69 89.06,39.58 90.1,40.63 90.1,43.55 90.36,43.8 90.36,48.88 89.67,49.57 v2(89.67,49.79)
  BOTTOM w0.305: U30.AM17 90.07,49.39 v2(89.67,49.79) 89.31,50.15 U30.AL18
+APU_VDD_33_S5: length 16.7
  TOP w0.508: R291.2 C396.1 v1(91.54,30.01) 91.21,30.33 91.21,31.61 C389.1 C382.1 91.3,32.66 91.3,35.72 92.01,36.44 92.01,39.21 91.5,39.72 91.5,40.75
  BOTTOM w0.305: U30.AM16 90.11,50.19 U30.AL17
  BOTTOM w0.381: U30.AM16 90.91,49.24 91.14,49 v2(91.14,48.95)
+APU_VDDIO_AZ: length 16.1
  TOP w0.508: v1(99.25,37.43) 99.41,37.26 C351.1 ; v2(96.5,46.46) 96.2,46.16 96.2,43.8 96.96,43.04 96.96,40.75 97.24,40.47 97.24,39.69 97.45,39.48 97.45,36.59 97.73,36.3 C350.1 99.4,36.3 C351.1 ; C351.1 99.41,35.84 99.25,35.67 R240.2
  BOTTOM w0.381: v2(96.5,46.46) 96.5,46.48 96.6,46.58 96.6,46.66 96.91,46.96 U30.AP9
+AZA_CPVDD: length 22.9
  TOP w0.203: R320.1 199.2,22.34 199.71,21.82 R329.2 199.71,21.63 199.12,21.03 v1(199.12,20.94) ; R354.2 206.6,19.07 206.6,19.61 v1(206.54,19.67) 207.07,19.67 207.69,20.29 207.69,21.51 208.62,22.44 208.62,22.95 207.71,23.86 v1(206.44,23.86)
  IN1 w0.203: v1(206.54,19.67) 206.56,19.65 206.56,19.21 205.85,18.5 204.51,18.5 203.72,17.72 202.8,17.72 200.34,20.18 199.55,20.18 199.12,20.61 v1(199.12,20.94)
  BOTTOM w0.203: C665.1 206.66,23.86 v1(206.44,23.86) 206.44,23.89 206.74,24.19 206.74,24.37 206.66,24.46 U35.36
+AZA_DVDD: length 39.3
  TOP w0.203: v1(199.79,20.96) 200.19,20.96 200.46,20.7 R344.2 201.03,20.13 201.15,20 v1(201.46,20) 201.46,20.64 R334.2
  IN2 w0.203: v1(199.79,20.96) 199.79,20.64 199.38,20.23 198.49,20.23 197.83,19.57 v1(197.83,19.42) 195.26,21.98 195.26,28.43 197.67,30.85 197.67,31.99 199.2,33.51 v1(199.32,33.51)
  BOTTOM w0.203: v1(197.83,19.42) 197.29,18.88 197.29,18.86 197.16,18.72 193.77,18.72 193.36,19.14 193.36,20.97 193.1,21.22 v1(193.1,23.28) 193.31,23.49 R678.2 ; v1(199.32,33.51) 199.53,33.51 199.96,33.08 R647.2 ; U35.1 199.67,24.46 199.45,24.24 199.45,24.04 198.85,23.43 C664.2 198.85,22.56 199.06,22.35 C669.1 199.06,21.69 v1(199.79,20.96)
+ECSPI: length 11.4
  TOP w0.102: v1(159.95,23.84) 159.44,23.33 R683.2 158.54,23.33 158.18,23.68 158.18,25.13 158.79,25.74 158.79,26.43 159.28,26.92 R293.1 159.22,27.02 R284.1 R283.2
  BOTTOM w0.102: v1(159.95,23.84) 159.95,23.74 159.45,23.23 U37.8
+G_SEN_PW: length 8.9
  TOP w0.178: v1(64.04,14.49) C485.1 64.04,15.58 64.16,15.7 U17.1 ; R378.2 69.53,16.24 v1(69.78,15.99)
  TOP w0.203: R386.2 v1(66.48,14.39)
  TOP w0.305: U17.14 62.89,18.7 62.75,18.55 C449.1 ; U17.8 v1(65.81,18.7)
  TOP w0.508: C449.1 v1(62.3,19.47) R340.2 v1(63.56,20.31)
+TYPEC_VBUS: length 30.3
  TOP w0.203: R373.2 24.19,16.62 v1(24.45,16.88)
  TOP w0.508: C500.1 10.16,13.84 9.89,14.11 v1(9.89,14.51) ; C435.1 v1(8.94,20.17) ; CN15.B4 6.34,17.2 6.92,16.62 6.92,14.97 6.55,14.6 CN15.B9
  IN2 w0.508: 14.54,22.97 16.44,22.97 17.59,21.83 17.59,21.32 18.86,20.05 18.86,18.53 19.37,18.02 20.25,18.02 21.02,17.26 22.41,17.26 22.79,16.88 v1(24.45,16.88) ; CN15.B9 7.42,14.6 7.94,14.08 9.46,14.08 v1(9.89,14.51)
  IN3 w0.508: CN15.B4 7.2,18.27 7.68,18.27 8.32,18.91 8.32,19.16 8.94,19.79 v1(8.94,20.17)
  BOTTOM w0.254: CN15.A4 6.17,14.65 CN15.B9 ; CN15.B4 6.17,17.15 CN15.A9
  vias: v1(13.52,23.86) v1(13.52,23.23)
+USBPWR0:
  vias: v1(18.2,52.79) v1(18.27,52.08) v1(18.86,52.36) v1(18.86,51.73) v1(18.86,51.09) v1(19.42,52.03) v1(19.42,51.4) v1(19.95,54.52)
+USBPWR1: length 8.2
  BOTTOM w0.178: v1(20.64,33.9) 20.79,34.05 C633.1
  BOTTOM w0.508: v1(20.64,33.9) 18.71,33.9 16.32,36.28 16.32,38.47
  vias: v1(16.95,42.28) v1(16.95,41.64) v1(16.95,41.01) v1(17.59,42.28) v1(17.59,41.64) v1(17.59,41.01) v1(20.99,55.1) v1(21.3,55.66) v1(21.93,55.66) v1(22.57,55.66) v1(22.57,55.03)
+VGA_CORE: length 107.8
  IN2 w0.152: v1(70.22,104.04) 70.04,103.87 70.04,101.54 76.47,95.11 85.28,95.11 87.44,97.27 88.51,97.27 89.17,97.93 89.17,98.45 88.2,99.43 87.82,99.43 v1(87.69,99.3) ; v1(66.52,106.5) 68.21,106.5 69.02,105.69 69.02,101.21 76.01,94.22 85.79,94.22 87.82,96.25 88.76,96.25 90.07,97.56 91.54,97.56 91.95,97.97 91.95,102.4 91.5,102.86 89.72,102.86 89.12,103.46 v1(89.12,105.12)
  IN3 w0.381: v1(126.43,121.53) 126.35,121.45 124.78,121.45 124.47,121.75 124.47,122.06 124.17,122.36 121.22,122.36 118.04,119.19 118.04,118.35 116.38,116.69 116.38,109.96 v1(115.53,109.1)
  BOTTOM w0.203: PL8.2 88.74,101.26 88.37,100.89 88.37,99.96 87.71,99.3 v1(87.69,99.3) ; PL7.2 92.79,108.47 89.66,108.47 89.51,108.32 89.51,105.51 v1(89.12,105.12) ; v1(70.22,104.04) 70.11,103.94 PR196.2 ; PR188.2 67.02,106 v1(66.52,106.5)
  BOTTOM w0.381: v1(126.43,121.53) 126.43,120.88 PR141.1
  vias: v1(95.69,102.48) v1(95.69,101.84) v1(103.93,108.64) v1(106.67,105.75) v1(106.97,109.33) v1(107.3,106.22) v1(107.3,105.22) v1(107.3,103.22) v1(107.3,102.22) v1(107.45,107.1) v1(107.35,101.23) v1(107.45,104.28) v1(108.47,104.28) v1(108.49,101.31) v1(109.49,104.28) v1(109.56,101.26) v1(110.5,109.08) v1(110.5,108.22) v1(110.5,104.28) v1(110.5,101.26) v1(111.54,108.22) v1(111.52,101.08) v1(111.49,100.37) v1(112.51,108.24) v1(112.46,105.12) v1(112.48,104.28) v1(112.51,100.37) v1(113.42,108.24) v1(114.34,105.22) v1(114.51,102.12) v1(114.51,101.08) v1(114.54,100.37) v1(114.57,108.24) v1(114.59,104.2) v1(115.58,105.22) v3(88.12,103.92) v3(88.12,103.14) v3(88.12,102.37) v3(88.15,101.64) v3(88.71,111.75) v3(88.71,110.98) v3(88.89,102.02) v3(89.47,111.75) v3(89.47,110.98) v3(89.47,110.22) v3(89.47,109.46) v3(89.65,102.02) v3(90.23,111.75) v3(90.23,110.98) v3(90.23,110.22) v3(90.23,109.46) v3(90.23,107.94) v3(90.23,107.17) v3(90.23,106.44) v3(90.23,105.7) v3(90.23,104.96) v3(90.23,104.23) v3(90.23,103.49) v3(90.99,111.75) v3(90.99,110.98) v3(90.99,110.22) v3(90.99,109.46) v3(90.99,107.94) v3(90.99,107.17) v3(90.99,106.44) v3(90.99,105.7) v3(90.99,104.96) v3(90.99,104.23) v3(90.99,103.49) v3(91.81,110.96) v3(91.88,111.75) v3(92.67,111.75) v3(95.01,103.19) v3(95.24,107.43) v3(95.24,106.67) v3(95.24,105.78) v3(95.24,105.02) v3(95.16,104.08) v3(95.74,103.16)
+VREF_CA0: length 2.3
  TOP w0.102: C298.1 v1(50.62,51.47)
  BOTTOM w0.254: CN5.164 51.5,53.46 v1(51.62,53.33)
+VREF_CA1: length 109.3
  TOP w0.203: 36,77.7 C199.2 ; 37.33,42.18 37.36,42.15 C338.1 ; 36.94,42.91 C336.2 ; C197.1 36.89,77.33
  TOP w0.356: 37.33,42.18 U12.M1 ; U6.M1 37.33,76.06
  TOP w0.381: 36.02,54.67 36.36,55 C273.2 C274.1 37.3,54.37 37.33,54.34 U9.M1 ; 37.33,42.18 37.33,42.53 37.23,42.62 ; U5.M1 38.67,88.25 41.51,88.25 43.1,89.84
  TOP w0.508: 29.13,56.01 32.69,56.01 34.03,54.67 36.02,54.67 ; 29.13,56.01 28.71,55.59 v1(28.71,49.03) 27.77,48.09 27.77,43.24 28.43,42.58 31.61,42.58 31.66,42.53 34.61,42.53 35.19,43.12 36.73,43.12 37.23,42.62 ; 29.13,56.01 28.26,56.87 28.26,65.32 28.92,65.98 28.26,66.63 28.26,74.92 v1(29.91,76.57) 30.19,76.85 34.76,76.85 35.61,77.7 36.52,77.7 36.89,77.33 36.89,76.95 37.33,76.51 37.33,76.06
  IN3 w0.508: v1(43.29,92.01) 43.17,91.88 41.57,91.88 40.68,92.77 31.35,92.77 30.16,91.58 30.16,79.44 30.49,79.11 30.49,77.15 v1(29.91,76.57)
AC_PRESENT_EC: length 233.7
  TOP w0.102: v1(178.5,23.33) 178.88,23.71 179.97,23.71 180.32,23.36 U15.84 ; v1(126.93,123.05) 127.09,123.05 127.72,122.41 128.33,122.41 128.56,122.19 R28.2
  IN2 w0.089: v1(151.5,40.45) 151.06,40.88 151.06,44.61 150.94,44.74 150.94,45.83 151.95,46.85 151.95,48.98 152.8,49.83 152.8,54.73 152.23,56.11 151.46,56.88 151.46,59.89 150.46,60.9 150.46,62.2 149.57,63.09 149.57,77.05 149.03,77.58 149.03,116.45 146.75,118.73 144.79,118.73 144.41,119.11 140.65,119.11 138.87,120.89 131.13,120.89 129.47,122.54 127.44,122.54 v1(126.93,123.05) ; v1(115.49,35.79) 115.25,36.03 115.25,36.18 113.75,37.68 110.96,37.68 110.73,37.45 108.34,37.45 108.22,37.32 106.49,37.32 106.08,37.73 102.53,37.73 100.52,39.74 v2(100.26,39.74)
  IN3 w0.089: v1(115.49,35.79) 116.01,36.31 117.87,36.31 118.27,35.9 118.27,35.44 119.57,34.15 120.58,34.15 121.85,32.88 121.85,31.86 124.2,29.51 131.27,29.51 132.23,28.55 134.9,28.55 135.28,28.17 137.24,28.17 139.57,25.84 154.09,25.84 154.58,25.35 158.63,25.35 159.52,26.24 159.52,27.34 159.97,27.8 168.05,27.8 168.84,27.01 v1(168.84,26.66) 168.84,26.39 169.23,26.01 169.23,24.91 169.78,24.36 171.62,24.36 172.59,25.34 176.77,25.34 178.5,23.61 v1(178.5,23.33) ; v1(151.5,40.45) 151.5,39.19 152.49,38.2 153.94,38.2 157.3,34.83 158.42,34.83 158.58,35 164.08,35 v1(164.08,35.01)
  BOTTOM w0.102: v1(168.84,26.66) 168.84,27.25 169.21,27.62 169.21,29.32 169.68,29.79 169.68,32.04 170.24,32.6 170.24,33.64 168.72,35.17 164.24,35.17 v1(164.08,35.01) ; U30.BA8 98.55,41.89 98.92,41.52 99.02,41.52 99.43,41.11 99.43,40.43 99.75,40.11 99.89,40.11 v2(100.26,39.74)
ACCEL_INT2: length 164.9
  TOP w0.102: v1(69.45,20.84) 69.45,20.9 D11.1 68.65,20.93 68.74,20.84 v1(68.74,20.69)
  IN2 w0.089: v1(211.8,17.92) 211.77,17.89 209.48,17.89 208.09,16.5 208.09,15.73 207.25,14.9 199.12,14.9 198.44,14.21 191.83,14.21 191.45,14.59 191.45,18.9 190.23,20.12 188.59,20.12 187.44,18.96 187.44,17.67 186.2,16.43 185.27,16.43 185.06,16.64 182.59,16.64 180.77,14.82 171.74,14.82 171.33,14.41 165.21,14.41 163.64,15.99 153.86,15.99 153.48,16.37 153.48,17.35 153.19,17.64 149.88,17.64 147.88,19.63 146.37,19.63 145.69,20.31 142.52,20.31 141,18.78 135.7,18.78 134.73,19.75 134.31,19.75 133.09,18.53 124.52,18.53 123.86,17.87 111.06,17.87 110.07,16.88 105.85,16.88 105.34,16.37 104.71,16.37 104.07,17 99.02,17 96.94,19.09 93.09,19.09 90.58,21.6 79.01,21.6 78.22,20.81 69.78,20.81 69.66,20.69 v1(68.74,20.69)
  BOTTOM w0.102: R707.2 212.18,16.82 211.9,17.11 211.9,17.82 v1(211.8,17.92)
