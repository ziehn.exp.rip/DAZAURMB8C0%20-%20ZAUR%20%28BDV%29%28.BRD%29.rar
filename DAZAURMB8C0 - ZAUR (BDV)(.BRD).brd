# Allegro board DAZAURMB8C0 - ZAUR (BDV)(.BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VDDQ_VTT on TOP (solid shape): 41.97,92.57 41.97,90.54 41.84,90.41 30.41,90.41 29.94,89.93 29.94,89.08 30.07,88.94 30.35,88.94 30.35,88.95 30.41,88.89 30.41,81.77 30.29,81.65 30.03,81.65 29.78,81.39 29.78,80.89 29.91,80.76 30.29,80.76 30.41,80.63 30.41,79.38 30.27,79.24 29.28,79.24 29.09,79.2 28.92,79.09 28.91,79.09 28.78,78.86 28.78,78.6 28.76,78.51 28.68,78.47 27.87,78.47 27.87,84.82 27.5,85.2 27.5,92.45 27.75,92.7 41.85,92.7
+VDDQ_VTT on BOTTOM (solid shape): 49.22,31.96 49.22,30.19 49.33,30.08 50.17,30.08 50.21,30.08 50.25,30.07 51.02,30.07 51.15,29.94 51.15,29.89 51.14,29.85 51.1,29.84 50.25,29.84 50.21,29.83 50.17,29.83 49.37,29.83 49.37,29.83 48.09,29.83 47.94,29.98 47.94,31.37 48.33,31.76 48.41,31.87 48.44,32 48.44,32.02 48.54,32.12 49.06,32.12
+VDDQ_VTT on IN1 (solid shape): outline of 140 points within 24.95,28.84 49.57,80.27
+VIN on TOP (solid shape): outline of 10208 points within 50.3,8.05 147.08,125.59
+VIN on BOTTOM (solid shape): 83.37,122.35 83.37,120.63 82.91,120.17 79.25,120.17 78.6,119.52 78.6,119.36 78.33,119.08 76.95,119.08 76.7,119.34 76.7,120.3 76.71,120.31 77.19,120.31 77.39,120.5 77.78,120.5 78.07,120.79 78.07,121.19 78.18,121.31 79.62,121.31 79.88,121.57 79.88,122.24 80.06,122.42 83.3,122.42
+VIN on BOTTOM (solid shape): 123.37,38.97 123.37,36.88 123.36,36.87 123.36,36.42 123.65,36.13 125.18,36.13 125.2,36.11 126.85,36.11 126.97,35.98 126.97,35.98 127.06,35.89 127.06,35.42 127.83,34.64 127.83,34.03 127.69,33.89 125.28,33.89 125.06,33.67 120.75,33.67 120.5,33.92 120.5,34.34 120.53,34.37 120.53,39.12 120.64,39.23 123.12,39.23
+VIN on BOTTOM (solid shape): 134.38,69.4 134.38,63.17 134.23,63.02 129.76,63.02 129.54,63.23 125.4,63.23 124.81,63.83 124.81,65.45 124.78,65.48 124.78,65.86 124.73,65.91 124.73,67.03 124.13,67.63 124.04,67.63 124.04,67.63 123.51,67.63 123.21,67.93 123.21,68.33 123.31,68.43 124.86,68.43 125.08,68.65 128.41,68.65 129.53,69.77 134.01,69.77
+VIN on BOTTOM (solid shape): 143.09,33.87 143.09,33.28 143.3,33.07 145.22,33.07 145.28,33.05 145.35,33.04 145.42,33.05 145.48,33.07 145.64,33.07 145.68,33.02 145.68,32.51 145.65,32.47 143.37,32.47 143.01,32.11 142.99,32.09 142.99,29.91 142.43,29.35 140.66,29.35 140.55,29.46 140.55,32.78 140.34,32.98 139.24,32.98 139.05,33.17 139.05,34.86 139.33,35.14 141.82,35.14
+VIN on BOTTOM (solid shape): 143.32,65.42 144.11,65.42 144.31,65.61 146.98,65.61 147.1,65.5 147.1,65.14 147.32,64.92 148.11,64.92 148.11,64.92 148.11,64.67 148.11,64.66 147.32,64.66 147.1,64.44 147.1,64.25 147.05,64.2 144.4,64.2 144.31,64.28 144.31,64.46 144.11,64.66 143.32,64.66 143.14,64.48 142.17,64.48 142,64.31 142,62.88 141.9,62.78 141.54,62.78 141.25,63.06 141.25,64.92 144.11,64.92 144.11,65.16 143.32,65.16 143.32,64.92 141.25,64.92 141.25,65.8 141.6,66.14 142.6,66.14
+VIN on BOTTOM (solid shape): 48.64,20.75 48.64,19.33 48.78,19.19 50.28,19.19 50.33,19.14 50.33,18.5 51.22,17.61 51.22,15.76 52.81,14.16 52.81,13.86 52.68,13.73 48.63,13.73 47.8,14.55 47.8,16.42 47.69,16.53 47.69,16.89 47.45,17.12 47.45,17.17 47.46,17.18 47.46,17.61 47.31,17.75 46.33,17.75 46.33,17.76 46.02,18.07 46.02,18.51 45.93,18.6 43.68,18.6 43.63,18.66 43.63,19.08 43.63,19.08 43.63,19.22 43.67,19.26 46.26,19.26 46.59,18.94 48.04,18.94 48.1,19 48.1,19 48.23,19.13 48.23,19.58 47.7,20.1 46.61,20.1 46.61,20.1 46.61,20.97 46.61,20.97 48.42,20.97
+VIN on BOTTOM (solid shape): 143.85,45.13 143.85,44.34 144.07,44.12 144.26,44.12 144.31,44.07 144.31,41.42 144.23,41.33 144.05,41.33 143.85,41.13 143.85,40.34 143.99,40.2 143.99,39.23 144.14,39.08 144.61,39.08 144.98,39.45 145.54,39.45 145.59,39.4 145.59,39.01 145.34,38.76 145.28,38.8 145.23,38.82 145.18,38.84 145.12,38.85 145.07,38.85 145.01,38.84 144.96,38.83 144.91,38.8 144.87,38.77 144.83,38.74 144.79,38.7 144.76,38.65 144.74,38.6 144.72,38.55 144.71,38.49 144.72,38.38 144.72,38.35 144.71,38.32 144.69,38.3 144.67,38.28 144.64,38.27 144.62,38.27 142.71,38.27 142.37,38.62 142.37,39.62 143.09,40.34 143.59,40.34 143.59,41.13 143.35,41.13 143.35,40.34 143.09,40.34 143.09,41.13 142.9,41.33 142.9,44 143.01,44.12 143.37,44.12 143.59,44.34 143.59,45.13 143.59,45.13 143.84,45.13
+VIN on BOTTOM (solid shape): outline of 107 points within 136.35,47.29 144.25,62.89
+VIN on BOTTOM (solid shape): outline of 139 points within 69.15,92.44 81.61,114.42
+VIN_BLIGHT on TOP (solid shape): 64.25,107.91 64.25,106.13 64.46,105.92 64.46,104.46 64.42,104.41 62.72,104.41 62.63,104.5 62.63,107.8 62.82,107.99 64.17,107.99
+VIN_BLIGHT on BOTTOM (solid shape): 64.73,108.06 64.76,108.05 64.77,108.04 64.78,108.01 64.78,105.51 64.54,105.27 62.6,105.27 62.46,105.41 62.46,106.13 62.57,106.24 62.57,106.71 63.07,106.71 63.07,107.54 62.87,107.54 62.87,106.71 62.57,106.71 62.57,107.83 62.8,108.06
GND on TOP (solid shape): 43.75,123.38 36.43,123.38 36.43,124.39 43.75,124.39
GND on TOP (solid shape): 45.99,104.04 43.29,104.04 43.29,106.75 45.99,106.75
GND on TOP (solid shape): 108.82,35.8 108.82,32.75 105.19,32.75 105.19,35.8 106.13,35.8 106.81,36.48 108.15,36.48
GND on TOP (solid shape): 49.3,122.56 49.3,121.74 49.25,121.69 48.3,121.69 47.79,122.21 47.79,122.58 47.94,122.74 49.12,122.74
GND on TOP (solid shape): 119.67,22.14 119.67,21.66 119.51,21.5 116.09,21.5 116.01,21.58 116.01,22.72 116.27,22.97 118.84,22.97
GND on TOP (solid shape): 46.92,20.62 46.92,19.89 46.67,19.65 42.67,19.65 42.6,19.73 42.6,20.43 42.9,20.73 43.16,20.73 43.87,21.45 46.09,21.45
GND on TOP (solid shape): 75.5,113.37 75.5,110.3 74.99,109.79 71.99,109.79 71.41,110.37 71.41,113.52 71.72,113.83 75.04,113.83
GND on TOP (solid shape): 128.51,31.85 128.51,30.15 128.32,29.97 125.68,29.97 125.49,30.16 125.49,31.89 125.65,32.05 128.31,32.05
GND on TOP (solid shape): 23.81,19.01 23.81,17.88 24.11,17.58 24.11,17.3 23.92,17.11 22.56,17.11 22.42,17.25 22.42,17.65 22.92,18.14 22.92,18.95 23.05,19.09 23.73,19.09
GND on TOP (solid shape): 146.67,70.28 146.67,68.55 146.84,68.38 146.84,67.51 146.68,67.36 143.68,67.36 143.51,67.52 143.51,68.81 144.09,69.38 144.09,69.53 145.45,70.89 146.06,70.89
GND on TOP (solid shape): 149.41,22.97 149.41,20.31 149.29,20.18 148.4,20.18 148.26,20.32 148.26,22.96 148.4,23.1 149.29,23.1
GND on TOP (solid shape): 156.78,24.88 156.78,23.86 156.69,23.77 154.31,23.77 154.11,23.96 154.11,24.7 154.22,24.81 155.82,24.81 156.02,25.01 156.65,25.01
GND on TOP (solid shape): 89.28,30.15 89.28,29.02 88.91,28.65 88.91,28.51 88.68,28.28 88.68,27.19 88.66,27.16 88.07,27.16 87.95,27.29 87.95,28.18 88.2,28.43 88.2,30.09 88.33,30.21 89.22,30.21
GND on TOP (solid shape): 92.01,117.13 92.01,116.06 91.76,115.81 90.87,115.81 90.36,116.32 90.3,116.32 89.97,116.32 89.9,116.39 89.9,116.9 90.44,117.44 91.71,117.44
GND on TOP (solid shape): 109.03,21.31 109.03,19.42 108.52,18.91 104.96,18.91 104.84,19.04 104.84,20.05 105.09,20.31 105.18,20.31 105.19,20.29 105.91,20.29 106.21,20.58 107.54,20.58 108.38,21.43 108.9,21.43
GND on TOP (solid shape): 52.59,106.44 52.59,105.88 52.28,105.57 49.31,105.57 48.96,105.92 48.96,106.18 49.12,106.34 49.39,106.34 49.6,106.12 51.54,106.12 51.76,106.12 52.19,106.55 52.47,106.55
GND on TOP (solid shape): 59.88,28.88 59.88,26.59 58.34,25.05 55.68,25.05 55.54,25.19 55.54,26.16 55.55,26.16 55.55,26.39 55.74,26.58 57.44,26.58 57.73,26.29 58.32,26.29 58.43,26.4 58.43,28.95 58.56,29.08 59.68,29.08
GND on TOP (solid shape): 111.06,111.33 111.06,110.73 110.93,110.6 110.3,110.6 109.92,110.98 107.38,110.98 107,110.6 103.85,110.6 103.74,110.71 103.74,111.2 103.96,111.42 110.97,111.42
GND on TOP (solid shape): 106.84,103.64 106.84,101.97 106.64,101.76 105.37,101.76 105.05,102.08 104.63,102.08 103.86,102.86 102.31,102.86 102.1,103.07 102.1,103.32 102.35,103.57 102.75,103.57 102.76,103.57 103.27,103.57 103.46,103.77 106.72,103.77
GND on TOP (solid shape): 116.88,102.35 116.88,100.27 115.93,99.32 113.3,99.32 113.26,99.37 113.26,100.01 113.29,100.05 114.29,100.05 114.36,99.98 114.72,99.98 114.79,100.04 114.87,100.05 115.77,100.05 116.08,100.35 116.08,102.21 116.34,102.48 116.75,102.48
GND on TOP (solid shape): 62.24,49.35 62.24,49.22 62.68,48.78 64.85,48.78 65.05,48.59 65.05,47.67 65.34,47.38 70.78,47.38 71.18,46.98 71.18,45.56 70.76,45.14 64.73,45.14 62.86,47 60.82,47 60.17,47.65 60.17,49.4 60.26,49.48 61.46,49.48 61.56,49.58 62.01,49.58
GND on TOP (solid shape): 140.55,75.87 140.55,75.23 141.42,74.36 149.2,74.36 149.28,74.28 149.28,73.35 149.17,73.24 144.25,73.24 144.13,73.31 144,73.33 143.88,73.31 143.76,73.24 137.58,73.24 136.68,74.14 136.68,77.06 136.82,77.2 139.23,77.2
GND on TOP (solid shape): 65.59,66.76 65.59,66.53 65.47,66.41 64.96,66.41 64.8,66.56 61.94,66.56 61.78,66.72 61.78,66.84 61.54,67.09 60.09,67.09 60.05,67.13 60.05,67.95 60.13,68.14 60.1,68.35 60.09,68.38 60.11,68.41 60.23,68.53 63.82,68.53
GND on TOP (solid shape): 110.61,100.56 110.61,99.66 110.47,99.53 108.18,99.53 108.05,99.4 108.05,98.58 108.19,98.44 108.27,98.44 108.32,98.38 108.79,98.38 108.92,98.25 108.92,97.81 108.98,97.76 108.98,97.55 108.9,97.47 108.55,97.47 108.32,97.7 107.3,97.7 106.5,98.49 105.63,98.49 105.39,98.73 105.39,99.41 105.42,99.44 107.58,99.44 107.83,99.7 107.83,100.49 108.09,100.75 110.42,100.75
GND on TOP (solid shape): 116,104.14 116,102.71 115.87,102.58 113.74,102.58 113.59,102.44 113.59,102.04 113.5,101.94 113.07,101.94 112.97,102.05 112.97,102.74 112.81,102.9 111.03,102.9 110.91,102.78 110.91,101.99 110.74,101.81 107.73,101.81 107.71,101.84 107.71,103.49 107.76,103.54 115.19,103.54 115.3,103.66 115.3,104.09 115.46,104.25 115.88,104.25
GND on TOP (solid shape): 147.5,33.74 147.5,30.5 147.5,30.5 147.5,30.4 147.42,30.32 146.59,30.32 145.98,29.7 145.96,29.7 145.88,29.68 145.8,29.64 143.17,29.64 143.12,29.69 143.12,30.72 143.1,30.79 143.06,30.85 142.95,30.96 142.95,31.57 143.4,32.01 143.95,32.01 144.52,32.58 145.27,32.58 146.52,33.83 147.4,33.83
GND on TOP (solid shape): 44.26,43.39 44.26,42.34 44.07,42.16 39.02,42.16 38.79,41.93 38.22,41.93 38.17,41.98 38.17,42.98 38.73,42.98 39.06,43.31 40.38,43.31 40.57,43.26 40.75,43.3 40.76,43.31 41.05,43.31 41.08,43.28 41.08,42.8 41.17,42.72 43.41,42.72 43.5,42.81 43.5,43.41 43.53,43.45 44.21,43.45
GND on TOP (solid shape): 215.05,18.27 215.9,17.97 216.8,17.87 217.06,17.87 217.32,17.9 217.35,17.9 217.74,17.51 217.74,12.81 217.61,12.69 217.1,12.69 216.98,12.81 216.98,17 216.72,17.26 215.07,17.26 214.95,17.13 214.56,17.13 214.44,17.26 214.44,17.89 214.82,18.27 215.04,18.27
GND on TOP (solid shape): 45.28,28.84 45.28,28.49 45.25,28.46 43.54,28.46 43.46,28.37 42.62,28.37 42.15,27.9 42.1,27.9 42.07,27.93 42.07,27.94 41.18,27.94 41.18,27.93 41.15,27.9 41.08,27.9 40.92,27.74 40.92,25.93 40.25,25.26 39.34,25.26 39.25,25.35 39.25,25.95 38.9,26.29 38.9,26.74 38.91,26.74 39.77,26.74 39.81,26.74 39.98,26.91 39.98,28.79 40.17,28.98 43.93,28.98 44.07,29.12 45,29.12
GND on TOP (solid shape): 47.32,93.02 47.32,91.86 47.21,91.76 44.72,91.76 44.54,91.58 44.54,91.01 44.44,90.91 44.18,90.91 44.1,91 44.1,92.69 43.83,92.95 27.62,92.95 27.24,92.57 27.24,84.94 27.62,84.57 27.62,80.05 27.58,80.01 26.89,80.01 26.4,80.5 26.4,81.75 26.55,81.89 26.56,81.89 26.81,82.15 26.81,82.15 26.84,82.19 26.84,83.82 26.37,84.29 26.37,93.3 27.29,94.22 46.12,94.22
GND on TOP (solid shape): 216.6,31.77 216.72,31.53 216.98,31.43 217.15,31.47 217.28,31.58 217.48,31.58 217.7,31.36 217.7,27.63 217.44,27.38 216.3,27.38 215.95,27.72 215.95,29.87 215.88,29.94 215.88,30.51 215.62,30.77 214.1,30.77 213.94,30.93 213.94,31.39 214.36,31.81 216.59,31.81
GND on TOP (solid shape): 88.69,115.96 88.72,115.96 88.82,115.85 88.94,115.81 89.24,115.81 89.31,115.82 89.37,115.85 89.38,115.86 89.47,115.86 89.88,115.45 89.88,114.95 89.86,114.91 89.83,114.9 88.86,114.9 88.73,114.77 88.73,113.63 88.63,113.52 88.05,113.52 87.87,113.7 87.87,115.2 87.56,115.51 87.56,115.73 87.79,115.96
GND on TOP (solid shape): 106.74,125.84 106.74,124.7 105.98,123.94 105.98,123.68 105.85,123.56 104.33,123.56 103.57,122.8 103.57,122.79 103.19,122.41 103.19,121.55 102.98,121.34 102.42,121.34 102.33,121.43 102.33,122.04 102.48,122.19 102.48,122.73 102.41,122.8 102.38,122.8 102.37,122.83 102.3,122.93 102.2,123 102.18,123.02 102.17,123.05 102.17,124.19 101.53,124.83 101.53,125.75 101.7,125.92 106.66,125.92
GND on TOP (solid shape): 143.83,25.26 143.83,24.78 144.36,24.24 144.36,20.5 143.15,19.29 142.93,19.11 142.03,18.56 141.01,18.27 139.97,18.27 139.63,18.34 139.3,18.43 139.15,18.46 139,18.46 138.94,18.53 138.24,18.53 136.89,19.87 136.89,24.93 138.11,26.15 142.94,26.15
GND on TOP (solid shape): 196.89,16.14 196.89,15.68 197.27,15.3 197.7,15.3 197.81,15.19 197.81,15.03 197.8,15.01 197.7,14.87 197.67,14.72 197.68,14.68 197.68,14.63 197.68,14.6 197.62,14.55 197.62,13.72 197.55,13.65 197.14,13.65 197.06,13.73 197.06,14.34 196.94,14.46 195.3,14.46 195.25,14.5 195.25,15.06 195.03,15.28 194.8,15.28 194.45,15.63 194.45,16.11 194.58,16.24 196.78,16.24
GND on TOP (solid shape): 19.25,34.83 19.25,34.3 19.12,34.18 19.12,33.75 19.11,33.71 19.07,33.7 18.27,33.7 18.13,33.79 17.97,33.82 17.46,33.82 17.3,33.79 17.16,33.7 16.91,33.7 16.8,33.69 16.71,33.65 16.67,33.64 16.65,33.66 16.58,33.73 16.58,34.8 16.86,35.08 19,35.08
GND on TOP (solid shape): 69.66,85.58 73.34,85.58 73.59,85.33 73.59,83.58 73.19,83.17 70.06,83.17 69.85,82.96 69.85,79.82 70.31,79.35 72.99,79.35 73.16,79.18 73.16,78.14 75.63,75.68 75.63,73.14 74.94,72.45 74.9,72.45 74.7,72.4 74.56,72.25 74.23,72.25 67,79.49 66.95,79.49 66.95,79.53 66.61,79.87 66.61,87.49 66.74,87.62 67.63,87.62
GND on TOP (solid shape): 106.71,107.46 106.71,106.79 106.65,106.7 106.54,106.72 106.41,106.81 106.26,106.84 105.99,106.73 105.88,106.46 105.89,106.37 105.92,106.29 105.92,106.19 105.83,106.14 104.5,106.14 104.41,106.23 104.41,106.77 104.28,106.9 104.28,107.46 104.35,107.54 106.64,107.54
GND on TOP (solid shape): 110.52,107.49 115.86,107.49 116.04,107.31 116.04,106.33 116.48,105.88 116.48,105.51 116.39,105.42 116.03,105.42 115.82,105.62 115.34,105.62 115.16,105.43 114.75,105.43 114.56,105.62 114.2,105.62 113.7,105.12 112.99,105.12 112.75,105.37 112.6,105.51 112.33,105.51 112.27,105.45 112.18,105.38 112.12,105.3 111.98,105.16 110.77,105.16 110.45,105.48 110.45,106.56 110.3,106.72 108.44,106.72 108.37,106.79 108.37,106.81 107.7,107.48 107.53,107.48 107.46,107.48 107.42,107.52 107.42,107.93 107.49,107.99 110.01,107.99
GND on TOP (solid shape): 41.32,107.91 41.97,107.91 42.23,107.66 42.61,107.66 42.68,107.58 42.68,107.33 42.5,107.14 42,107.14 42,107.17 41.94,107.23 41.95,107.27 41.95,107.32 41.6,107.7 41.19,107.37 41.17,107.34 41.17,106.35 41.12,106.31 41.08,106.31 41.01,106.27 40.85,106.27 40.79,106.31 40.38,106.72 39.69,106.72 39.38,106.41 38.82,106.41 38.62,106.62 38.62,107.22 39.57,108.17 41.06,108.17
GND on TOP (solid shape): 151.9,30.24 151.9,29.98 152.16,29.73 152.5,29.73 152.5,29.73 152.93,29.73 153.41,29.24 156.62,29.24 156.71,29.21 156.81,29.2 157.08,29.31 157.19,29.58 157.18,29.64 157.17,29.7 157.18,29.79 157.26,29.83 158,29.83 158.05,29.78 158.05,29.48 157.87,29.3 157.87,28.53 157.65,28.31 157.65,28.05 157.54,27.94 157.15,27.94 157.08,28.01 157.08,28.24 157.02,28.3 153.24,28.3 152.91,27.96 152.49,27.96 151.93,28.52 151.15,28.52 151.09,28.58 151.09,29.19 151.11,29.26 151.12,29.33 151.17,29.39 151.17,30.45 151.22,30.49 151.65,30.49
GND on TOP (solid shape): 22.47,76.49 22.88,76.49 22.92,76.44 22.97,76.44 23.15,76.26 23.35,76.26 23.37,76.25 23.55,76.06 23.55,75.74 23.56,75.71 23.56,75.39 23.55,75.36 23.55,74.98 23.56,74.95 23.56,74.63 23.55,74.6 23.55,74.28 23.43,74.15 23.18,74.15 23.12,74.21 23.12,74.26 23.1,74.37 23.05,74.47 23.05,74.79 23.04,74.8 23.04,75.13 22.87,75.3 22.31,75.3 22.21,75.4 22.21,76.01 22.16,76.06 22.16,76.47 22.08,76.54 21.22,76.54 21.02,76.34 21.02,75.75 21.27,75.5 21.58,75.5 21.6,75.48 21.6,75.3 21.58,75.27 20.45,75.27 20.4,75.32 20.4,76.96 20.89,77.46 21.5,77.46
GND on TOP (solid shape): 152.84,19.29 152.84,18.53 153.1,18.27 153.41,18.27 153.5,18.28 153.72,18.41 153.81,18.66 153.8,18.72 153.79,18.78 153.8,18.87 153.89,18.91 154.19,18.91 154.6,18.5 157.06,18.5 157.54,18.02 158.68,18.02 158.94,18.27 159.52,18.27 159.57,18.27 159.81,18.27 159.91,18.17 159.93,18.17 159.95,18.15 160.72,18.15 160.97,17.89 163.39,17.89 163.64,18.14 164.24,18.14 164.43,17.95 164.47,17.95 164.53,17.89 164.82,17.89 164.82,17.86 166.3,17.86 166.3,17.66 164.82,17.66 164.82,17.64 164.53,17.64 164.27,17.39 161.86,17.39 161.61,17.13 160.84,17.13 160.59,17.39 148.75,17.39 148.63,17.51 148.63,18.13 148.67,18.17 149.56,18.17 149.66,18.27 149.68,18.27 149.94,18.39 150.05,18.64 150.05,18.66 150.13,18.74 150.13,19.37 150.17,19.42 151.06,19.42 151.19,19.54 152.59,19.54
GND on TOP (solid shape): 137.07,56.05 137.07,54.48 137.07,54.05 137.11,54 137.15,53.97 137.22,53.9 137.34,53.9 137.34,53.91 137.73,53.91 137.86,54.04 137.86,54.18 137.99,54.31 138.78,54.31 138.99,54.1 138.99,49.44 138.9,49.36 138.49,49.36 138.29,49.56 138.29,50 138.11,50.18 136.21,50.18 135.82,49.8 134.12,49.8 134.12,49.8 134.12,50.63 134.74,50.63 134.74,50.58 134.76,50.52 134.78,50.47 134.8,50.42 134.84,50.38 134.88,50.34 134.92,50.31 134.97,50.28 135.02,50.27 135.08,50.26 135.14,50.25 135.19,50.26 135.24,50.27 135.3,50.3 135.34,50.32 135.39,50.36 135.42,50.4 135.45,50.45 135.48,50.5 135.49,50.55 135.5,50.61 135.5,50.66 135.49,50.72 135.48,50.77 135.45,50.82 135.42,50.87 135.39,50.91 135.34,50.95 135.3,50.97 135.24,51 135.19,51.01 135.14,51.02 135.08,51.01 135.02,51 134.97,50.99 134.92,50.96 134.88,50.93 134.84,50.89 134.8,50.85 134.78,50.8 134.76,50.74 134.74,50.69 134.74,50.63 134.12,50.63 134.12,53.89 134.35,54.12 135.4,54.12 135.95,54.68 135.95,56.05 136.08,56.16 136.96,56.16
GND on TOP (solid shape): 138.74,35.36 138.74,35 138.72,34.94 138.65,34.9 138.61,34.91 138.54,34.91 138.27,34.8 138.16,34.53 138.24,34.29 138.46,34.16 138.47,34.15 138.52,34.1 138.51,34.07 138.51,33.77 138.46,33.72 138.44,33.72 138.3,33.68 138.18,33.59 137.71,33.59 137.56,33.44 137.11,33.44 136.98,33.31 136.98,29.58 136.88,29.48 136.88,29.01 136.79,28.92 136.42,28.92 136.36,28.97 136.36,29.31 136.13,29.54 135.7,29.54 135.47,29.31 135.47,29.08 135.06,28.66 132.96,28.66 132.87,28.76 132.87,29.11 132.91,29.17 132.94,29.22 132.94,29.66 132.68,29.93 132.3,29.93 132.24,29.9 132.19,29.86 131.82,29.86 131.69,30 131.69,30.44 131.8,30.55 132.25,30.55 132.4,30.7 132.4,32.96 132.25,33.11 132.25,33.85 132.28,33.88 135.5,33.88 135.98,34.35 135.98,34.42 136.01,34.45 137.07,34.45 137.43,34.81 137.43,34.84 137.46,34.87 137.46,34.94 137.93,35.41 138.16,35.41 138.18,35.42 138.68,35.42
GND on TOP (solid shape): 15.36,48.35 15.36,47.27 15.88,46.75 15.88,45.63 15.37,45.13 15.37,42.98 14.92,42.53 14.92,41.9 15.04,41.78 15.04,41.77 15.15,41.65 15.15,40.33 14.54,39.72 12.76,39.72 12.76,41.84 12.01,42.81 10.88,42.35 8.75,42.35 8.32,42.17 8.14,41.75 3.25,41.75 3.25,47.13 8.16,47.13 8.42,46.7 8.9,46.53 10.88,46.53 12.01,46.07 12.76,47.04 12.76,48.84 14.87,48.84
GND on TOP (solid shape): 138.56,65.04 138.73,65.04 138.88,64.89 138.88,62.35 138.52,62 136.67,62 136.49,61.82 136.49,59.97 136.34,59.81 136.34,58.04 135.7,57.41 133.66,57.41 132.74,58.33 132.74,59.43 132.88,59.56 133.28,59.56 133.41,59.69 133.41,59.73 133.43,59.78 133.44,59.83 133.44,60.11 133.43,60.16 133.41,60.21 133.41,60.83 133.44,60.88 133.46,60.88 134.23,61.33 134.89,61.93 134.98,61.97 135.05,61.91 135.19,61.77 135.39,61.71 135.66,61.83 135.77,62.1 135.68,62.34 135.45,62.47 135.38,62.53 135.38,62.62 135.78,63.61 135.92,64.66 135.92,64.8 135.91,64.94 135.94,65.02 136.01,65.05 138.55,65.05
GND on TOP (solid shape): 6.12,11.15 6.11,10.91 6.07,10.68 9.56,10.68 9.64,10.6 9.64,7.04 9.84,6.84 9.84,2.4 10.72,1.52 40.48,1.52 40.48,3.39 41.09,3.51 41.5,3.98 41.5,1.01 41.35,0.65 41,0.51 4,0.51 1.53,1.53 0.51,4 0.51,10.64 3.23,10.64 4.36,10.18 5.11,11.15 5.11,11.93 6.12,11.93
GND on TOP (solid shape): 12.9,88.89 12.64,88.25 12.15,87.76 12.15,83.02 11.68,82.55 10.93,82.55 10.62,82.24 10.62,81.42 9.61,81.42 9.61,83.9 8.46,85.28 6.89,84.41 2.21,84.41 2.01,84.61 2.01,87.41 0.51,87.41 0.51,88.29 0.71,88.49 4.49,88.49 4.49,88 4.7,87.5 5.2,87.29 6.6,87.29 7.1,87.5 7.31,88 7.31,88.49 11.2,88.49 11.58,88.61 11.85,88.91 11.87,88.94 12.85,88.94
GND on TOP (solid shape): 12.22,70.51 12.22,63.81 13.34,63.09 13.77,61.84 13.77,61.71 12.76,61.71 12.76,61.84 12.01,62.81 10.88,62.35 8.9,62.35 8.42,62.18 8.16,61.75 2.31,61.75 2.11,61.95 2.11,67.79 2.31,67.99 6.89,67.99 8.46,67.12 9.61,68.5 9.61,70.87 11.86,70.87
GND on TOP (solid shape): outline of 108 points within 86.66,65.31 88.7,75.79
GND on TOP (solid shape): 14.74,116.24 14.74,114.55 15.37,113.92 16.23,113.92 16.34,113.82 16.34,112.8 16.12,112.58 15.56,112.58 15.51,112.53 15.51,107.56 12.64,104.69 12.64,104.68 11.68,103.72 11.46,103.86 11.2,103.91 7.31,103.91 7.31,104.4 7.1,104.9 6.6,105.11 5.2,105.11 4.7,104.9 4.49,104.4 4.49,103.91 0.71,103.91 0.51,104.11 0.51,105.19 0.51,105.19 2.11,105.19 2.11,111.21 0.51,111.21 0.51,111.21 0.51,112.59 0.71,112.79 3.3,112.79 3.6,112.57 3.97,112.49 5.93,112.49 6.31,112.58 6.62,112.81 7.28,112.82 8.36,112.46 8.95,113.42 9.97,113.42 9.97,113.42 10.6,113.42 12.06,114.88 12.06,115.21 13.11,116.26 14.72,116.26
GND on TOP (solid shape): outline of 108 points within 15.62,23.67 22.56,29.42
GND on TOP (solid shape): outline of 130 points within 91.76,27.42 93.79,33.01
GND on TOP (solid shape): 9.46,120.89 14.49,120.89 14.49,119.4 14.79,118.69 15.5,118.39 32.66,118.39 33.37,118.69 33.67,119.4 33.67,120.65 33.67,120.66 34.68,120.66 34.68,119.4 34.09,117.97 32.66,117.38 15.5,117.38 14.07,117.97 13.48,119.4 13.48,119.88 9.97,119.88 9.87,119.26 9.57,118.72 9.57,117.9 8.56,117.9 8.56,119.14 8.69,120.54 7.29,120.39 6.62,120.39 6.31,120.62 5.93,120.71 3.97,120.71 3.6,120.63 3.3,120.41 0.71,120.41 0.51,120.61 0.51,122.39 7.96,122.39
GND on TOP (solid shape): outline of 136 points within 60.13,121.4 73.17,125.06
GND on TOP (solid shape): outline of 269 points within 0.51,18.58 15.5,29
GND on TOP (solid shape): outline of 135 points within 46.84,6.51 224.66,52.31
GND on TOP (solid shape): outline of 681 points within 75.74,98.23 96.68,122.87
GND on TOP (solid shape): outline of 135 points within 47.08,32.98 205.01,127.49
GND on BOTTOM (solid shape): 49.3,122.56 49.3,121.74 49.25,121.69 48.3,121.69 47.79,122.21 47.79,122.58 47.94,122.74 49.12,122.74
GND on BOTTOM (solid shape): 62.9,18.84 62.9,16.95 62.57,16.62 61.28,16.62 61.02,16.88 61.02,18.66 61.28,18.91 62.83,18.91
GND on BOTTOM (solid shape): 69.74,19.84 69.74,18.2 69.4,17.86 66.31,17.86 66.26,17.91 66.26,19.72 66.51,19.97 69.6,19.97
GND on BOTTOM (solid shape): 80.17,19.94 80.17,19.41 79.79,19.02 79.79,17.96 79.53,17.7 77.46,17.7 77.26,17.89 77.26,19.68 77.67,20.08 80.02,20.08
GND on BOTTOM (solid shape): 144.85,50.63 144.85,47.24 144.51,46.9 143.46,46.9 143.3,47.06 143.3,50.43 143.38,50.51 143.85,50.51 144,50.66 144.81,50.66
GND on BOTTOM (solid shape): 150.86,38.77 150.86,38.16 150.65,37.95 149.68,37.95 149.36,38.27 149.36,38.42 149.49,38.55 149.49,38.69 149.67,38.87 150.76,38.87
GND on BOTTOM (solid shape): 193.11,10.84 193.11,10.79 193.19,10.72 193.19,10.25 193.08,10.13 191.77,10.13 191.7,10.2 191.7,10.89 191.7,10.89 191.7,10.98 191.76,11.03 192.92,11.03
GND on BOTTOM (solid shape): 32.39,15.85 35.19,15.85 35.63,15.42 35.63,14.62 35.54,14.53 34.71,14.53 34.45,14.79 28.17,14.79 28.02,14.93 28.02,15.6 28.21,15.79 31.74,15.79 31.98,16.02 32.22,16.02
GND on BOTTOM (solid shape): 23.23,115.2 23.28,115.2 23.81,114.67 23.94,114.67 23.94,113.91 23.05,113.02 22.16,113.02 21.02,114.16 18.6,114.16 16.44,112 16.06,112 15.17,112.89 15.17,113.91 16.83,115.56 22.87,115.56
GND on BOTTOM (solid shape): 54.74,18.99 56.38,18.99 56.45,18.92 56.45,16.5 56.28,16.32 54.48,16.32 54.27,16.54 54.27,18.02 54.06,18.22 52.72,18.22 52.67,18.27 52.67,19.39 52.69,19.42 54.32,19.42
GND on BOTTOM (solid shape): 57.64,125.84 57.64,125.54 57.4,125.3 57.4,124.4 57.25,124.25 53.05,124.25 52.73,124.57 51.53,124.57 51.05,125.06 51.05,125.64 51.22,125.82 56.58,125.82 56.75,126 57.49,126
GND on BOTTOM (solid shape): 127.8,33.51 127.8,32.94 128.38,32.36 128.38,30.8 128.35,30.77 128.35,29.95 127.96,29.56 125.41,29.56 125.33,29.63 125.33,31.71 125.22,31.82 125.22,33.41 125.51,33.7 127.6,33.7
GND on BOTTOM (solid shape): 130.92,38.34 137.62,38.34 137.88,38.08 137.88,37.21 137.81,37.14 130.99,37.14 130.58,37.56 130.54,37.61 130.49,37.65 130.47,37.67 130.47,37.76 130.25,37.98 130.25,38.41 130.31,38.46 130.79,38.46
GND on BOTTOM (solid shape): 36,24.62 36,23.74 35.88,23.61 32.95,23.61 32.45,23.1 31.61,23.1 31.57,23.11 31.56,23.15 31.56,23.86 31.81,24.12 31.81,24.13 31.84,24.16 31.84,24.78 31.94,24.88 33.21,24.88 33.46,25.13 35.49,25.13
GND on BOTTOM (solid shape): 62.42,122.99 62.42,122.42 61.97,121.98 61.97,121.77 61.77,121.57 60.92,121.57 60.79,121.7 60.79,121.98 60.87,122.07 60.89,122.09 60.91,122.09 61.18,122.09 61.42,122.33 61.42,122.89 61.56,123.03 62.39,123.03
GND on BOTTOM (solid shape): 140.54,65.96 140.54,63.4 140.18,63.04 139.15,63.04 138.9,62.79 138.9,62.44 138.54,62.08 136.31,62.08 135.67,62.72 134.96,62.72 134.64,63.05 134.64,64.65 134.97,64.99 135.72,64.99 135.72,64.99 136.15,64.99 136.39,65.24 136.39,66.17 136.68,66.45 140.05,66.45
GND on BOTTOM (solid shape): 119.09,77.3 119.09,74.51 119.59,74 122.94,74 123.31,73.63 123.32,73.63 123.62,73.34 128.96,73.34 129.13,73.16 129.13,69.75 128.2,68.81 125.06,68.81 124.81,68.56 123.3,68.56 123.14,68.72 123.14,71.44 121.63,72.95 114.68,72.95 114.62,73.02 114.62,77.46 114.87,77.71 118.68,77.71
GND on BOTTOM (solid shape): 22.82,42.37 22.89,42.34 22.92,42.27 22.96,42.12 23.07,41.97 23.07,41.95 23.07,40.7 22.85,40.47 20.89,40.47 20.71,40.66 20.71,42.27 20.81,42.37
GND on BOTTOM (solid shape): 36,121.53 36.43,121.53 37.12,120.84 38.31,120.84 38.85,120.31 39.51,120.31 39.65,120.17 39.65,118.95 39.51,118.81 38.77,118.81 38.19,118.22 38.19,117.51 37.91,117.23 36.18,117.23 35.12,118.3 35.12,118.79 35.17,119.09 35.19,119.4 35.19,121.6 35.24,121.65 35.88,121.65
GND on BOTTOM (solid shape): 44.81,30.61 44.81,28.99 44.8,28.97 44.79,28.96 44.69,28.7 44.79,28.44 44.8,28.42 44.81,28.4 44.81,27.44 44.63,27.26 38.65,27.26 38.46,27.46 38.46,30.63 38.62,30.79 44.63,30.79
GND on BOTTOM (solid shape): 116.24,107.1 116.24,105.61 116.11,105.48 115.91,105.48 115.77,105.62 115.74,105.63 115.4,105.63 115.35,105.62 115.15,105.42 114.84,105.42 114.62,105.65 114.21,105.65 114.16,105.6 114.16,105.6 113.95,105.4 112.89,105.4 112.71,105.57 112.23,105.57 112.05,105.4 108.93,105.4 108.77,105.55 108.77,107.15 109,107.38 115.96,107.38
GND on BOTTOM (solid shape): 116.69,64.93 116.69,61.79 116.34,61.44 116.33,61.43 115.66,61.24 115.03,60.96 115.02,60.95 114.28,60.95 113.85,61.38 113.85,65.24 113.87,65.27 113.9,65.29 114.07,65.29 114.14,65.3 114.21,65.34 114.22,65.36 116.26,65.36
GND on BOTTOM (solid shape): 196.07,12.85 196.07,12.18 197.17,11.09 197.6,11.09 197.7,10.98 198.11,10.98 198.41,11.29 199.43,11.29 199.5,11.21 199.5,10.35 199.29,10.13 194.47,10.13 194.32,10.29 194.32,11.21 194.37,11.26 195.18,11.26 195.44,11.52 195.44,11.71 195.46,11.74 195.46,12.46 195.26,12.66 194.47,12.66 194.24,12.43 192.62,12.43 192.62,12.98 194.74,12.98 194.88,13.12 195.8,13.12
GND on BOTTOM (solid shape): 118.81,84.57 118.81,83.17 119.19,82.79 120.71,82.79 120.97,83.04 121.85,83.04 121.99,82.91 121.99,81.72 121.8,81.53 121.8,81.52 115.16,81.52 114.99,81.69 114.99,82.3 115.09,82.41 116.01,82.41 116.01,82.41 116.84,82.41 117.16,82.72 117.16,83.69 117.05,83.81 116.9,83.81 116.65,84.06 116.65,84.44 116.77,84.57 117.54,84.57 117.79,84.82 118.55,84.82
GND on BOTTOM (solid shape): 21.05,49.39 21.05,48.05 20.48,47.48 19.85,47.48 19.7,47.46 19.58,47.37 18.64,46.43 18.58,46.36 18.54,46.27 18.54,46.26 18.51,46.24 16.1,46.24 15.93,46.41 15.93,48.77 16.01,48.81 16.08,48.87 16.1,48.88 16.12,48.88 18.25,48.88 18.91,49.55 20.89,49.55
GND on BOTTOM (solid shape): 153.52,29.08 153.52,28.7 153.67,28.54 153.76,28.54 153.8,28.53 153.83,28.53 154.11,28.53 154.14,28.53 154.17,28.54 155.17,28.54 155.17,27.89 154.6,27.89 154.31,28.19 153.76,28.19 153.67,28.11 153.64,28.07 153.55,27.98 153.55,27.67 153.38,27.51 152.92,27.51 152.3,28.13 152.3,29.2 152.35,29.25 153.35,29.25
GND on BOTTOM (solid shape): 125.41,48.63 125.41,45.83 124.39,44.82 124.39,43.18 124.01,42.79 120.72,42.79 120.46,43.06 120.46,45.79 120.89,46.22 120.93,46.22 120.97,46.21 121.24,46.33 121.35,46.6 121.32,46.75 121.23,46.87 121.23,48.51 121.73,49.01 125.03,49.01
GND on BOTTOM (solid shape): 157.63,25.78 157.63,22.58 157.57,22.52 155.53,22.52 155.45,22.55 155.43,22.64 155.43,22.68 155.43,22.72 155.32,22.99 155.05,23.1 155.01,23.1 154.97,23.09 154.82,23.09 154.16,23.74 154.16,25.04 155.03,25.9 157.52,25.9
GND on BOTTOM (solid shape): 156.67,29.22 156.73,29.2 156.81,29.2 156.88,29.2 156.95,29.22 157.39,29.22 157.44,29.18 157.44,29.16 157.46,29.11 157.49,29.08 157.5,29.07 157.53,29.03 157.53,28.6 157.5,28.56 157.49,28.55 157.45,28.51 157.44,28.45 157.44,27.91 157.44,27.87 156.99,27.42 156.52,27.42 156.36,27.58 156.36,29.16 156.43,29.22 156.65,29.22
GND on BOTTOM (solid shape): 102.55,99.91 102.55,99.49 102.54,99.48 102.51,99.39 102.5,99.3 102.5,99.29 102.5,99.27 102.46,99.23 102.46,98.17 102.52,98.11 102.55,98.05 102.59,98.01 102.6,98 102.6,97.98 102.6,97.62 102.47,97.5 102.12,97.5 102.02,97.6 102.02,97.95 101.62,98.35 101.61,98.37 101.61,99.18 101.62,99.19 101.65,99.25 101.66,99.35 101.99,99.68 101.99,99.79 102,99.85 102.14,99.99 102.47,99.99
GND on BOTTOM (solid shape): 48.02,22.72 48.02,22.11 48.22,21.9 49.39,21.9 49.54,21.75 49.54,20.61 49.77,20.38 50.13,20.38 50.2,20.31 50.2,19.49 50.1,19.39 48.83,19.39 48.78,19.44 48.78,20.79 48.42,21.14 48.03,21.14 48.02,21.14 46.56,21.14 46.47,21.05 46.47,20.06 46.58,19.95 47.62,19.95 48.05,19.51 48.05,19.14 48,19.09 46.67,19.09 46.37,19.39 43.62,19.39 43.62,20.39 43.36,20.66 43.36,21.11 43.44,21.2 43.44,21.6 43.63,21.79 44.33,21.79 44.68,22.14 44.68,22.61 44.81,22.74 48,22.74
GND on BOTTOM (solid shape): 140.57,43.12 140.58,43.11 141.4,43.11 141.42,43.1 141.42,40.3 141.95,39.77 141.95,38.38 140.71,37.13 139.67,37.13 139.59,37.21 139.59,40.42 138.87,41.14 138.87,41.61 141.36,41.61 141.36,41.86 140.58,41.86 140.58,41.61 138.87,41.61 138.87,42.11 141.36,42.11 141.36,42.36 140.58,42.36 140.58,42.11 138.87,42.11 138.87,42.35 139.14,42.61 141.36,42.61 141.36,42.86 140.58,42.86 140.58,42.61 139.14,42.61 139.14,42.62 139.14,43.11 139.24,43.2 140.49,43.2
GND on BOTTOM (solid shape): 146.48,69.13 146.48,68.85 146.18,68.55 146.18,68.02 146.1,67.94 146.09,67.94 146.09,67.11 146.08,67.09 143.28,67.09 142.78,66.6 141.24,66.6 141.21,66.62 141.21,67.15 145.84,67.15 145.84,67.94 145.59,67.94 145.59,67.15 145.34,67.15 145.34,67.94 145.09,67.94 145.09,67.15 144.84,67.15 144.84,67.94 144.59,67.94 144.59,67.15 141.21,67.15 141.21,67.45 141.57,67.81 141.57,67.81 141.65,67.89 142.17,67.89 142.36,68.08 142.36,69.21 142.42,69.27 146.34,69.27
GND on BOTTOM (solid shape): 136.16,61.61 136.16,57.45 137.08,56.52 138.03,56.52 138.1,56.45 138.1,55.66 139.29,54.47 139.29,49.62 140.09,48.83 140.09,47.68 139.88,47.47 138.36,47.47 137.83,47.99 137.83,48.71 137.7,48.85 136.98,48.85 136.76,49.07 136.76,49.22 136.74,49.22 136.58,49.38 136.58,53.16 136.85,53.43 137.31,53.43 137.48,53.6 137.48,54.37 137.3,54.55 136.15,54.55 135.62,55.08 135.49,55.08 135.42,55.09 135.35,55.08 132.91,55.08 132.81,55.18 132.81,56.62 133.43,57.24 133.43,60.57 133.63,60.77 134.2,60.77 134.62,61.19 134.62,61.67 134.62,61.67 136.1,61.67
GND on BOTTOM (solid shape): 212.5,32.64 212.5,32.26 212.44,32.26 212.31,32.23 212.19,32.15 212.12,32.09 212.07,32.06 211.93,31.92 211.87,31.74 211.93,31.55 212.07,31.42 212.12,31.39 212.28,31.23 212.28,30.96 211.91,30.59 210.12,30.59 210.11,30.58 209.96,30.58 209.92,30.63 209.92,31.84 209.94,31.87 210.18,31.87 210.19,31.88 211.13,31.88 212.03,32.78 212.36,32.78
GND on BOTTOM (solid shape): 48.02,11.17 48.02,8.96 47.46,8.41 42.02,8.41 41.08,7.48 38.99,7.48 38.72,7.74 37.08,7.74 36.69,7.74 36.55,7.75 36.54,7.76 36.53,8.01 36.69,8.18 38.89,8.18 39.18,8.46 39.18,8.83 39.2,8.85 39.7,8.85 39.7,10.4 39.5,10.4 39.5,8.85 39.2,8.85 39.2,9.37 39.21,9.39 39.24,9.44 39.26,9.49 39.27,9.54 39.28,9.6 39.28,9.63 39.28,10.58 39.29,10.67 40.04,11.41 47.77,11.41
GND on BOTTOM (solid shape): 46.25,97.78 46.25,95.12 46,94.87 39.32,94.87 38.34,95.85 38.34,96.76 39.18,96.76 39.18,96.7 39.19,96.65 39.21,96.6 39.24,96.55 39.27,96.51 39.31,96.47 39.36,96.43 39.41,96.41 39.46,96.39 39.52,96.38 39.57,96.38 39.63,96.38 39.68,96.4 39.73,96.42 39.78,96.45 39.82,96.49 39.86,96.53 39.89,96.57 39.92,96.62 39.93,96.68 39.94,96.73 39.94,96.79 39.93,96.84 39.92,96.9 39.89,96.95 39.86,96.99 39.82,97.04 39.78,97.07 39.73,97.1 39.68,97.12 39.63,97.14 39.57,97.14 39.52,97.14 39.46,97.13 39.41,97.11 39.36,97.09 39.31,97.05 39.27,97.01 39.24,96.97 39.21,96.92 39.19,96.87 39.18,96.82 39.18,96.76 38.34,96.76 38.34,97.08 38.67,97.42 38.68,97.42 39.61,98.35 40.07,98.35 40.1,98.38 45.65,98.38
GND on BOTTOM (solid shape): 179.28,16.37 180.02,16.37 180.26,16.13 180.26,15.22 180.2,15.15 179.59,15.15 179.11,14.67 179.11,14.12 178.65,13.66 175.05,13.66 174.39,14.31 174.39,14.81 174.56,14.98 174.59,14.98 174.64,14.97 174.69,14.97 174.96,15.62 174.31,15.35 174.31,15.31 174.32,15.25 174.31,15.23 174.14,15.05 173.82,15.05 173.68,15.19 173.68,15.91 174.05,16.28 175.65,16.28 176.39,17.03 178.62,17.03
GND on BOTTOM (solid shape): 110.1,23.76 110.1,22.71 110.35,22.47 111.97,22.47 112.08,22.36 112.08,21.45 109.54,18.91 105.09,18.91 104.96,19.04 104.96,20.17 105.34,20.55 105.73,20.55 105.9,20.71 105.9,21.21 106.62,21.93 106.62,22.01 106.66,22.09 106.75,22.1 106.81,22.09 106.87,22.08 107.25,22.47 106.87,22.85 106.73,22.82 106.62,22.75 106.58,22.74 106.55,22.75 106.44,22.86 105.56,22.86 105.5,22.92 105.5,23.32 105.57,23.39 108.16,23.39 108.6,23.82 110.03,23.82
GND on BOTTOM (solid shape): 152.73,38.79 154.53,37.13 156.79,36.15 157.26,36.04 157.74,35.96 157.75,35.95 157.9,35.81 159.16,35.81 159.29,35.67 159.29,35.09 159.22,35.01 158.89,35.01 158.68,34.81 158.68,34.25 158.58,34.15 158.38,34.15 158.23,34.3 158.23,34.94 158.2,34.96 157.9,34.96 157.9,34.96 157.11,34.96 156.9,35.17 156.33,35.17 155.99,35.51 155.27,35.51 154.9,35.88 154.22,35.88 152.97,37.12 152.97,37.14 152.97,37.2 152.88,37.44 152.66,37.57 152.42,37.81 151.47,37.81 151.33,37.95 151.33,38.79 151.42,38.89 152.66,38.89
GND on BOTTOM (solid shape): 124.04,115.73 124.04,114.88 123.38,114.22 123.37,114.21 123.35,114.21 122.89,114.21 122.56,113.87 122.54,113.87 122.43,113.8 122.36,113.68 122.36,113.67 122.11,113.42 122.11,113.3 122.1,113.28 122.09,113.26 122,113.07 122.09,112.88 122.1,112.87 122.11,112.84 122.11,112.18 121.75,111.82 121.54,111.82 121.41,111.95 121.41,112.27 121.42,112.36 121.41,112.44 121.41,112.57 121.56,112.71 121.56,113.1 121.63,113.18 121.68,113.23 121.74,113.29 121.74,113.34 121.76,113.46 121.74,113.58 121.74,113.68 122.27,114.21 122.27,114.46 122.49,114.68 122.49,115.12 122.87,115.51 122.87,115.7 123.03,115.86 123.05,115.87 123.07,115.88 123.9,115.88
GND on BOTTOM (solid shape): 146.9,55.86 150.3,55.86 150.43,55.72 150.43,55.31 150.17,55.05 149.14,55.05 149.04,54.95 149.01,54.95 148.85,54.88 148.79,54.72 148.79,54.42 148.79,54.37 148.81,54.32 148.83,54.29 148.62,54.07 148.24,54.07 148.16,53.99 148.11,53.99 147.95,53.92 147.89,53.76 147.89,53.46 147.93,53.33 148.05,53.24 148.07,53.24 148.17,53.14 148.35,53.14 148.35,52.68 148.35,52.59 148.39,52.5 148.48,52.46 148.68,52.46 148.73,52.47 148.77,52.5 148.8,52.53 149.12,52.21 149.12,51.69 148.87,51.44 148.68,51.44 148.65,51.41 148.64,51.41 148.59,51.38 148.56,51.33 148.55,51.31 148.53,51.29 148.53,50.96 148.43,50.86 148.07,50.86 147.76,51.17 147.76,52.01 147.61,52.16 146.32,52.16 146.15,51.99 146.15,51.72 145.91,51.48 145.07,51.48 144.65,51.91 144.65,55.41 144.57,55.49 144.57,55.95 144.59,55.97 146.79,55.97
GND on BOTTOM (solid shape): 106.61,125.84 106.61,125.34 106.23,124.95 106.23,124.85 106.23,124.58 106.23,124.54 106.23,124.34 106.23,124.34 106.23,124.2 106.23,123.93 106.23,123.88 106.23,123.59 106.23,123.55 106.23,123.28 106.27,123.19 106.36,123.15 106.39,123.15 106.61,122.92 106.61,121.77 106.4,121.56 106.3,121.56 106.22,121.55 106.14,121.53 106.11,121.53 106.07,121.48 106.06,121.48 105.96,121.41 105.89,121.32 105.89,121.31 105.73,121.14 105.6,121.14 105.57,121.17 105.57,121.81 105.97,122.2 105.97,122.97 106,123.01 106,123.05 106,124.24 105.96,124.33 105.87,124.37 104.47,124.37 104.44,124.39 104.44,124.41 104.39,124.53 104.31,124.63 103.8,125.14 103.8,125.84 103.8,125.86 103.83,125.93 103.9,125.97 106.49,125.97
GND on BOTTOM (solid shape): 22.8,26.3 22.83,26.29 22.85,26.26 22.88,26.16 22.94,26.08 22.96,26.01 22.94,25.94 22.87,25.82 22.85,25.69 22.96,25.42 23.23,25.31 23.36,25.33 23.48,25.4 23.54,25.43 23.61,25.4 23.73,25.33 23.86,25.31 24.13,25.42 24.24,25.69 24.22,25.82 24.15,25.94 24.12,26.01 24.15,26.08 24.21,26.16 24.24,26.26 24.25,26.29 24.29,26.3 24.32,26.3 24.88,25.73 24.88,24.16 24.83,24.11 19.31,24.11 19.04,24.39 19.04,25.08 19.19,25.24 21.08,25.24 21.38,25.53 21.38,26.04 21.64,26.3
GND on BOTTOM (solid shape): 217.51,30.27 217.51,25.95 217.47,25.88 217.39,25.85 215.01,25.48 213.27,23.8 213.26,23.78 213.23,23.78 213.03,23.78 212.92,23.84 212.79,23.86 212.67,23.84 212.56,23.79 212.54,23.78 212.5,23.78 212.45,23.82 212.45,23.83 212.4,23.9 212.33,23.93 211.79,23.93 211.71,23.9 211.67,23.82 211.67,23.8 211.64,23.78 211.46,23.78 211.38,23.7 211.38,22.51 211.37,22.48 211.33,22.46 210.87,22.46 210.84,22.49 210.84,23.66 211.3,24.13 211.31,24.13 211.55,24.36 211.55,25.12 211.62,25.19 212.23,25.19 212.76,25.72 212.76,27.24 213.05,27.53 215.77,27.53 215.95,27.71 215.95,30.43 216.07,30.55 217.23,30.55
GND on BOTTOM (solid shape): 102.05,125.97 102.12,125.93 102.15,125.86 102.15,125.84 102.15,124.65 102.19,124.56 102.28,124.52 102.98,124.52 103.44,124.06 103.44,123.12 103.09,122.77 102.98,122.61 102.94,122.41 102.94,122.37 102.95,122.29 102.8,122.14 102.78,122.15 102.73,122.16 102.68,122.16 102.6,122.15 102.53,122.13 102.45,122.13 102.39,122.18 102.36,122.24 102.32,122.3 102.29,122.36 102.32,122.43 102.38,122.54 102.4,122.67 102.29,122.94 102.02,123.05 101.97,123.05 101.92,123.04 101.83,123.06 101.79,123.14 101.8,123.22 101.8,123.31 101.7,124.22 101.41,125.08 101.41,125.09 101.41,125.72 101.66,125.97
GND on BOTTOM (solid shape): 105.14,94.37 105.19,94.31 105.25,94.26 105.56,93.95 105.56,93.74 105.48,93.65 105.03,93.65 104.86,93.72 104.69,93.67 104.68,93.65 104.65,93.65 104.65,93.65 103.95,93.65 103.94,93.65 103.92,93.66 103.75,93.72 103.59,93.66 103.57,93.65 103.55,93.65 102.85,93.65 102.84,93.65 102.73,93.71 102.62,93.72 102.51,93.68 102.43,93.6 102.43,93.59 102.3,93.46 101.99,93.46 101.61,93.08 101.61,92.9 101.51,92.8 101.51,92.31 101.39,92.19 100.04,92.19 99.92,92.31 99.92,92.51 100.63,93.22 101.14,93.22 101.52,93.6 101.62,93.69 101.66,93.83 101.71,93.89 101.76,93.97 101.78,93.98 101.8,93.99 102.39,93.99 102.5,93.92 102.63,93.89 102.78,93.91 102.9,93.99 103.54,93.99 103.72,93.94 103.9,93.99 104.35,93.99 104.81,94.45 105.07,94.45
GND on BOTTOM (solid shape): outline of 108 points within 108.72,101.43 116.22,103.52
GND on BOTTOM (solid shape): 106.93,84.13 106.96,84.11 106.98,84.08 107.02,83.94 107.12,83.82 107.13,83.78 107.13,83.12 107.11,83.09 106.99,83.15 106.87,83.17 106.6,83.06 106.49,82.79 106.51,82.66 106.57,82.55 106.35,82.33 105.74,82.33 105.7,82.38 105.7,82.53 105.71,82.6 105.67,82.87 105.55,83.04 105.48,83.11 105.45,83.11 105.44,83.12 105.33,83.16 105.21,83.17 105.09,83.16 104.98,83.12 104.97,83.11 104.93,83.11 104.81,83 104.81,82.99 104.8,82.97 104.71,82.82 104.68,82.65 104.68,82.1 104.67,82.07 104.63,82.05 104.04,82.05 103.99,82.1 103.82,82.1 103.81,82.14 103.81,82.18 103.82,82.23 103.82,82.28 103.78,82.45 103.67,82.59 103.63,82.64 103.64,82.71 103.65,82.74 103.65,82.76 103.65,83.32 103.62,83.41 103.53,83.45 103.27,83.45 103.23,83.47 103.22,83.5 103.22,84.02 103.33,84.13
GND on BOTTOM (solid shape): outline of 131 points within 139.44,27.84 145.72,32.76
GND on BOTTOM (solid shape): 6.89,67.99 8.14,67.09 9.46,67.88 10.54,67.88 8.71,66.13 6.31,66.98 3.12,66.98 3.12,62.76 7.57,62.76 8.17,63.21 8.9,63.36 10.42,63.36 12.59,63.68 13.77,61.84 13.77,61.71 12.76,61.71 12.76,61.84 12.01,62.81 10.88,62.35 8.9,62.35 8.44,62.19 8.17,61.79 8.16,61.75 2.31,61.75 2.11,61.95 2.11,67.79 2.31,67.99
GND on BOTTOM (solid shape): 12.89,88.86 12.29,87.87 11.2,87.48 8.24,87.48 7.62,86.61 6.6,86.28 5.2,86.28 4.18,86.61 3.56,87.48 3.02,87.48 3.02,85.86 3.46,85.42 6.31,85.42 8.63,86.29 10.5,84.67 10.43,84.6 9.42,84.6 8.09,85.3 6.89,84.41 2.21,84.41 2.01,84.61 2.01,87.41 0.51,87.41 0.51,88.29 0.71,88.49 4.49,88.49 4.49,88 4.7,87.5 5.2,87.29 6.6,87.29 7.1,87.5 7.31,88 7.31,88.49 11.2,88.49 11.64,88.65 11.89,89.04 12.71,89.04
GND on BOTTOM (solid shape): 13.77,47.04 12.59,45.2 10.42,45.52 8.9,45.52 8.17,45.67 7.57,46.12 4.26,46.12 4.26,42.76 7.49,42.76 8.05,43.21 8.75,43.36 10.42,43.36 12.59,43.68 13.77,41.84 12.76,41.84 12.01,42.81 10.88,42.35 8.75,42.35 8.34,42.19 8.14,41.79 8.14,41.75 3.25,41.75 3.25,47.13 8.16,47.13 8.17,47.09 8.44,46.69 8.9,46.53 10.88,46.53 12.01,46.07 12.76,47.04 12.76,47.16 13.77,47.16
GND on BOTTOM (solid shape): 9.13,111.72 6.92,111.75 6.44,111.55 5.93,111.48 5.65,111.48 5.65,106.12 6.6,106.12 7.62,105.79 8.24,104.92 11.2,104.92 11.74,104.84 12.22,104.59 12.22,104.22 11.7,103.7 11.47,103.85 11.2,103.91 7.31,103.91 7.31,104.4 7.1,104.9 6.6,105.11 5.2,105.11 4.7,104.9 4.49,104.4 4.49,103.91 0.71,103.91 0.51,104.11 0.51,105.19 0.51,105.19 2.11,105.19 2.11,111.21 0.51,111.21 0.51,111.21 0.51,112.59 0.71,112.79 3.3,112.79 3.6,112.57 3.97,112.49 5.93,112.49 6.3,112.57 6.61,112.8 6.62,112.81 7.28,112.82 7.3,112.8 8.47,112.51 8.9,113.64 8.91,113.73 8.99,113.78 9.86,113.78 9.92,113.78
GND on BOTTOM (solid shape): outline of 285 points within 69.23,89.42 87.82,118.8
GND on BOTTOM (solid shape): outline of 323 points within 99.5,110.1 102.42,112.94
GND on BOTTOM (solid shape): outline of 345 points within 103.03,101.31 106.64,107.22
GND on BOTTOM (solid shape): outline of 499 points within 59.59,58.41 69.56,82.79
GND on BOTTOM (solid shape): outline of 150 points within 0.51,0.51 41.5,27.13
GND on BOTTOM (solid shape): outline of 656 points within 40.51,4.87 224.66,52.31
GND on BOTTOM (solid shape): outline of 180 points within 0.51,31.66 205.05,127.49
GND on SGND (solid shape): outline of 2745 points within 0.51,0.51 224.66,127.49
GND on IN1 (solid shape): 105.93,125.97 105.97,125.95 105.98,125.92 105.98,125.65 105.93,125.46 105.98,125.28 105.98,123 105.77,122.8 102.37,122.8 102.34,122.81 102.34,122.82 102.28,122.91 102.2,122.98 102.18,123 102.17,123.02 102.17,123.76 101.31,124.62 101.31,125.67 101.61,125.97
GND on IN1 (solid shape): 108.27,41.35 108.98,41.35 109.26,41.07 109.26,37.32 109.11,37.19 109.05,36.99 109.11,36.8 109.26,36.67 109.26,34.36 108.37,33.47 108.37,32.86 108.27,32.75 105.44,32.75 105.39,32.8 105.39,35.12 106.07,35.8 106.61,35.8 107.07,36.26 107.07,41.06 107.37,41.36 108.26,41.36
GND on IN1 (solid shape): 12.67,69.57 12.67,65.18 15.32,62.53 15.32,61.71 12.76,61.71 12.76,61.84 12.01,62.81 10.88,62.35 8.9,62.35 8.42,62.18 8.16,61.75 2.31,61.75 2.11,61.95 2.11,67.79 2.31,67.99 6.89,67.99 8.46,67.12 9.61,68.5 9.61,69.86 12.37,69.86
GND on IN1 (solid shape): 12.92,88.89 12.92,88.23 13.28,87.87 13.28,83.71 11.97,82.4 9.61,82.4 9.61,83.9 8.46,85.28 6.89,84.41 2.21,84.41 2.01,84.61 2.01,87.41 0.51,87.41 0.51,88.29 0.71,88.49 4.49,88.49 4.49,88 4.7,87.5 5.2,87.29 6.6,87.29 7.1,87.5 7.31,88 7.31,88.49 11.2,88.49 11.62,88.63 11.88,88.99 12.82,88.99
GND on IN1 (solid shape): 16.57,49.14 16.57,45.75 16.28,45.45 16.28,40.98 14.75,39.46 12.76,39.46 12.76,41.84 12.01,42.81 10.88,42.35 8.75,42.35 8.32,42.17 8.14,41.75 3.25,41.75 3.25,47.13 8.16,47.13 8.42,46.7 8.9,46.53 10.88,46.53 12.01,46.07 12.76,47.04 12.76,49.05 15.17,49.05 15.64,49.52 16.19,49.52
GND on IN1 (solid shape): 6.12,11.15 6.11,10.92 6.07,10.7 10.12,6.65 10.12,2.36 10.96,1.52 40.48,1.52 40.48,3.39 41.09,3.51 41.5,3.98 41.5,1.01 41.35,0.65 41,0.51 4,0.51 1.53,1.53 0.51,4 0.51,10.64 3.23,10.64 4.36,10.18 5.11,11.15 5.11,11.93 6.12,11.93
GND on IN1 (solid shape): 9.96,113.55 9.03,111.65 6.92,111.75 6.44,111.55 5.93,111.48 3.97,111.48 3.54,111.53 3.12,111.67 3.12,104.92 3.56,104.92 4.18,105.79 5.2,106.12 6.6,106.12 7.62,105.79 8.24,104.92 11.2,104.92 11.67,104.86 12.11,104.67 12.11,104.24 11.63,103.76 11.43,103.87 11.2,103.91 7.31,103.91 7.31,104.4 7.1,104.9 6.6,105.11 5.2,105.11 4.7,104.9 4.49,104.4 4.49,103.91 0.71,103.91 0.51,104.11 0.51,105.19 0.51,105.19 2.11,105.19 2.11,111.21 0.51,111.21 0.51,111.21 0.51,112.59 0.71,112.79 3.3,112.79 3.6,112.57 3.97,112.49 5.93,112.49 6.31,112.58 6.62,112.81 7.28,112.82 8.42,112.48 8.93,113.55
GND on IN1 (solid shape): 12.97,27.3 13.05,27.29 13.72,27.29 13.76,27.28 13.77,27.24 13.77,27.04 13.47,25.97 12.63,25.22 12.26,25.08 11.87,25.02 11.47,25.04 11.08,25.13 10.73,25.29 10.42,25.52 8.75,25.52 8.05,25.67 7.49,26.12 1.97,26.12 2.61,25.53 3.01,24.76 3.04,24.65 2.91,24.34 2.87,24 2.91,23.66 3.04,23.35 2.77,22.71 2.34,22.17 2.77,22.17 3.37,22.54 4.06,22.67 4.16,22.67 4.26,22.67 4.9,22.51 5.45,22.16 5.61,22 5.99,21.37 6.12,20.65 6.12,19.82 6.11,19.79 5.8,19.63 5.69,19.34 5.69,18.95 5.65,18.91 5.24,18.91 5.11,19.04 5.11,20.65 4.38,21.62 3.24,21.18 3.23,21.16 3.2,21.16 0.56,21.16 0.52,21.17 0.51,21.21 0.51,22.44 0.52,22.48 0.56,22.49 0.6,22.49 2.11,24 0.6,25.51 0.56,25.51 0.52,25.52 0.51,25.56 0.51,27.08 0.52,27.12 0.56,27.13 8.11,27.13 8.14,27.11 8.14,27.09 8.34,26.69 8.75,26.53 10.85,26.53 10.88,26.53 10.89,26.51 12.03,26.07 12.76,27.04 12.76,27.21 12.8,27.29 12.88,27.31
GND on IN1 (solid shape): outline of 112 points within 40.5,4.72 224.66,52.31
GND on IN1 (solid shape): outline of 184 points within 0.51,32.96 205.04,127.49
GND on IN2 (solid shape): 108.82,35.8 108.82,32.75 105.19,32.75 105.19,35.8 106.81,35.8 107.45,36.44 108.18,36.44
GND on IN2 (solid shape): 105.93,125.97 105.97,125.95 105.98,125.92 105.98,125.65 105.93,125.46 105.98,125.28 105.98,122.85 105.97,122.81 105.93,122.8 102.37,122.8 102.34,122.81 102.34,122.82 102.28,122.91 102.2,122.98 102.18,123 102.17,123.02 102.17,123.93 101.33,124.77 101.33,125.44 101.86,125.97
GND on IN2 (solid shape): 6.12,11.83 6.12,11.15 6.09,10.79 6,10.45 10.32,6.13 10.32,2.17 10.97,1.52 40.42,1.52 40.48,1.53 40.48,3.39 41.09,3.51 41.5,3.98 41.5,1.01 41.35,0.65 41,0.51 4,0.51 1.53,1.53 0.51,4 0.51,10.64 3.23,10.64 4.36,10.18 5.11,11.15 5.11,12.05 5.9,12.05
GND on IN2 (solid shape): 6.89,67.99 8.1,67.1 9.43,67.82 9.45,67.8 10.09,67.8 10.37,67.53 10.37,67.41 8.46,66.09 6.31,66.98 3.12,66.98 3.12,62.76 7.57,62.76 8.17,63.21 8.9,63.36 10.42,63.36 12.54,63.7 13.77,61.95 13.74,61.87 13.67,61.84 12.76,61.84 12.76,61.89 11.99,62.82 10.88,62.35 8.9,62.35 8.44,62.19 8.17,61.79 8.16,61.75 2.31,61.75 2.11,61.95 2.11,67.79 2.31,67.99
GND on IN2 (solid shape): 8.17,47.09 8.44,46.69 8.9,46.53 10.88,46.53 12.01,46.07 12.76,47.04 12.76,47.1 13.77,47.1 13.77,47.04 12.59,45.2 10.42,45.52 8.9,45.52 8.17,45.67 7.57,46.12 4.26,46.12 4.26,42.76 7.49,42.76 8.05,43.21 8.75,43.36 10.42,43.36 12.56,43.69 13.77,41.89 13.72,41.84 12.76,41.84 12.01,42.81 10.88,42.35 8.75,42.35 8.34,42.19 8.14,41.79 8.14,41.75 3.25,41.75 3.25,47.13 8.16,47.13
GND on IN2 (solid shape): 12.9,88.94 12.32,87.89 11.2,87.48 8.24,87.48 7.62,86.61 6.6,86.28 5.2,86.28 4.18,86.61 3.56,87.48 3.02,87.48 3.02,86.17 3.77,85.42 6.31,85.42 9.01,86.19 10.62,83.9 10.62,81.41 10.6,81.39 9.61,81.39 9.61,83.9 8.46,85.28 6.89,84.41 2.21,84.41 2.01,84.61 2.01,87.41 0.51,87.41 0.51,88.29 0.71,88.49 4.49,88.49 4.49,88 4.7,87.5 5.2,87.29 6.6,87.29 7.1,87.5 7.31,88 7.31,88.49 11.2,88.49 11.63,88.64 11.88,89.01 12.83,89.01
GND on IN2 (solid shape): 9.14,111.72 6.92,111.75 6.44,111.55 5.93,111.48 3.97,111.48 3.54,111.53 3.12,111.67 3.12,104.92 3.56,104.92 4.18,105.79 5.2,106.12 6.6,106.12 7.62,105.79 8.24,104.92 11.2,104.92 11.67,104.86 12.1,104.67 12.1,104.25 11.62,103.77 11.42,103.87 11.2,103.91 7.31,103.91 7.31,104.4 7.1,104.9 6.6,105.11 5.2,105.11 4.7,104.9 4.49,104.4 4.49,103.91 0.71,103.91 0.51,104.11 0.51,105.19 0.51,105.19 2.11,105.19 2.11,111.21 0.51,111.21 0.51,111.21 0.51,112.59 0.71,112.79 3.3,112.79 3.6,112.57 3.97,112.49 5.93,112.49 6.3,112.57 6.61,112.8 6.62,112.81 7.28,112.82 7.3,112.8 8.48,112.51 8.89,113.66 8.9,113.76 8.98,113.8 9.86,113.8 9.91,113.8
GND on IN2 (solid shape): 8.14,27.09 8.34,26.69 8.75,26.53 10.88,26.53 11.99,26.06 12.76,26.99 12.76,27.04 13.67,27.04 13.74,27.01 13.77,26.93 12.54,25.18 10.42,25.52 8.75,25.52 8.05,25.67 7.49,26.12 1.98,26.12 2.64,25.48 3.04,24.65 2.91,24.34 2.87,24.01 2.87,23.99 2.91,23.66 3.04,23.35 2.77,22.71 2.34,22.17 2.77,22.17 3.37,22.54 4.06,22.67 4.13,22.67 4.26,22.67 5.59,22.02 6.12,20.65 6.12,19.93 6,19.8 5.23,19.8 5.11,19.93 5.11,20.65 4.36,21.62 3.23,21.16 0.51,21.16 0.51,22.49 0.6,22.49 2.11,24 0.6,25.51 0.51,25.51 0.51,27.13 8.14,27.13
GND on IN2 (solid shape): outline of 107 points within 40.5,4.72 224.66,52.31
GND on IN2 (solid shape): outline of 171 points within 0.51,32.93 205.04,127.49
GND on IN2 (solid shape): outline of 1185 points within 91.37,99.17 104.58,115.43
GND on IN2 (solid shape): outline of 12052 points within 108.96,79.22 148.63,119.49
GND on IN2 (solid shape): outline of 14591 points within 27.91,26.34 91.06,97.96
GND on SVCC (solid shape): outline of 137 points within 200.6,15.48 223.14,50.79
